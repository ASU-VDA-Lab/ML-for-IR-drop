R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_403200_0 n1_m1_408000_0 5.356235
R98 n1_m1_408000_0 n1_m1_412800_0 5.356235
R99 n1_m1_412800_0 n1_m1_417600_0 5.356235
R100 n1_m1_417600_0 n1_m1_422400_0 5.356235
R101 n1_m1_422400_0 n1_m1_424000_0 1.785412
R102 n1_m1_427200_0 n1_m1_424000_0 3.570824
R103 n1_m1_427200_0 n1_m1_432000_0 5.356235
R104 n1_m1_432000_0 n1_m1_436800_0 5.356235
R105 n1_m1_436800_0 n1_m1_441600_0 5.356235
R106 n1_m1_441600_0 n1_m1_446400_0 5.356235
R107 n1_m1_446400_0 n1_m1_451200_0 5.356235
R108 n1_m1_451200_0 n1_m1_452000_0 0.892706
R109 n1_m1_456000_0 n1_m1_452000_0 4.463529
R110 n1_m1_456000_0 n1_m1_460800_0 5.356235
R111 n1_m1_460800_0 n1_m1_465600_0 5.356235
R112 n1_m1_465600_0 n1_m1_470400_0 5.356235
R113 n1_m1_470400_0 n1_m1_475200_0 5.356235
R114 n1_m1_475200_0 n1_m1_480000_0 5.356235
R115 n1_m1_480000_0 n1_m1_484800_0 5.356235
R116 n1_m1_484800_0 n1_m1_489600_0 5.356235
R117 n1_m1_489600_0 n1_m1_494400_0 5.356235
R118 n1_m1_494400_0 n1_m1_499200_0 5.356235
R119 n1_m1_499200_0 n1_m1_504000_0 5.356235
R120 n1_m1_504000_0 n1_m1_508000_0 4.463529
R121 n1_m1_508800_0 n1_m1_508000_0 0.892706
R122 n1_m1_508800_0 n1_m1_513600_0 5.356235
R123 n1_m1_513600_0 n1_m1_518400_0 5.356235
R124 n1_m1_518400_0 n1_m1_523200_0 5.356235
R125 n1_m1_523200_0 n1_m1_528000_0 5.356235
R126 n1_m1_528000_0 n1_m1_532800_0 5.356235
R127 n1_m1_532800_0 n1_m1_536000_0 3.570824
R128 n1_m1_537600_0 n1_m1_536000_0 1.785412
R129 n1_m1_537600_0 n1_m1_542400_0 5.356235
R130 n1_m1_542400_0 n1_m1_547200_0 5.356235
R131 n1_m1_547200_0 n1_m1_552000_0 5.356235
R132 n1_m1_552000_0 n1_m1_556800_0 5.356235
R133 n1_m1_556800_0 n1_m1_561600_0 5.356235
R134 n1_m1_561600_0 n1_m1_564000_0 2.678118
R135 n1_m1_566400_0 n1_m1_564000_0 2.678118
R136 n1_m1_566400_0 n1_m1_571200_0 5.356235
R137 n1_m1_571200_0 n1_m1_576000_0 5.356235
R138 n1_m1_576000_0 n1_m1_580800_0 5.356235
R139 n1_m1_580800_0 n1_m1_585600_0 5.356235
R140 n1_m1_585600_0 n1_m1_590400_0 5.356235
R141 n1_m1_590400_0 n1_m1_592000_0 1.785412
R142 n1_m1_595200_0 n1_m1_592000_0 3.570824
R143 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R144 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R145 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R146 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R147 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R148 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R149 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R150 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R151 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R152 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R153 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R154 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R155 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R156 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R157 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R158 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R159 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R160 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R161 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R162 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R163 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R164 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R165 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R166 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R167 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R168 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R169 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R170 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R171 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R172 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R173 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R174 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R175 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R176 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R177 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R178 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R179 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R180 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R181 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R182 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R183 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R184 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R185 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R186 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R187 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R188 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R189 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R190 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R191 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R192 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R193 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R194 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R195 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R196 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R197 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R198 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R199 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R200 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R201 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R202 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R203 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R204 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R205 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R206 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R207 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R208 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R209 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R210 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R211 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R212 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R213 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R214 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R215 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R216 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R217 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R218 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R219 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R220 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R221 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R222 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R223 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R224 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R225 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R226 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R227 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R228 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R229 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R230 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R231 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R232 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R233 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R234 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R235 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R236 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R237 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R238 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R239 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R240 n1_m1_403200_4800 n1_m1_408000_4800 5.356235
R241 n1_m1_408000_4800 n1_m1_412800_4800 5.356235
R242 n1_m1_412800_4800 n1_m1_417600_4800 5.356235
R243 n1_m1_417600_4800 n1_m1_422400_4800 5.356235
R244 n1_m1_422400_4800 n1_m1_424000_4800 1.785412
R245 n1_m1_427200_4800 n1_m1_424000_4800 3.570824
R246 n1_m1_427200_4800 n1_m1_432000_4800 5.356235
R247 n1_m1_432000_4800 n1_m1_436800_4800 5.356235
R248 n1_m1_436800_4800 n1_m1_441600_4800 5.356235
R249 n1_m1_441600_4800 n1_m1_446400_4800 5.356235
R250 n1_m1_446400_4800 n1_m1_451200_4800 5.356235
R251 n1_m1_451200_4800 n1_m1_452000_4800 0.892706
R252 n1_m1_456000_4800 n1_m1_452000_4800 4.463529
R253 n1_m1_456000_4800 n1_m1_460800_4800 5.356235
R254 n1_m1_460800_4800 n1_m1_465600_4800 5.356235
R255 n1_m1_465600_4800 n1_m1_470400_4800 5.356235
R256 n1_m1_470400_4800 n1_m1_475200_4800 5.356235
R257 n1_m1_475200_4800 n1_m1_480000_4800 5.356235
R258 n1_m1_480000_4800 n1_m1_484800_4800 5.356235
R259 n1_m1_484800_4800 n1_m1_489600_4800 5.356235
R260 n1_m1_489600_4800 n1_m1_494400_4800 5.356235
R261 n1_m1_494400_4800 n1_m1_499200_4800 5.356235
R262 n1_m1_499200_4800 n1_m1_504000_4800 5.356235
R263 n1_m1_504000_4800 n1_m1_508000_4800 4.463529
R264 n1_m1_508800_4800 n1_m1_508000_4800 0.892706
R265 n1_m1_508800_4800 n1_m1_513600_4800 5.356235
R266 n1_m1_513600_4800 n1_m1_518400_4800 5.356235
R267 n1_m1_518400_4800 n1_m1_523200_4800 5.356235
R268 n1_m1_523200_4800 n1_m1_528000_4800 5.356235
R269 n1_m1_528000_4800 n1_m1_532800_4800 5.356235
R270 n1_m1_532800_4800 n1_m1_536000_4800 3.570824
R271 n1_m1_537600_4800 n1_m1_536000_4800 1.785412
R272 n1_m1_537600_4800 n1_m1_542400_4800 5.356235
R273 n1_m1_542400_4800 n1_m1_547200_4800 5.356235
R274 n1_m1_547200_4800 n1_m1_552000_4800 5.356235
R275 n1_m1_552000_4800 n1_m1_556800_4800 5.356235
R276 n1_m1_556800_4800 n1_m1_561600_4800 5.356235
R277 n1_m1_561600_4800 n1_m1_564000_4800 2.678118
R278 n1_m1_566400_4800 n1_m1_564000_4800 2.678118
R279 n1_m1_566400_4800 n1_m1_571200_4800 5.356235
R280 n1_m1_571200_4800 n1_m1_576000_4800 5.356235
R281 n1_m1_576000_4800 n1_m1_580800_4800 5.356235
R282 n1_m1_580800_4800 n1_m1_585600_4800 5.356235
R283 n1_m1_585600_4800 n1_m1_590400_4800 5.356235
R284 n1_m1_590400_4800 n1_m1_592000_4800 1.785412
R285 n1_m1_595200_4800 n1_m1_592000_4800 3.570824
R286 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R287 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R288 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R289 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R290 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R291 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R292 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R293 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R294 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R295 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R296 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R297 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R298 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R299 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R300 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R301 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R302 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R303 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R304 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R305 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R306 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R307 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R308 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R309 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R310 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R311 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R312 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R313 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R314 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R315 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R316 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R317 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R318 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R319 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R320 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R321 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R322 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R323 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R324 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R325 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R326 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R327 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R328 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R329 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R330 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R331 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R332 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R333 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R334 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R335 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R336 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R337 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R338 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R339 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R340 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R341 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R342 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R343 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R344 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R345 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R346 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R347 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R348 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R349 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R350 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R351 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R352 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R353 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R354 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R355 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R356 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R357 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R358 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R359 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R360 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R361 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R362 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R363 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R364 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R365 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R366 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R367 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R368 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R369 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R370 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R371 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R372 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R373 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R374 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R375 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R376 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R377 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R378 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R379 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R380 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R381 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R382 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R383 n1_m1_403200_9600 n1_m1_408000_9600 5.356235
R384 n1_m1_408000_9600 n1_m1_412800_9600 5.356235
R385 n1_m1_412800_9600 n1_m1_417600_9600 5.356235
R386 n1_m1_417600_9600 n1_m1_422400_9600 5.356235
R387 n1_m1_422400_9600 n1_m1_424000_9600 1.785412
R388 n1_m1_427200_9600 n1_m1_424000_9600 3.570824
R389 n1_m1_427200_9600 n1_m1_432000_9600 5.356235
R390 n1_m1_432000_9600 n1_m1_436800_9600 5.356235
R391 n1_m1_436800_9600 n1_m1_441600_9600 5.356235
R392 n1_m1_441600_9600 n1_m1_446400_9600 5.356235
R393 n1_m1_446400_9600 n1_m1_451200_9600 5.356235
R394 n1_m1_451200_9600 n1_m1_452000_9600 0.892706
R395 n1_m1_456000_9600 n1_m1_452000_9600 4.463529
R396 n1_m1_456000_9600 n1_m1_460800_9600 5.356235
R397 n1_m1_460800_9600 n1_m1_465600_9600 5.356235
R398 n1_m1_465600_9600 n1_m1_470400_9600 5.356235
R399 n1_m1_470400_9600 n1_m1_475200_9600 5.356235
R400 n1_m1_475200_9600 n1_m1_480000_9600 5.356235
R401 n1_m1_480000_9600 n1_m1_484800_9600 5.356235
R402 n1_m1_484800_9600 n1_m1_489600_9600 5.356235
R403 n1_m1_489600_9600 n1_m1_494400_9600 5.356235
R404 n1_m1_494400_9600 n1_m1_499200_9600 5.356235
R405 n1_m1_499200_9600 n1_m1_504000_9600 5.356235
R406 n1_m1_504000_9600 n1_m1_508000_9600 4.463529
R407 n1_m1_508800_9600 n1_m1_508000_9600 0.892706
R408 n1_m1_508800_9600 n1_m1_513600_9600 5.356235
R409 n1_m1_513600_9600 n1_m1_518400_9600 5.356235
R410 n1_m1_518400_9600 n1_m1_523200_9600 5.356235
R411 n1_m1_523200_9600 n1_m1_528000_9600 5.356235
R412 n1_m1_528000_9600 n1_m1_532800_9600 5.356235
R413 n1_m1_532800_9600 n1_m1_536000_9600 3.570824
R414 n1_m1_537600_9600 n1_m1_536000_9600 1.785412
R415 n1_m1_537600_9600 n1_m1_542400_9600 5.356235
R416 n1_m1_542400_9600 n1_m1_547200_9600 5.356235
R417 n1_m1_547200_9600 n1_m1_552000_9600 5.356235
R418 n1_m1_552000_9600 n1_m1_556800_9600 5.356235
R419 n1_m1_556800_9600 n1_m1_561600_9600 5.356235
R420 n1_m1_561600_9600 n1_m1_564000_9600 2.678118
R421 n1_m1_566400_9600 n1_m1_564000_9600 2.678118
R422 n1_m1_566400_9600 n1_m1_571200_9600 5.356235
R423 n1_m1_571200_9600 n1_m1_576000_9600 5.356235
R424 n1_m1_576000_9600 n1_m1_580800_9600 5.356235
R425 n1_m1_580800_9600 n1_m1_585600_9600 5.356235
R426 n1_m1_585600_9600 n1_m1_590400_9600 5.356235
R427 n1_m1_590400_9600 n1_m1_592000_9600 1.785412
R428 n1_m1_595200_9600 n1_m1_592000_9600 3.570824
R429 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R430 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R431 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R432 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R433 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R434 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R435 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R436 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R437 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R438 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R439 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R440 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R441 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R442 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R443 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R444 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R445 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R446 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R447 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R448 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R449 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R450 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R451 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R452 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R453 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R454 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R455 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R456 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R457 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R458 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R459 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R460 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R461 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R462 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R463 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R464 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R465 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R466 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R467 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R468 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R469 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R470 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R471 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R472 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R473 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R474 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R475 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R476 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R477 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R478 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R479 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R480 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R481 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R482 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R483 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R484 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R485 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R486 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R487 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R488 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R489 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R490 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R491 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R492 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R493 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R494 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R495 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R496 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R497 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R498 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R499 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R500 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R501 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R502 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R503 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R504 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R505 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R506 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R507 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R508 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R509 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R510 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R511 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R512 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R513 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R514 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R515 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R516 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R517 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R518 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R519 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R520 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R521 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R522 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R523 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R524 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R525 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R526 n1_m1_403200_14400 n1_m1_408000_14400 5.356235
R527 n1_m1_408000_14400 n1_m1_412800_14400 5.356235
R528 n1_m1_412800_14400 n1_m1_417600_14400 5.356235
R529 n1_m1_417600_14400 n1_m1_422400_14400 5.356235
R530 n1_m1_422400_14400 n1_m1_424000_14400 1.785412
R531 n1_m1_427200_14400 n1_m1_424000_14400 3.570824
R532 n1_m1_427200_14400 n1_m1_432000_14400 5.356235
R533 n1_m1_432000_14400 n1_m1_436800_14400 5.356235
R534 n1_m1_436800_14400 n1_m1_441600_14400 5.356235
R535 n1_m1_441600_14400 n1_m1_446400_14400 5.356235
R536 n1_m1_446400_14400 n1_m1_451200_14400 5.356235
R537 n1_m1_451200_14400 n1_m1_452000_14400 0.892706
R538 n1_m1_456000_14400 n1_m1_452000_14400 4.463529
R539 n1_m1_456000_14400 n1_m1_460800_14400 5.356235
R540 n1_m1_460800_14400 n1_m1_465600_14400 5.356235
R541 n1_m1_465600_14400 n1_m1_470400_14400 5.356235
R542 n1_m1_470400_14400 n1_m1_475200_14400 5.356235
R543 n1_m1_475200_14400 n1_m1_480000_14400 5.356235
R544 n1_m1_480000_14400 n1_m1_484800_14400 5.356235
R545 n1_m1_484800_14400 n1_m1_489600_14400 5.356235
R546 n1_m1_489600_14400 n1_m1_494400_14400 5.356235
R547 n1_m1_494400_14400 n1_m1_499200_14400 5.356235
R548 n1_m1_499200_14400 n1_m1_504000_14400 5.356235
R549 n1_m1_504000_14400 n1_m1_508000_14400 4.463529
R550 n1_m1_508800_14400 n1_m1_508000_14400 0.892706
R551 n1_m1_508800_14400 n1_m1_513600_14400 5.356235
R552 n1_m1_513600_14400 n1_m1_518400_14400 5.356235
R553 n1_m1_518400_14400 n1_m1_523200_14400 5.356235
R554 n1_m1_523200_14400 n1_m1_528000_14400 5.356235
R555 n1_m1_528000_14400 n1_m1_532800_14400 5.356235
R556 n1_m1_532800_14400 n1_m1_536000_14400 3.570824
R557 n1_m1_537600_14400 n1_m1_536000_14400 1.785412
R558 n1_m1_537600_14400 n1_m1_542400_14400 5.356235
R559 n1_m1_542400_14400 n1_m1_547200_14400 5.356235
R560 n1_m1_547200_14400 n1_m1_552000_14400 5.356235
R561 n1_m1_552000_14400 n1_m1_556800_14400 5.356235
R562 n1_m1_556800_14400 n1_m1_561600_14400 5.356235
R563 n1_m1_561600_14400 n1_m1_564000_14400 2.678118
R564 n1_m1_566400_14400 n1_m1_564000_14400 2.678118
R565 n1_m1_566400_14400 n1_m1_571200_14400 5.356235
R566 n1_m1_571200_14400 n1_m1_576000_14400 5.356235
R567 n1_m1_576000_14400 n1_m1_580800_14400 5.356235
R568 n1_m1_580800_14400 n1_m1_585600_14400 5.356235
R569 n1_m1_585600_14400 n1_m1_590400_14400 5.356235
R570 n1_m1_590400_14400 n1_m1_592000_14400 1.785412
R571 n1_m1_595200_14400 n1_m1_592000_14400 3.570824
R572 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R573 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R574 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R575 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R576 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R577 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R578 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R579 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R580 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R581 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R582 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R583 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R584 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R585 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R586 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R587 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R588 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R589 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R590 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R591 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R592 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R593 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R594 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R595 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R596 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R597 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R598 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R599 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R600 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R601 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R602 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R603 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R604 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R605 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R606 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R607 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R608 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R609 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R610 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R611 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R612 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R613 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R614 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R615 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R616 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R617 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R618 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R619 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R620 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R621 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R622 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R623 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R624 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R625 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R626 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R627 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R628 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R629 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R630 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R631 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R632 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R633 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R634 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R635 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R636 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R637 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R638 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R639 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R640 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R641 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R642 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R643 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R644 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R645 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R646 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R647 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R648 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R649 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R650 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R651 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R652 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R653 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R654 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R655 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R656 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R657 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R658 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R659 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R660 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R661 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R662 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R663 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R664 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R665 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R666 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R667 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R668 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R669 n1_m1_403200_19200 n1_m1_408000_19200 5.356235
R670 n1_m1_408000_19200 n1_m1_412800_19200 5.356235
R671 n1_m1_412800_19200 n1_m1_417600_19200 5.356235
R672 n1_m1_417600_19200 n1_m1_422400_19200 5.356235
R673 n1_m1_422400_19200 n1_m1_424000_19200 1.785412
R674 n1_m1_427200_19200 n1_m1_424000_19200 3.570824
R675 n1_m1_427200_19200 n1_m1_432000_19200 5.356235
R676 n1_m1_432000_19200 n1_m1_436800_19200 5.356235
R677 n1_m1_436800_19200 n1_m1_441600_19200 5.356235
R678 n1_m1_441600_19200 n1_m1_446400_19200 5.356235
R679 n1_m1_446400_19200 n1_m1_451200_19200 5.356235
R680 n1_m1_451200_19200 n1_m1_452000_19200 0.892706
R681 n1_m1_456000_19200 n1_m1_452000_19200 4.463529
R682 n1_m1_456000_19200 n1_m1_460800_19200 5.356235
R683 n1_m1_460800_19200 n1_m1_465600_19200 5.356235
R684 n1_m1_465600_19200 n1_m1_470400_19200 5.356235
R685 n1_m1_470400_19200 n1_m1_475200_19200 5.356235
R686 n1_m1_475200_19200 n1_m1_480000_19200 5.356235
R687 n1_m1_480000_19200 n1_m1_484800_19200 5.356235
R688 n1_m1_484800_19200 n1_m1_489600_19200 5.356235
R689 n1_m1_489600_19200 n1_m1_494400_19200 5.356235
R690 n1_m1_494400_19200 n1_m1_499200_19200 5.356235
R691 n1_m1_499200_19200 n1_m1_504000_19200 5.356235
R692 n1_m1_504000_19200 n1_m1_508000_19200 4.463529
R693 n1_m1_508800_19200 n1_m1_508000_19200 0.892706
R694 n1_m1_508800_19200 n1_m1_513600_19200 5.356235
R695 n1_m1_513600_19200 n1_m1_518400_19200 5.356235
R696 n1_m1_518400_19200 n1_m1_523200_19200 5.356235
R697 n1_m1_523200_19200 n1_m1_528000_19200 5.356235
R698 n1_m1_528000_19200 n1_m1_532800_19200 5.356235
R699 n1_m1_532800_19200 n1_m1_536000_19200 3.570824
R700 n1_m1_537600_19200 n1_m1_536000_19200 1.785412
R701 n1_m1_537600_19200 n1_m1_542400_19200 5.356235
R702 n1_m1_542400_19200 n1_m1_547200_19200 5.356235
R703 n1_m1_547200_19200 n1_m1_552000_19200 5.356235
R704 n1_m1_552000_19200 n1_m1_556800_19200 5.356235
R705 n1_m1_556800_19200 n1_m1_561600_19200 5.356235
R706 n1_m1_561600_19200 n1_m1_564000_19200 2.678118
R707 n1_m1_566400_19200 n1_m1_564000_19200 2.678118
R708 n1_m1_566400_19200 n1_m1_571200_19200 5.356235
R709 n1_m1_571200_19200 n1_m1_576000_19200 5.356235
R710 n1_m1_576000_19200 n1_m1_580800_19200 5.356235
R711 n1_m1_580800_19200 n1_m1_585600_19200 5.356235
R712 n1_m1_585600_19200 n1_m1_590400_19200 5.356235
R713 n1_m1_590400_19200 n1_m1_592000_19200 1.785412
R714 n1_m1_595200_19200 n1_m1_592000_19200 3.570824
R715 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R716 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R717 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R718 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R719 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R720 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R721 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R722 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R723 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R724 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R725 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R726 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R727 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R728 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R729 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R730 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R731 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R732 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R733 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R734 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R735 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R736 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R737 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R738 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R739 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R740 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R741 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R742 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R743 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R744 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R745 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R746 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R747 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R748 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R749 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R750 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R751 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R752 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R753 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R754 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R755 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R756 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R757 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R758 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R759 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R760 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R761 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R762 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R763 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R764 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R765 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R766 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R767 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R768 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R769 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R770 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R771 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R772 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R773 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R774 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R775 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R776 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R777 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R778 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R779 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R780 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R781 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R782 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R783 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R784 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R785 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R786 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R787 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R788 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R789 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R790 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R791 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R792 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R793 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R794 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R795 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R796 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R797 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R798 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R799 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R800 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R801 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R802 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R803 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R804 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R805 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R806 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R807 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R808 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R809 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R810 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R811 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R812 n1_m1_403200_24000 n1_m1_408000_24000 5.356235
R813 n1_m1_408000_24000 n1_m1_412800_24000 5.356235
R814 n1_m1_412800_24000 n1_m1_417600_24000 5.356235
R815 n1_m1_417600_24000 n1_m1_422400_24000 5.356235
R816 n1_m1_422400_24000 n1_m1_424000_24000 1.785412
R817 n1_m1_427200_24000 n1_m1_424000_24000 3.570824
R818 n1_m1_427200_24000 n1_m1_432000_24000 5.356235
R819 n1_m1_432000_24000 n1_m1_436800_24000 5.356235
R820 n1_m1_436800_24000 n1_m1_441600_24000 5.356235
R821 n1_m1_441600_24000 n1_m1_446400_24000 5.356235
R822 n1_m1_446400_24000 n1_m1_451200_24000 5.356235
R823 n1_m1_451200_24000 n1_m1_452000_24000 0.892706
R824 n1_m1_456000_24000 n1_m1_452000_24000 4.463529
R825 n1_m1_456000_24000 n1_m1_460800_24000 5.356235
R826 n1_m1_460800_24000 n1_m1_465600_24000 5.356235
R827 n1_m1_465600_24000 n1_m1_470400_24000 5.356235
R828 n1_m1_470400_24000 n1_m1_475200_24000 5.356235
R829 n1_m1_475200_24000 n1_m1_480000_24000 5.356235
R830 n1_m1_480000_24000 n1_m1_484800_24000 5.356235
R831 n1_m1_484800_24000 n1_m1_489600_24000 5.356235
R832 n1_m1_489600_24000 n1_m1_494400_24000 5.356235
R833 n1_m1_494400_24000 n1_m1_499200_24000 5.356235
R834 n1_m1_499200_24000 n1_m1_504000_24000 5.356235
R835 n1_m1_504000_24000 n1_m1_508000_24000 4.463529
R836 n1_m1_508800_24000 n1_m1_508000_24000 0.892706
R837 n1_m1_508800_24000 n1_m1_513600_24000 5.356235
R838 n1_m1_513600_24000 n1_m1_518400_24000 5.356235
R839 n1_m1_518400_24000 n1_m1_523200_24000 5.356235
R840 n1_m1_523200_24000 n1_m1_528000_24000 5.356235
R841 n1_m1_528000_24000 n1_m1_532800_24000 5.356235
R842 n1_m1_532800_24000 n1_m1_536000_24000 3.570824
R843 n1_m1_537600_24000 n1_m1_536000_24000 1.785412
R844 n1_m1_537600_24000 n1_m1_542400_24000 5.356235
R845 n1_m1_542400_24000 n1_m1_547200_24000 5.356235
R846 n1_m1_547200_24000 n1_m1_552000_24000 5.356235
R847 n1_m1_552000_24000 n1_m1_556800_24000 5.356235
R848 n1_m1_556800_24000 n1_m1_561600_24000 5.356235
R849 n1_m1_561600_24000 n1_m1_564000_24000 2.678118
R850 n1_m1_566400_24000 n1_m1_564000_24000 2.678118
R851 n1_m1_566400_24000 n1_m1_571200_24000 5.356235
R852 n1_m1_571200_24000 n1_m1_576000_24000 5.356235
R853 n1_m1_576000_24000 n1_m1_580800_24000 5.356235
R854 n1_m1_580800_24000 n1_m1_585600_24000 5.356235
R855 n1_m1_585600_24000 n1_m1_590400_24000 5.356235
R856 n1_m1_590400_24000 n1_m1_592000_24000 1.785412
R857 n1_m1_595200_24000 n1_m1_592000_24000 3.570824
R858 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R859 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R860 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R861 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R862 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R863 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R864 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R865 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R866 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R867 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R868 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R869 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R870 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R871 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R872 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R873 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R874 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R875 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R876 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R877 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R878 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R879 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R880 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R881 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R882 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R883 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R884 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R885 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R886 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R887 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R888 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R889 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R890 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R891 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R892 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R893 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R894 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R895 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R896 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R897 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R898 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R899 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R900 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R901 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R902 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R903 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R904 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R905 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R906 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R907 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R908 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R909 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R910 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R911 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R912 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R913 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R914 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R915 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R916 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R917 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R918 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R919 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R920 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R921 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R922 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R923 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R924 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R925 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R926 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R927 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R928 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R929 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R930 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R931 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R932 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R933 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R934 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R935 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R936 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R937 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R938 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R939 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R940 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R941 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R942 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R943 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R944 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R945 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R946 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R947 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R948 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R949 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R950 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R951 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R952 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R953 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R954 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R955 n1_m1_403200_28800 n1_m1_408000_28800 5.356235
R956 n1_m1_408000_28800 n1_m1_412800_28800 5.356235
R957 n1_m1_412800_28800 n1_m1_417600_28800 5.356235
R958 n1_m1_417600_28800 n1_m1_422400_28800 5.356235
R959 n1_m1_422400_28800 n1_m1_424000_28800 1.785412
R960 n1_m1_427200_28800 n1_m1_424000_28800 3.570824
R961 n1_m1_427200_28800 n1_m1_432000_28800 5.356235
R962 n1_m1_432000_28800 n1_m1_436800_28800 5.356235
R963 n1_m1_436800_28800 n1_m1_441600_28800 5.356235
R964 n1_m1_441600_28800 n1_m1_446400_28800 5.356235
R965 n1_m1_446400_28800 n1_m1_451200_28800 5.356235
R966 n1_m1_451200_28800 n1_m1_452000_28800 0.892706
R967 n1_m1_456000_28800 n1_m1_452000_28800 4.463529
R968 n1_m1_456000_28800 n1_m1_460800_28800 5.356235
R969 n1_m1_460800_28800 n1_m1_465600_28800 5.356235
R970 n1_m1_465600_28800 n1_m1_470400_28800 5.356235
R971 n1_m1_470400_28800 n1_m1_475200_28800 5.356235
R972 n1_m1_475200_28800 n1_m1_480000_28800 5.356235
R973 n1_m1_480000_28800 n1_m1_484800_28800 5.356235
R974 n1_m1_484800_28800 n1_m1_489600_28800 5.356235
R975 n1_m1_489600_28800 n1_m1_494400_28800 5.356235
R976 n1_m1_494400_28800 n1_m1_499200_28800 5.356235
R977 n1_m1_499200_28800 n1_m1_504000_28800 5.356235
R978 n1_m1_504000_28800 n1_m1_508000_28800 4.463529
R979 n1_m1_508800_28800 n1_m1_508000_28800 0.892706
R980 n1_m1_508800_28800 n1_m1_513600_28800 5.356235
R981 n1_m1_513600_28800 n1_m1_518400_28800 5.356235
R982 n1_m1_518400_28800 n1_m1_523200_28800 5.356235
R983 n1_m1_523200_28800 n1_m1_528000_28800 5.356235
R984 n1_m1_528000_28800 n1_m1_532800_28800 5.356235
R985 n1_m1_532800_28800 n1_m1_536000_28800 3.570824
R986 n1_m1_537600_28800 n1_m1_536000_28800 1.785412
R987 n1_m1_537600_28800 n1_m1_542400_28800 5.356235
R988 n1_m1_542400_28800 n1_m1_547200_28800 5.356235
R989 n1_m1_547200_28800 n1_m1_552000_28800 5.356235
R990 n1_m1_552000_28800 n1_m1_556800_28800 5.356235
R991 n1_m1_556800_28800 n1_m1_561600_28800 5.356235
R992 n1_m1_561600_28800 n1_m1_564000_28800 2.678118
R993 n1_m1_566400_28800 n1_m1_564000_28800 2.678118
R994 n1_m1_566400_28800 n1_m1_571200_28800 5.356235
R995 n1_m1_571200_28800 n1_m1_576000_28800 5.356235
R996 n1_m1_576000_28800 n1_m1_580800_28800 5.356235
R997 n1_m1_580800_28800 n1_m1_585600_28800 5.356235
R998 n1_m1_585600_28800 n1_m1_590400_28800 5.356235
R999 n1_m1_590400_28800 n1_m1_592000_28800 1.785412
R1000 n1_m1_595200_28800 n1_m1_592000_28800 3.570824
R1001 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R1002 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R1003 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R1004 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R1005 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R1006 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R1007 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R1008 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R1009 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R1010 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R1011 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R1012 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R1013 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R1014 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R1015 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R1016 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R1017 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R1018 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R1019 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R1020 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R1021 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R1022 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R1023 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R1024 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R1025 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R1026 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R1027 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R1028 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R1029 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R1030 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R1031 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R1032 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R1033 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R1034 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R1035 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R1036 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R1037 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R1038 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R1039 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R1040 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R1041 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R1042 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R1043 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R1044 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R1045 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R1046 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R1047 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R1048 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R1049 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R1050 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R1051 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R1052 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R1053 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R1054 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R1055 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R1056 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R1057 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R1058 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R1059 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R1060 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R1061 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R1062 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R1063 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R1064 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R1065 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R1066 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R1067 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R1068 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R1069 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R1070 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R1071 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R1072 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R1073 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R1074 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R1075 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R1076 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R1077 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R1078 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R1079 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R1080 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R1081 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R1082 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R1083 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R1084 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R1085 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R1086 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R1087 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R1088 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R1089 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R1090 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R1091 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R1092 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R1093 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R1094 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R1095 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R1096 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R1097 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R1098 n1_m1_403200_33600 n1_m1_408000_33600 5.356235
R1099 n1_m1_408000_33600 n1_m1_412800_33600 5.356235
R1100 n1_m1_412800_33600 n1_m1_417600_33600 5.356235
R1101 n1_m1_417600_33600 n1_m1_422400_33600 5.356235
R1102 n1_m1_422400_33600 n1_m1_424000_33600 1.785412
R1103 n1_m1_427200_33600 n1_m1_424000_33600 3.570824
R1104 n1_m1_427200_33600 n1_m1_432000_33600 5.356235
R1105 n1_m1_432000_33600 n1_m1_436800_33600 5.356235
R1106 n1_m1_436800_33600 n1_m1_441600_33600 5.356235
R1107 n1_m1_441600_33600 n1_m1_446400_33600 5.356235
R1108 n1_m1_446400_33600 n1_m1_451200_33600 5.356235
R1109 n1_m1_451200_33600 n1_m1_452000_33600 0.892706
R1110 n1_m1_456000_33600 n1_m1_452000_33600 4.463529
R1111 n1_m1_456000_33600 n1_m1_460800_33600 5.356235
R1112 n1_m1_460800_33600 n1_m1_465600_33600 5.356235
R1113 n1_m1_465600_33600 n1_m1_470400_33600 5.356235
R1114 n1_m1_470400_33600 n1_m1_475200_33600 5.356235
R1115 n1_m1_475200_33600 n1_m1_480000_33600 5.356235
R1116 n1_m1_480000_33600 n1_m1_484800_33600 5.356235
R1117 n1_m1_484800_33600 n1_m1_489600_33600 5.356235
R1118 n1_m1_489600_33600 n1_m1_494400_33600 5.356235
R1119 n1_m1_494400_33600 n1_m1_499200_33600 5.356235
R1120 n1_m1_499200_33600 n1_m1_504000_33600 5.356235
R1121 n1_m1_504000_33600 n1_m1_508000_33600 4.463529
R1122 n1_m1_508800_33600 n1_m1_508000_33600 0.892706
R1123 n1_m1_508800_33600 n1_m1_513600_33600 5.356235
R1124 n1_m1_513600_33600 n1_m1_518400_33600 5.356235
R1125 n1_m1_518400_33600 n1_m1_523200_33600 5.356235
R1126 n1_m1_523200_33600 n1_m1_528000_33600 5.356235
R1127 n1_m1_528000_33600 n1_m1_532800_33600 5.356235
R1128 n1_m1_532800_33600 n1_m1_536000_33600 3.570824
R1129 n1_m1_537600_33600 n1_m1_536000_33600 1.785412
R1130 n1_m1_537600_33600 n1_m1_542400_33600 5.356235
R1131 n1_m1_542400_33600 n1_m1_547200_33600 5.356235
R1132 n1_m1_547200_33600 n1_m1_552000_33600 5.356235
R1133 n1_m1_552000_33600 n1_m1_556800_33600 5.356235
R1134 n1_m1_556800_33600 n1_m1_561600_33600 5.356235
R1135 n1_m1_561600_33600 n1_m1_564000_33600 2.678118
R1136 n1_m1_566400_33600 n1_m1_564000_33600 2.678118
R1137 n1_m1_566400_33600 n1_m1_571200_33600 5.356235
R1138 n1_m1_571200_33600 n1_m1_576000_33600 5.356235
R1139 n1_m1_576000_33600 n1_m1_580800_33600 5.356235
R1140 n1_m1_580800_33600 n1_m1_585600_33600 5.356235
R1141 n1_m1_585600_33600 n1_m1_590400_33600 5.356235
R1142 n1_m1_590400_33600 n1_m1_592000_33600 1.785412
R1143 n1_m1_595200_33600 n1_m1_592000_33600 3.570824
R1144 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R1145 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R1146 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R1147 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R1148 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R1149 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R1150 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R1151 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R1152 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R1153 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R1154 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R1155 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R1156 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R1157 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R1158 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R1159 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R1160 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R1161 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R1162 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R1163 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R1164 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R1165 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R1166 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R1167 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R1168 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R1169 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R1170 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R1171 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R1172 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R1173 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R1174 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R1175 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R1176 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R1177 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R1178 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R1179 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R1180 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R1181 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R1182 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R1183 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R1184 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R1185 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R1186 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R1187 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R1188 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R1189 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R1190 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R1191 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R1192 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R1193 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R1194 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R1195 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R1196 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R1197 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R1198 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R1199 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R1200 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R1201 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R1202 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R1203 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R1204 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R1205 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R1206 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R1207 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R1208 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R1209 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R1210 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R1211 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R1212 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R1213 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R1214 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R1215 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R1216 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R1217 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R1218 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R1219 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R1220 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R1221 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R1222 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R1223 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R1224 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R1225 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R1226 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R1227 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R1228 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R1229 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R1230 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R1231 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R1232 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R1233 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R1234 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R1235 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R1236 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R1237 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R1238 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R1239 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R1240 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R1241 n1_m1_403200_38400 n1_m1_408000_38400 5.356235
R1242 n1_m1_408000_38400 n1_m1_412800_38400 5.356235
R1243 n1_m1_412800_38400 n1_m1_417600_38400 5.356235
R1244 n1_m1_417600_38400 n1_m1_422400_38400 5.356235
R1245 n1_m1_422400_38400 n1_m1_424000_38400 1.785412
R1246 n1_m1_427200_38400 n1_m1_424000_38400 3.570824
R1247 n1_m1_427200_38400 n1_m1_432000_38400 5.356235
R1248 n1_m1_432000_38400 n1_m1_436800_38400 5.356235
R1249 n1_m1_436800_38400 n1_m1_441600_38400 5.356235
R1250 n1_m1_441600_38400 n1_m1_446400_38400 5.356235
R1251 n1_m1_446400_38400 n1_m1_451200_38400 5.356235
R1252 n1_m1_451200_38400 n1_m1_452000_38400 0.892706
R1253 n1_m1_456000_38400 n1_m1_452000_38400 4.463529
R1254 n1_m1_456000_38400 n1_m1_460800_38400 5.356235
R1255 n1_m1_460800_38400 n1_m1_465600_38400 5.356235
R1256 n1_m1_465600_38400 n1_m1_470400_38400 5.356235
R1257 n1_m1_470400_38400 n1_m1_475200_38400 5.356235
R1258 n1_m1_475200_38400 n1_m1_480000_38400 5.356235
R1259 n1_m1_480000_38400 n1_m1_484800_38400 5.356235
R1260 n1_m1_484800_38400 n1_m1_489600_38400 5.356235
R1261 n1_m1_489600_38400 n1_m1_494400_38400 5.356235
R1262 n1_m1_494400_38400 n1_m1_499200_38400 5.356235
R1263 n1_m1_499200_38400 n1_m1_504000_38400 5.356235
R1264 n1_m1_504000_38400 n1_m1_508000_38400 4.463529
R1265 n1_m1_508800_38400 n1_m1_508000_38400 0.892706
R1266 n1_m1_508800_38400 n1_m1_513600_38400 5.356235
R1267 n1_m1_513600_38400 n1_m1_518400_38400 5.356235
R1268 n1_m1_518400_38400 n1_m1_523200_38400 5.356235
R1269 n1_m1_523200_38400 n1_m1_528000_38400 5.356235
R1270 n1_m1_528000_38400 n1_m1_532800_38400 5.356235
R1271 n1_m1_532800_38400 n1_m1_536000_38400 3.570824
R1272 n1_m1_537600_38400 n1_m1_536000_38400 1.785412
R1273 n1_m1_537600_38400 n1_m1_542400_38400 5.356235
R1274 n1_m1_542400_38400 n1_m1_547200_38400 5.356235
R1275 n1_m1_547200_38400 n1_m1_552000_38400 5.356235
R1276 n1_m1_552000_38400 n1_m1_556800_38400 5.356235
R1277 n1_m1_556800_38400 n1_m1_561600_38400 5.356235
R1278 n1_m1_561600_38400 n1_m1_564000_38400 2.678118
R1279 n1_m1_566400_38400 n1_m1_564000_38400 2.678118
R1280 n1_m1_566400_38400 n1_m1_571200_38400 5.356235
R1281 n1_m1_571200_38400 n1_m1_576000_38400 5.356235
R1282 n1_m1_576000_38400 n1_m1_580800_38400 5.356235
R1283 n1_m1_580800_38400 n1_m1_585600_38400 5.356235
R1284 n1_m1_585600_38400 n1_m1_590400_38400 5.356235
R1285 n1_m1_590400_38400 n1_m1_592000_38400 1.785412
R1286 n1_m1_595200_38400 n1_m1_592000_38400 3.570824
R1287 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R1288 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R1289 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R1290 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R1291 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R1292 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R1293 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R1294 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R1295 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R1296 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R1297 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R1298 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R1299 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R1300 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R1301 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R1302 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R1303 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R1304 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R1305 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R1306 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R1307 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R1308 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R1309 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R1310 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R1311 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R1312 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R1313 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R1314 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R1315 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R1316 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R1317 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R1318 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R1319 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R1320 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R1321 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R1322 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R1323 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R1324 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R1325 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R1326 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R1327 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R1328 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R1329 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R1330 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R1331 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R1332 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R1333 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R1334 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R1335 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R1336 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R1337 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R1338 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R1339 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R1340 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R1341 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R1342 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R1343 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R1344 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R1345 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R1346 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R1347 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R1348 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R1349 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R1350 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R1351 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R1352 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R1353 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R1354 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R1355 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R1356 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R1357 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R1358 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R1359 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R1360 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R1361 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R1362 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R1363 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R1364 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R1365 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R1366 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R1367 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R1368 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R1369 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R1370 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R1371 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R1372 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R1373 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R1374 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R1375 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R1376 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R1377 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R1378 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R1379 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R1380 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R1381 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R1382 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R1383 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R1384 n1_m1_403200_43200 n1_m1_408000_43200 5.356235
R1385 n1_m1_408000_43200 n1_m1_412800_43200 5.356235
R1386 n1_m1_412800_43200 n1_m1_417600_43200 5.356235
R1387 n1_m1_417600_43200 n1_m1_422400_43200 5.356235
R1388 n1_m1_422400_43200 n1_m1_424000_43200 1.785412
R1389 n1_m1_427200_43200 n1_m1_424000_43200 3.570824
R1390 n1_m1_427200_43200 n1_m1_432000_43200 5.356235
R1391 n1_m1_432000_43200 n1_m1_436800_43200 5.356235
R1392 n1_m1_436800_43200 n1_m1_441600_43200 5.356235
R1393 n1_m1_441600_43200 n1_m1_446400_43200 5.356235
R1394 n1_m1_446400_43200 n1_m1_451200_43200 5.356235
R1395 n1_m1_451200_43200 n1_m1_452000_43200 0.892706
R1396 n1_m1_456000_43200 n1_m1_452000_43200 4.463529
R1397 n1_m1_456000_43200 n1_m1_460800_43200 5.356235
R1398 n1_m1_460800_43200 n1_m1_465600_43200 5.356235
R1399 n1_m1_465600_43200 n1_m1_470400_43200 5.356235
R1400 n1_m1_470400_43200 n1_m1_475200_43200 5.356235
R1401 n1_m1_475200_43200 n1_m1_480000_43200 5.356235
R1402 n1_m1_480000_43200 n1_m1_484800_43200 5.356235
R1403 n1_m1_484800_43200 n1_m1_489600_43200 5.356235
R1404 n1_m1_489600_43200 n1_m1_494400_43200 5.356235
R1405 n1_m1_494400_43200 n1_m1_499200_43200 5.356235
R1406 n1_m1_499200_43200 n1_m1_504000_43200 5.356235
R1407 n1_m1_504000_43200 n1_m1_508000_43200 4.463529
R1408 n1_m1_508800_43200 n1_m1_508000_43200 0.892706
R1409 n1_m1_508800_43200 n1_m1_513600_43200 5.356235
R1410 n1_m1_513600_43200 n1_m1_518400_43200 5.356235
R1411 n1_m1_518400_43200 n1_m1_523200_43200 5.356235
R1412 n1_m1_523200_43200 n1_m1_528000_43200 5.356235
R1413 n1_m1_528000_43200 n1_m1_532800_43200 5.356235
R1414 n1_m1_532800_43200 n1_m1_536000_43200 3.570824
R1415 n1_m1_537600_43200 n1_m1_536000_43200 1.785412
R1416 n1_m1_537600_43200 n1_m1_542400_43200 5.356235
R1417 n1_m1_542400_43200 n1_m1_547200_43200 5.356235
R1418 n1_m1_547200_43200 n1_m1_552000_43200 5.356235
R1419 n1_m1_552000_43200 n1_m1_556800_43200 5.356235
R1420 n1_m1_556800_43200 n1_m1_561600_43200 5.356235
R1421 n1_m1_561600_43200 n1_m1_564000_43200 2.678118
R1422 n1_m1_566400_43200 n1_m1_564000_43200 2.678118
R1423 n1_m1_566400_43200 n1_m1_571200_43200 5.356235
R1424 n1_m1_571200_43200 n1_m1_576000_43200 5.356235
R1425 n1_m1_576000_43200 n1_m1_580800_43200 5.356235
R1426 n1_m1_580800_43200 n1_m1_585600_43200 5.356235
R1427 n1_m1_585600_43200 n1_m1_590400_43200 5.356235
R1428 n1_m1_590400_43200 n1_m1_592000_43200 1.785412
R1429 n1_m1_595200_43200 n1_m1_592000_43200 3.570824
R1430 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R1431 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R1432 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R1433 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R1434 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R1435 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R1436 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R1437 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R1438 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R1439 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R1440 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R1441 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R1442 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R1443 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R1444 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R1445 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R1446 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R1447 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R1448 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R1449 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R1450 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R1451 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R1452 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R1453 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R1454 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R1455 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R1456 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R1457 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R1458 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R1459 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1460 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1461 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1462 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1463 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1464 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1465 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1466 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1467 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1468 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1469 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1470 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1471 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1472 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1473 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1474 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1475 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1476 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1477 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1478 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1479 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1480 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1481 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1482 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1483 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1484 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1485 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1486 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1487 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1488 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1489 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1490 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1491 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1492 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1493 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1494 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1495 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1496 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1497 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1498 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1499 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1500 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1501 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1502 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1503 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1504 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1505 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1506 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1507 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1508 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1509 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1510 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1511 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1512 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1513 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1514 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1515 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1516 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1517 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1518 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1519 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1520 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1521 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1522 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1523 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1524 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1525 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1526 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1527 n1_m1_403200_48000 n1_m1_408000_48000 5.356235
R1528 n1_m1_408000_48000 n1_m1_412800_48000 5.356235
R1529 n1_m1_412800_48000 n1_m1_417600_48000 5.356235
R1530 n1_m1_417600_48000 n1_m1_422400_48000 5.356235
R1531 n1_m1_422400_48000 n1_m1_424000_48000 1.785412
R1532 n1_m1_427200_48000 n1_m1_424000_48000 3.570824
R1533 n1_m1_427200_48000 n1_m1_432000_48000 5.356235
R1534 n1_m1_432000_48000 n1_m1_436800_48000 5.356235
R1535 n1_m1_436800_48000 n1_m1_441600_48000 5.356235
R1536 n1_m1_441600_48000 n1_m1_446400_48000 5.356235
R1537 n1_m1_446400_48000 n1_m1_451200_48000 5.356235
R1538 n1_m1_451200_48000 n1_m1_452000_48000 0.892706
R1539 n1_m1_456000_48000 n1_m1_452000_48000 4.463529
R1540 n1_m1_456000_48000 n1_m1_460800_48000 5.356235
R1541 n1_m1_460800_48000 n1_m1_465600_48000 5.356235
R1542 n1_m1_465600_48000 n1_m1_470400_48000 5.356235
R1543 n1_m1_470400_48000 n1_m1_475200_48000 5.356235
R1544 n1_m1_475200_48000 n1_m1_480000_48000 5.356235
R1545 n1_m1_480000_48000 n1_m1_484800_48000 5.356235
R1546 n1_m1_484800_48000 n1_m1_489600_48000 5.356235
R1547 n1_m1_489600_48000 n1_m1_494400_48000 5.356235
R1548 n1_m1_494400_48000 n1_m1_499200_48000 5.356235
R1549 n1_m1_499200_48000 n1_m1_504000_48000 5.356235
R1550 n1_m1_504000_48000 n1_m1_508000_48000 4.463529
R1551 n1_m1_508800_48000 n1_m1_508000_48000 0.892706
R1552 n1_m1_508800_48000 n1_m1_513600_48000 5.356235
R1553 n1_m1_513600_48000 n1_m1_518400_48000 5.356235
R1554 n1_m1_518400_48000 n1_m1_523200_48000 5.356235
R1555 n1_m1_523200_48000 n1_m1_528000_48000 5.356235
R1556 n1_m1_528000_48000 n1_m1_532800_48000 5.356235
R1557 n1_m1_532800_48000 n1_m1_536000_48000 3.570824
R1558 n1_m1_537600_48000 n1_m1_536000_48000 1.785412
R1559 n1_m1_537600_48000 n1_m1_542400_48000 5.356235
R1560 n1_m1_542400_48000 n1_m1_547200_48000 5.356235
R1561 n1_m1_547200_48000 n1_m1_552000_48000 5.356235
R1562 n1_m1_552000_48000 n1_m1_556800_48000 5.356235
R1563 n1_m1_556800_48000 n1_m1_561600_48000 5.356235
R1564 n1_m1_561600_48000 n1_m1_564000_48000 2.678118
R1565 n1_m1_566400_48000 n1_m1_564000_48000 2.678118
R1566 n1_m1_566400_48000 n1_m1_571200_48000 5.356235
R1567 n1_m1_571200_48000 n1_m1_576000_48000 5.356235
R1568 n1_m1_576000_48000 n1_m1_580800_48000 5.356235
R1569 n1_m1_580800_48000 n1_m1_585600_48000 5.356235
R1570 n1_m1_585600_48000 n1_m1_590400_48000 5.356235
R1571 n1_m1_590400_48000 n1_m1_592000_48000 1.785412
R1572 n1_m1_595200_48000 n1_m1_592000_48000 3.570824
R1573 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1574 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1575 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1576 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1577 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1578 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1579 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1580 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1581 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1582 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1583 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1584 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1585 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1586 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1587 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1588 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1589 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1590 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1591 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1592 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1593 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1594 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1595 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1596 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1597 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1598 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1599 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1600 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1601 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1602 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1603 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1604 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1605 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1606 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1607 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1608 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1609 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1610 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1611 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1612 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1613 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1614 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1615 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1616 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1617 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1618 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1619 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1620 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1621 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1622 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1623 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1624 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1625 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1626 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1627 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1628 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1629 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1630 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1631 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1632 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1633 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1634 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1635 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1636 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1637 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1638 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1639 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1640 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1641 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1642 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1643 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1644 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1645 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1646 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1647 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1648 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1649 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1650 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1651 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1652 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1653 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1654 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1655 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1656 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1657 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1658 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1659 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1660 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1661 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1662 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1663 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1664 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1665 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1666 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1667 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1668 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1669 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1670 n1_m1_403200_52800 n1_m1_408000_52800 5.356235
R1671 n1_m1_408000_52800 n1_m1_412800_52800 5.356235
R1672 n1_m1_412800_52800 n1_m1_417600_52800 5.356235
R1673 n1_m1_417600_52800 n1_m1_422400_52800 5.356235
R1674 n1_m1_422400_52800 n1_m1_424000_52800 1.785412
R1675 n1_m1_427200_52800 n1_m1_424000_52800 3.570824
R1676 n1_m1_427200_52800 n1_m1_432000_52800 5.356235
R1677 n1_m1_432000_52800 n1_m1_436800_52800 5.356235
R1678 n1_m1_436800_52800 n1_m1_441600_52800 5.356235
R1679 n1_m1_441600_52800 n1_m1_446400_52800 5.356235
R1680 n1_m1_446400_52800 n1_m1_451200_52800 5.356235
R1681 n1_m1_451200_52800 n1_m1_452000_52800 0.892706
R1682 n1_m1_456000_52800 n1_m1_452000_52800 4.463529
R1683 n1_m1_456000_52800 n1_m1_460800_52800 5.356235
R1684 n1_m1_460800_52800 n1_m1_465600_52800 5.356235
R1685 n1_m1_465600_52800 n1_m1_470400_52800 5.356235
R1686 n1_m1_470400_52800 n1_m1_475200_52800 5.356235
R1687 n1_m1_475200_52800 n1_m1_480000_52800 5.356235
R1688 n1_m1_480000_52800 n1_m1_484800_52800 5.356235
R1689 n1_m1_484800_52800 n1_m1_489600_52800 5.356235
R1690 n1_m1_489600_52800 n1_m1_494400_52800 5.356235
R1691 n1_m1_494400_52800 n1_m1_499200_52800 5.356235
R1692 n1_m1_499200_52800 n1_m1_504000_52800 5.356235
R1693 n1_m1_504000_52800 n1_m1_508000_52800 4.463529
R1694 n1_m1_508800_52800 n1_m1_508000_52800 0.892706
R1695 n1_m1_508800_52800 n1_m1_513600_52800 5.356235
R1696 n1_m1_513600_52800 n1_m1_518400_52800 5.356235
R1697 n1_m1_518400_52800 n1_m1_523200_52800 5.356235
R1698 n1_m1_523200_52800 n1_m1_528000_52800 5.356235
R1699 n1_m1_528000_52800 n1_m1_532800_52800 5.356235
R1700 n1_m1_532800_52800 n1_m1_536000_52800 3.570824
R1701 n1_m1_537600_52800 n1_m1_536000_52800 1.785412
R1702 n1_m1_537600_52800 n1_m1_542400_52800 5.356235
R1703 n1_m1_542400_52800 n1_m1_547200_52800 5.356235
R1704 n1_m1_547200_52800 n1_m1_552000_52800 5.356235
R1705 n1_m1_552000_52800 n1_m1_556800_52800 5.356235
R1706 n1_m1_556800_52800 n1_m1_561600_52800 5.356235
R1707 n1_m1_561600_52800 n1_m1_564000_52800 2.678118
R1708 n1_m1_566400_52800 n1_m1_564000_52800 2.678118
R1709 n1_m1_566400_52800 n1_m1_571200_52800 5.356235
R1710 n1_m1_571200_52800 n1_m1_576000_52800 5.356235
R1711 n1_m1_576000_52800 n1_m1_580800_52800 5.356235
R1712 n1_m1_580800_52800 n1_m1_585600_52800 5.356235
R1713 n1_m1_585600_52800 n1_m1_590400_52800 5.356235
R1714 n1_m1_590400_52800 n1_m1_592000_52800 1.785412
R1715 n1_m1_595200_52800 n1_m1_592000_52800 3.570824
R1716 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1717 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1718 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1719 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1720 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1721 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1722 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1723 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1724 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1725 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1726 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1727 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1728 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1729 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1730 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1731 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1732 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1733 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1734 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1735 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1736 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1737 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1738 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1739 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1740 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1741 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1742 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1743 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1744 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1745 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1746 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1747 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1748 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1749 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1750 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1751 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1752 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1753 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1754 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1755 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1756 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1757 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1758 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1759 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1760 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1761 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1762 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1763 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1764 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1765 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1766 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1767 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1768 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1769 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1770 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1771 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1772 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1773 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1774 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1775 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1776 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1777 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1778 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1779 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1780 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1781 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1782 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1783 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1784 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1785 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1786 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1787 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1788 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1789 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1790 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1791 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1792 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1793 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1794 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1795 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1796 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1797 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1798 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1799 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1800 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1801 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1802 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1803 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1804 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1805 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1806 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1807 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1808 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1809 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1810 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1811 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1812 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1813 n1_m1_403200_57600 n1_m1_408000_57600 5.356235
R1814 n1_m1_408000_57600 n1_m1_412800_57600 5.356235
R1815 n1_m1_412800_57600 n1_m1_417600_57600 5.356235
R1816 n1_m1_417600_57600 n1_m1_422400_57600 5.356235
R1817 n1_m1_422400_57600 n1_m1_424000_57600 1.785412
R1818 n1_m1_427200_57600 n1_m1_424000_57600 3.570824
R1819 n1_m1_427200_57600 n1_m1_432000_57600 5.356235
R1820 n1_m1_432000_57600 n1_m1_436800_57600 5.356235
R1821 n1_m1_436800_57600 n1_m1_441600_57600 5.356235
R1822 n1_m1_441600_57600 n1_m1_446400_57600 5.356235
R1823 n1_m1_446400_57600 n1_m1_451200_57600 5.356235
R1824 n1_m1_451200_57600 n1_m1_452000_57600 0.892706
R1825 n1_m1_456000_57600 n1_m1_452000_57600 4.463529
R1826 n1_m1_456000_57600 n1_m1_460800_57600 5.356235
R1827 n1_m1_460800_57600 n1_m1_465600_57600 5.356235
R1828 n1_m1_465600_57600 n1_m1_470400_57600 5.356235
R1829 n1_m1_470400_57600 n1_m1_475200_57600 5.356235
R1830 n1_m1_475200_57600 n1_m1_480000_57600 5.356235
R1831 n1_m1_480000_57600 n1_m1_484800_57600 5.356235
R1832 n1_m1_484800_57600 n1_m1_489600_57600 5.356235
R1833 n1_m1_489600_57600 n1_m1_494400_57600 5.356235
R1834 n1_m1_494400_57600 n1_m1_499200_57600 5.356235
R1835 n1_m1_499200_57600 n1_m1_504000_57600 5.356235
R1836 n1_m1_504000_57600 n1_m1_508000_57600 4.463529
R1837 n1_m1_508800_57600 n1_m1_508000_57600 0.892706
R1838 n1_m1_508800_57600 n1_m1_513600_57600 5.356235
R1839 n1_m1_513600_57600 n1_m1_518400_57600 5.356235
R1840 n1_m1_518400_57600 n1_m1_523200_57600 5.356235
R1841 n1_m1_523200_57600 n1_m1_528000_57600 5.356235
R1842 n1_m1_528000_57600 n1_m1_532800_57600 5.356235
R1843 n1_m1_532800_57600 n1_m1_536000_57600 3.570824
R1844 n1_m1_537600_57600 n1_m1_536000_57600 1.785412
R1845 n1_m1_537600_57600 n1_m1_542400_57600 5.356235
R1846 n1_m1_542400_57600 n1_m1_547200_57600 5.356235
R1847 n1_m1_547200_57600 n1_m1_552000_57600 5.356235
R1848 n1_m1_552000_57600 n1_m1_556800_57600 5.356235
R1849 n1_m1_556800_57600 n1_m1_561600_57600 5.356235
R1850 n1_m1_561600_57600 n1_m1_564000_57600 2.678118
R1851 n1_m1_566400_57600 n1_m1_564000_57600 2.678118
R1852 n1_m1_566400_57600 n1_m1_571200_57600 5.356235
R1853 n1_m1_571200_57600 n1_m1_576000_57600 5.356235
R1854 n1_m1_576000_57600 n1_m1_580800_57600 5.356235
R1855 n1_m1_580800_57600 n1_m1_585600_57600 5.356235
R1856 n1_m1_585600_57600 n1_m1_590400_57600 5.356235
R1857 n1_m1_590400_57600 n1_m1_592000_57600 1.785412
R1858 n1_m1_595200_57600 n1_m1_592000_57600 3.570824
R1859 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1860 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1861 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1862 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1863 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1864 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1865 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1866 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1867 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1868 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1869 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1870 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1871 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1872 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1873 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1874 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1875 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1876 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1877 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1878 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1879 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1880 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1881 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1882 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1883 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1884 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1885 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1886 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1887 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1888 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1889 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1890 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1891 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1892 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1893 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1894 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1895 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1896 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1897 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1898 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1899 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1900 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1901 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1902 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1903 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1904 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1905 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1906 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1907 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1908 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1909 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1910 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1911 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1912 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1913 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1914 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1915 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1916 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1917 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1918 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1919 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1920 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1921 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1922 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1923 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1924 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1925 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1926 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1927 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1928 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1929 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1930 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1931 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1932 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1933 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1934 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1935 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1936 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1937 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1938 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1939 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1940 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1941 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1942 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1943 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1944 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1945 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1946 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1947 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1948 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1949 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1950 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1951 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1952 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1953 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1954 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1955 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1956 n1_m1_403200_62400 n1_m1_408000_62400 5.356235
R1957 n1_m1_408000_62400 n1_m1_412800_62400 5.356235
R1958 n1_m1_412800_62400 n1_m1_417600_62400 5.356235
R1959 n1_m1_417600_62400 n1_m1_422400_62400 5.356235
R1960 n1_m1_422400_62400 n1_m1_424000_62400 1.785412
R1961 n1_m1_427200_62400 n1_m1_424000_62400 3.570824
R1962 n1_m1_427200_62400 n1_m1_432000_62400 5.356235
R1963 n1_m1_432000_62400 n1_m1_436800_62400 5.356235
R1964 n1_m1_436800_62400 n1_m1_441600_62400 5.356235
R1965 n1_m1_441600_62400 n1_m1_446400_62400 5.356235
R1966 n1_m1_446400_62400 n1_m1_451200_62400 5.356235
R1967 n1_m1_451200_62400 n1_m1_452000_62400 0.892706
R1968 n1_m1_456000_62400 n1_m1_452000_62400 4.463529
R1969 n1_m1_456000_62400 n1_m1_460800_62400 5.356235
R1970 n1_m1_460800_62400 n1_m1_465600_62400 5.356235
R1971 n1_m1_465600_62400 n1_m1_470400_62400 5.356235
R1972 n1_m1_470400_62400 n1_m1_475200_62400 5.356235
R1973 n1_m1_475200_62400 n1_m1_480000_62400 5.356235
R1974 n1_m1_480000_62400 n1_m1_484800_62400 5.356235
R1975 n1_m1_484800_62400 n1_m1_489600_62400 5.356235
R1976 n1_m1_489600_62400 n1_m1_494400_62400 5.356235
R1977 n1_m1_494400_62400 n1_m1_499200_62400 5.356235
R1978 n1_m1_499200_62400 n1_m1_504000_62400 5.356235
R1979 n1_m1_504000_62400 n1_m1_508000_62400 4.463529
R1980 n1_m1_508800_62400 n1_m1_508000_62400 0.892706
R1981 n1_m1_508800_62400 n1_m1_513600_62400 5.356235
R1982 n1_m1_513600_62400 n1_m1_518400_62400 5.356235
R1983 n1_m1_518400_62400 n1_m1_523200_62400 5.356235
R1984 n1_m1_523200_62400 n1_m1_528000_62400 5.356235
R1985 n1_m1_528000_62400 n1_m1_532800_62400 5.356235
R1986 n1_m1_532800_62400 n1_m1_536000_62400 3.570824
R1987 n1_m1_537600_62400 n1_m1_536000_62400 1.785412
R1988 n1_m1_537600_62400 n1_m1_542400_62400 5.356235
R1989 n1_m1_542400_62400 n1_m1_547200_62400 5.356235
R1990 n1_m1_547200_62400 n1_m1_552000_62400 5.356235
R1991 n1_m1_552000_62400 n1_m1_556800_62400 5.356235
R1992 n1_m1_556800_62400 n1_m1_561600_62400 5.356235
R1993 n1_m1_561600_62400 n1_m1_564000_62400 2.678118
R1994 n1_m1_566400_62400 n1_m1_564000_62400 2.678118
R1995 n1_m1_566400_62400 n1_m1_571200_62400 5.356235
R1996 n1_m1_571200_62400 n1_m1_576000_62400 5.356235
R1997 n1_m1_576000_62400 n1_m1_580800_62400 5.356235
R1998 n1_m1_580800_62400 n1_m1_585600_62400 5.356235
R1999 n1_m1_585600_62400 n1_m1_590400_62400 5.356235
R2000 n1_m1_590400_62400 n1_m1_592000_62400 1.785412
R2001 n1_m1_595200_62400 n1_m1_592000_62400 3.570824
R2002 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R2003 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R2004 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R2005 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R2006 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R2007 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R2008 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R2009 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R2010 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R2011 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R2012 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R2013 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R2014 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R2015 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R2016 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R2017 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R2018 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R2019 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R2020 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R2021 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R2022 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R2023 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R2024 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R2025 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R2026 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R2027 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R2028 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R2029 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R2030 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R2031 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R2032 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R2033 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R2034 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R2035 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R2036 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R2037 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R2038 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R2039 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R2040 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R2041 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R2042 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R2043 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R2044 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R2045 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R2046 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R2047 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R2048 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R2049 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R2050 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R2051 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R2052 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R2053 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R2054 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R2055 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R2056 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R2057 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R2058 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R2059 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R2060 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R2061 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R2062 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R2063 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R2064 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R2065 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R2066 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R2067 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R2068 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R2069 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R2070 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R2071 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R2072 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R2073 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R2074 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R2075 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R2076 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R2077 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R2078 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R2079 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R2080 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R2081 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R2082 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R2083 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R2084 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R2085 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R2086 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R2087 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R2088 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R2089 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R2090 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R2091 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R2092 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R2093 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R2094 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R2095 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R2096 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R2097 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R2098 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R2099 n1_m1_403200_67200 n1_m1_408000_67200 5.356235
R2100 n1_m1_408000_67200 n1_m1_412800_67200 5.356235
R2101 n1_m1_412800_67200 n1_m1_417600_67200 5.356235
R2102 n1_m1_417600_67200 n1_m1_422400_67200 5.356235
R2103 n1_m1_422400_67200 n1_m1_424000_67200 1.785412
R2104 n1_m1_427200_67200 n1_m1_424000_67200 3.570824
R2105 n1_m1_427200_67200 n1_m1_432000_67200 5.356235
R2106 n1_m1_432000_67200 n1_m1_436800_67200 5.356235
R2107 n1_m1_436800_67200 n1_m1_441600_67200 5.356235
R2108 n1_m1_441600_67200 n1_m1_446400_67200 5.356235
R2109 n1_m1_446400_67200 n1_m1_451200_67200 5.356235
R2110 n1_m1_451200_67200 n1_m1_452000_67200 0.892706
R2111 n1_m1_456000_67200 n1_m1_452000_67200 4.463529
R2112 n1_m1_456000_67200 n1_m1_460800_67200 5.356235
R2113 n1_m1_460800_67200 n1_m1_465600_67200 5.356235
R2114 n1_m1_465600_67200 n1_m1_470400_67200 5.356235
R2115 n1_m1_470400_67200 n1_m1_475200_67200 5.356235
R2116 n1_m1_475200_67200 n1_m1_480000_67200 5.356235
R2117 n1_m1_480000_67200 n1_m1_484800_67200 5.356235
R2118 n1_m1_484800_67200 n1_m1_489600_67200 5.356235
R2119 n1_m1_489600_67200 n1_m1_494400_67200 5.356235
R2120 n1_m1_494400_67200 n1_m1_499200_67200 5.356235
R2121 n1_m1_499200_67200 n1_m1_504000_67200 5.356235
R2122 n1_m1_504000_67200 n1_m1_508000_67200 4.463529
R2123 n1_m1_508800_67200 n1_m1_508000_67200 0.892706
R2124 n1_m1_508800_67200 n1_m1_513600_67200 5.356235
R2125 n1_m1_513600_67200 n1_m1_518400_67200 5.356235
R2126 n1_m1_518400_67200 n1_m1_523200_67200 5.356235
R2127 n1_m1_523200_67200 n1_m1_528000_67200 5.356235
R2128 n1_m1_528000_67200 n1_m1_532800_67200 5.356235
R2129 n1_m1_532800_67200 n1_m1_536000_67200 3.570824
R2130 n1_m1_537600_67200 n1_m1_536000_67200 1.785412
R2131 n1_m1_537600_67200 n1_m1_542400_67200 5.356235
R2132 n1_m1_542400_67200 n1_m1_547200_67200 5.356235
R2133 n1_m1_547200_67200 n1_m1_552000_67200 5.356235
R2134 n1_m1_552000_67200 n1_m1_556800_67200 5.356235
R2135 n1_m1_556800_67200 n1_m1_561600_67200 5.356235
R2136 n1_m1_561600_67200 n1_m1_564000_67200 2.678118
R2137 n1_m1_566400_67200 n1_m1_564000_67200 2.678118
R2138 n1_m1_566400_67200 n1_m1_571200_67200 5.356235
R2139 n1_m1_571200_67200 n1_m1_576000_67200 5.356235
R2140 n1_m1_576000_67200 n1_m1_580800_67200 5.356235
R2141 n1_m1_580800_67200 n1_m1_585600_67200 5.356235
R2142 n1_m1_585600_67200 n1_m1_590400_67200 5.356235
R2143 n1_m1_590400_67200 n1_m1_592000_67200 1.785412
R2144 n1_m1_595200_67200 n1_m1_592000_67200 3.570824
R2145 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R2146 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R2147 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R2148 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R2149 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R2150 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R2151 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R2152 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R2153 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R2154 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R2155 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R2156 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R2157 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R2158 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R2159 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R2160 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R2161 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R2162 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R2163 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R2164 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R2165 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R2166 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R2167 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R2168 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R2169 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R2170 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R2171 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R2172 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R2173 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R2174 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R2175 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R2176 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R2177 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R2178 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R2179 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R2180 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R2181 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R2182 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R2183 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R2184 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R2185 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R2186 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R2187 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R2188 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R2189 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R2190 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R2191 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R2192 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R2193 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R2194 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R2195 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R2196 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R2197 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R2198 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R2199 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R2200 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R2201 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R2202 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R2203 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R2204 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R2205 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R2206 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R2207 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R2208 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R2209 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R2210 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R2211 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R2212 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R2213 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R2214 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R2215 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R2216 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R2217 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R2218 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R2219 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R2220 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R2221 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R2222 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R2223 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R2224 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R2225 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R2226 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R2227 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R2228 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R2229 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R2230 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R2231 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R2232 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R2233 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R2234 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R2235 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R2236 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R2237 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R2238 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R2239 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R2240 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R2241 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R2242 n1_m1_403200_72000 n1_m1_408000_72000 5.356235
R2243 n1_m1_408000_72000 n1_m1_412800_72000 5.356235
R2244 n1_m1_412800_72000 n1_m1_417600_72000 5.356235
R2245 n1_m1_417600_72000 n1_m1_422400_72000 5.356235
R2246 n1_m1_422400_72000 n1_m1_424000_72000 1.785412
R2247 n1_m1_427200_72000 n1_m1_424000_72000 3.570824
R2248 n1_m1_427200_72000 n1_m1_432000_72000 5.356235
R2249 n1_m1_432000_72000 n1_m1_436800_72000 5.356235
R2250 n1_m1_436800_72000 n1_m1_441600_72000 5.356235
R2251 n1_m1_441600_72000 n1_m1_446400_72000 5.356235
R2252 n1_m1_446400_72000 n1_m1_451200_72000 5.356235
R2253 n1_m1_451200_72000 n1_m1_452000_72000 0.892706
R2254 n1_m1_456000_72000 n1_m1_452000_72000 4.463529
R2255 n1_m1_456000_72000 n1_m1_460800_72000 5.356235
R2256 n1_m1_460800_72000 n1_m1_465600_72000 5.356235
R2257 n1_m1_465600_72000 n1_m1_470400_72000 5.356235
R2258 n1_m1_470400_72000 n1_m1_475200_72000 5.356235
R2259 n1_m1_475200_72000 n1_m1_480000_72000 5.356235
R2260 n1_m1_480000_72000 n1_m1_484800_72000 5.356235
R2261 n1_m1_484800_72000 n1_m1_489600_72000 5.356235
R2262 n1_m1_489600_72000 n1_m1_494400_72000 5.356235
R2263 n1_m1_494400_72000 n1_m1_499200_72000 5.356235
R2264 n1_m1_499200_72000 n1_m1_504000_72000 5.356235
R2265 n1_m1_504000_72000 n1_m1_508000_72000 4.463529
R2266 n1_m1_508800_72000 n1_m1_508000_72000 0.892706
R2267 n1_m1_508800_72000 n1_m1_513600_72000 5.356235
R2268 n1_m1_513600_72000 n1_m1_518400_72000 5.356235
R2269 n1_m1_518400_72000 n1_m1_523200_72000 5.356235
R2270 n1_m1_523200_72000 n1_m1_528000_72000 5.356235
R2271 n1_m1_528000_72000 n1_m1_532800_72000 5.356235
R2272 n1_m1_532800_72000 n1_m1_536000_72000 3.570824
R2273 n1_m1_537600_72000 n1_m1_536000_72000 1.785412
R2274 n1_m1_537600_72000 n1_m1_542400_72000 5.356235
R2275 n1_m1_542400_72000 n1_m1_547200_72000 5.356235
R2276 n1_m1_547200_72000 n1_m1_552000_72000 5.356235
R2277 n1_m1_552000_72000 n1_m1_556800_72000 5.356235
R2278 n1_m1_556800_72000 n1_m1_561600_72000 5.356235
R2279 n1_m1_561600_72000 n1_m1_564000_72000 2.678118
R2280 n1_m1_566400_72000 n1_m1_564000_72000 2.678118
R2281 n1_m1_566400_72000 n1_m1_571200_72000 5.356235
R2282 n1_m1_571200_72000 n1_m1_576000_72000 5.356235
R2283 n1_m1_576000_72000 n1_m1_580800_72000 5.356235
R2284 n1_m1_580800_72000 n1_m1_585600_72000 5.356235
R2285 n1_m1_585600_72000 n1_m1_590400_72000 5.356235
R2286 n1_m1_590400_72000 n1_m1_592000_72000 1.785412
R2287 n1_m1_595200_72000 n1_m1_592000_72000 3.570824
R2288 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R2289 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R2290 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R2291 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R2292 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R2293 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R2294 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R2295 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R2296 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R2297 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R2298 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R2299 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R2300 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R2301 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R2302 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R2303 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R2304 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R2305 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R2306 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R2307 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R2308 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R2309 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R2310 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R2311 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R2312 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R2313 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R2314 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R2315 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R2316 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R2317 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R2318 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R2319 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R2320 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R2321 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R2322 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R2323 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R2324 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R2325 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R2326 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R2327 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R2328 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R2329 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R2330 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R2331 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R2332 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R2333 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R2334 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R2335 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R2336 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R2337 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R2338 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R2339 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R2340 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R2341 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R2342 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R2343 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R2344 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R2345 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R2346 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R2347 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R2348 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R2349 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R2350 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R2351 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R2352 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R2353 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R2354 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R2355 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R2356 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R2357 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R2358 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R2359 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R2360 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R2361 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R2362 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R2363 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R2364 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R2365 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R2366 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R2367 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R2368 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R2369 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R2370 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R2371 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R2372 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R2373 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R2374 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R2375 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R2376 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R2377 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R2378 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R2379 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R2380 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R2381 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R2382 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R2383 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R2384 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R2385 n1_m1_403200_76800 n1_m1_408000_76800 5.356235
R2386 n1_m1_408000_76800 n1_m1_412800_76800 5.356235
R2387 n1_m1_412800_76800 n1_m1_417600_76800 5.356235
R2388 n1_m1_417600_76800 n1_m1_422400_76800 5.356235
R2389 n1_m1_422400_76800 n1_m1_424000_76800 1.785412
R2390 n1_m1_427200_76800 n1_m1_424000_76800 3.570824
R2391 n1_m1_427200_76800 n1_m1_432000_76800 5.356235
R2392 n1_m1_432000_76800 n1_m1_436800_76800 5.356235
R2393 n1_m1_436800_76800 n1_m1_441600_76800 5.356235
R2394 n1_m1_441600_76800 n1_m1_446400_76800 5.356235
R2395 n1_m1_446400_76800 n1_m1_451200_76800 5.356235
R2396 n1_m1_451200_76800 n1_m1_452000_76800 0.892706
R2397 n1_m1_456000_76800 n1_m1_452000_76800 4.463529
R2398 n1_m1_456000_76800 n1_m1_460800_76800 5.356235
R2399 n1_m1_460800_76800 n1_m1_465600_76800 5.356235
R2400 n1_m1_465600_76800 n1_m1_470400_76800 5.356235
R2401 n1_m1_470400_76800 n1_m1_475200_76800 5.356235
R2402 n1_m1_475200_76800 n1_m1_480000_76800 5.356235
R2403 n1_m1_480000_76800 n1_m1_484800_76800 5.356235
R2404 n1_m1_484800_76800 n1_m1_489600_76800 5.356235
R2405 n1_m1_489600_76800 n1_m1_494400_76800 5.356235
R2406 n1_m1_494400_76800 n1_m1_499200_76800 5.356235
R2407 n1_m1_499200_76800 n1_m1_504000_76800 5.356235
R2408 n1_m1_504000_76800 n1_m1_508000_76800 4.463529
R2409 n1_m1_508800_76800 n1_m1_508000_76800 0.892706
R2410 n1_m1_508800_76800 n1_m1_513600_76800 5.356235
R2411 n1_m1_513600_76800 n1_m1_518400_76800 5.356235
R2412 n1_m1_518400_76800 n1_m1_523200_76800 5.356235
R2413 n1_m1_523200_76800 n1_m1_528000_76800 5.356235
R2414 n1_m1_528000_76800 n1_m1_532800_76800 5.356235
R2415 n1_m1_532800_76800 n1_m1_536000_76800 3.570824
R2416 n1_m1_537600_76800 n1_m1_536000_76800 1.785412
R2417 n1_m1_537600_76800 n1_m1_542400_76800 5.356235
R2418 n1_m1_542400_76800 n1_m1_547200_76800 5.356235
R2419 n1_m1_547200_76800 n1_m1_552000_76800 5.356235
R2420 n1_m1_552000_76800 n1_m1_556800_76800 5.356235
R2421 n1_m1_556800_76800 n1_m1_561600_76800 5.356235
R2422 n1_m1_561600_76800 n1_m1_564000_76800 2.678118
R2423 n1_m1_566400_76800 n1_m1_564000_76800 2.678118
R2424 n1_m1_566400_76800 n1_m1_571200_76800 5.356235
R2425 n1_m1_571200_76800 n1_m1_576000_76800 5.356235
R2426 n1_m1_576000_76800 n1_m1_580800_76800 5.356235
R2427 n1_m1_580800_76800 n1_m1_585600_76800 5.356235
R2428 n1_m1_585600_76800 n1_m1_590400_76800 5.356235
R2429 n1_m1_590400_76800 n1_m1_592000_76800 1.785412
R2430 n1_m1_595200_76800 n1_m1_592000_76800 3.570824
R2431 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R2432 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R2433 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R2434 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R2435 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R2436 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R2437 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R2438 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R2439 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R2440 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R2441 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R2442 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R2443 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R2444 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R2445 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R2446 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R2447 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R2448 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R2449 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R2450 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R2451 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R2452 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R2453 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R2454 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R2455 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R2456 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R2457 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R2458 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R2459 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R2460 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R2461 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R2462 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R2463 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R2464 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R2465 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R2466 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R2467 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R2468 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R2469 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R2470 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R2471 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R2472 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R2473 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R2474 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R2475 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R2476 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R2477 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R2478 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R2479 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R2480 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R2481 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R2482 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R2483 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R2484 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R2485 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R2486 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R2487 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R2488 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R2489 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R2490 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R2491 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R2492 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R2493 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R2494 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R2495 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R2496 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R2497 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R2498 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R2499 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R2500 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R2501 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R2502 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R2503 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R2504 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R2505 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R2506 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R2507 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R2508 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R2509 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R2510 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R2511 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R2512 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R2513 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R2514 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R2515 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R2516 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R2517 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R2518 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R2519 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R2520 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R2521 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R2522 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R2523 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R2524 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R2525 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R2526 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R2527 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R2528 n1_m1_403200_81600 n1_m1_408000_81600 5.356235
R2529 n1_m1_408000_81600 n1_m1_412800_81600 5.356235
R2530 n1_m1_412800_81600 n1_m1_417600_81600 5.356235
R2531 n1_m1_417600_81600 n1_m1_422400_81600 5.356235
R2532 n1_m1_422400_81600 n1_m1_424000_81600 1.785412
R2533 n1_m1_427200_81600 n1_m1_424000_81600 3.570824
R2534 n1_m1_427200_81600 n1_m1_432000_81600 5.356235
R2535 n1_m1_432000_81600 n1_m1_436800_81600 5.356235
R2536 n1_m1_436800_81600 n1_m1_441600_81600 5.356235
R2537 n1_m1_441600_81600 n1_m1_446400_81600 5.356235
R2538 n1_m1_446400_81600 n1_m1_451200_81600 5.356235
R2539 n1_m1_451200_81600 n1_m1_452000_81600 0.892706
R2540 n1_m1_456000_81600 n1_m1_452000_81600 4.463529
R2541 n1_m1_456000_81600 n1_m1_460800_81600 5.356235
R2542 n1_m1_460800_81600 n1_m1_465600_81600 5.356235
R2543 n1_m1_465600_81600 n1_m1_470400_81600 5.356235
R2544 n1_m1_470400_81600 n1_m1_475200_81600 5.356235
R2545 n1_m1_475200_81600 n1_m1_480000_81600 5.356235
R2546 n1_m1_480000_81600 n1_m1_484800_81600 5.356235
R2547 n1_m1_484800_81600 n1_m1_489600_81600 5.356235
R2548 n1_m1_489600_81600 n1_m1_494400_81600 5.356235
R2549 n1_m1_494400_81600 n1_m1_499200_81600 5.356235
R2550 n1_m1_499200_81600 n1_m1_504000_81600 5.356235
R2551 n1_m1_504000_81600 n1_m1_508000_81600 4.463529
R2552 n1_m1_508800_81600 n1_m1_508000_81600 0.892706
R2553 n1_m1_508800_81600 n1_m1_513600_81600 5.356235
R2554 n1_m1_513600_81600 n1_m1_518400_81600 5.356235
R2555 n1_m1_518400_81600 n1_m1_523200_81600 5.356235
R2556 n1_m1_523200_81600 n1_m1_528000_81600 5.356235
R2557 n1_m1_528000_81600 n1_m1_532800_81600 5.356235
R2558 n1_m1_532800_81600 n1_m1_536000_81600 3.570824
R2559 n1_m1_537600_81600 n1_m1_536000_81600 1.785412
R2560 n1_m1_537600_81600 n1_m1_542400_81600 5.356235
R2561 n1_m1_542400_81600 n1_m1_547200_81600 5.356235
R2562 n1_m1_547200_81600 n1_m1_552000_81600 5.356235
R2563 n1_m1_552000_81600 n1_m1_556800_81600 5.356235
R2564 n1_m1_556800_81600 n1_m1_561600_81600 5.356235
R2565 n1_m1_561600_81600 n1_m1_564000_81600 2.678118
R2566 n1_m1_566400_81600 n1_m1_564000_81600 2.678118
R2567 n1_m1_566400_81600 n1_m1_571200_81600 5.356235
R2568 n1_m1_571200_81600 n1_m1_576000_81600 5.356235
R2569 n1_m1_576000_81600 n1_m1_580800_81600 5.356235
R2570 n1_m1_580800_81600 n1_m1_585600_81600 5.356235
R2571 n1_m1_585600_81600 n1_m1_590400_81600 5.356235
R2572 n1_m1_590400_81600 n1_m1_592000_81600 1.785412
R2573 n1_m1_595200_81600 n1_m1_592000_81600 3.570824
R2574 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R2575 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R2576 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R2577 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R2578 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R2579 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R2580 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R2581 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R2582 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R2583 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R2584 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R2585 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R2586 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R2587 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R2588 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R2589 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R2590 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R2591 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R2592 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R2593 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R2594 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R2595 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R2596 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R2597 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R2598 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R2599 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R2600 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R2601 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R2602 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R2603 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R2604 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R2605 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R2606 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R2607 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R2608 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R2609 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R2610 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R2611 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R2612 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R2613 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R2614 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R2615 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R2616 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R2617 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R2618 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R2619 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R2620 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R2621 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R2622 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R2623 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R2624 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R2625 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R2626 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R2627 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R2628 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R2629 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R2630 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R2631 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R2632 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R2633 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R2634 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R2635 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R2636 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R2637 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R2638 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R2639 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R2640 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R2641 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R2642 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R2643 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R2644 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R2645 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R2646 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R2647 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R2648 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R2649 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R2650 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R2651 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R2652 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R2653 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R2654 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R2655 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R2656 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R2657 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R2658 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R2659 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R2660 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R2661 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R2662 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R2663 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R2664 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R2665 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R2666 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R2667 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R2668 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R2669 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R2670 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R2671 n1_m1_403200_86400 n1_m1_408000_86400 5.356235
R2672 n1_m1_408000_86400 n1_m1_412800_86400 5.356235
R2673 n1_m1_412800_86400 n1_m1_417600_86400 5.356235
R2674 n1_m1_417600_86400 n1_m1_422400_86400 5.356235
R2675 n1_m1_422400_86400 n1_m1_424000_86400 1.785412
R2676 n1_m1_427200_86400 n1_m1_424000_86400 3.570824
R2677 n1_m1_427200_86400 n1_m1_432000_86400 5.356235
R2678 n1_m1_432000_86400 n1_m1_436800_86400 5.356235
R2679 n1_m1_436800_86400 n1_m1_441600_86400 5.356235
R2680 n1_m1_441600_86400 n1_m1_446400_86400 5.356235
R2681 n1_m1_446400_86400 n1_m1_451200_86400 5.356235
R2682 n1_m1_451200_86400 n1_m1_452000_86400 0.892706
R2683 n1_m1_456000_86400 n1_m1_452000_86400 4.463529
R2684 n1_m1_456000_86400 n1_m1_460800_86400 5.356235
R2685 n1_m1_460800_86400 n1_m1_465600_86400 5.356235
R2686 n1_m1_465600_86400 n1_m1_470400_86400 5.356235
R2687 n1_m1_470400_86400 n1_m1_475200_86400 5.356235
R2688 n1_m1_475200_86400 n1_m1_480000_86400 5.356235
R2689 n1_m1_480000_86400 n1_m1_484800_86400 5.356235
R2690 n1_m1_484800_86400 n1_m1_489600_86400 5.356235
R2691 n1_m1_489600_86400 n1_m1_494400_86400 5.356235
R2692 n1_m1_494400_86400 n1_m1_499200_86400 5.356235
R2693 n1_m1_499200_86400 n1_m1_504000_86400 5.356235
R2694 n1_m1_504000_86400 n1_m1_508000_86400 4.463529
R2695 n1_m1_508800_86400 n1_m1_508000_86400 0.892706
R2696 n1_m1_508800_86400 n1_m1_513600_86400 5.356235
R2697 n1_m1_513600_86400 n1_m1_518400_86400 5.356235
R2698 n1_m1_518400_86400 n1_m1_523200_86400 5.356235
R2699 n1_m1_523200_86400 n1_m1_528000_86400 5.356235
R2700 n1_m1_528000_86400 n1_m1_532800_86400 5.356235
R2701 n1_m1_532800_86400 n1_m1_536000_86400 3.570824
R2702 n1_m1_537600_86400 n1_m1_536000_86400 1.785412
R2703 n1_m1_537600_86400 n1_m1_542400_86400 5.356235
R2704 n1_m1_542400_86400 n1_m1_547200_86400 5.356235
R2705 n1_m1_547200_86400 n1_m1_552000_86400 5.356235
R2706 n1_m1_552000_86400 n1_m1_556800_86400 5.356235
R2707 n1_m1_556800_86400 n1_m1_561600_86400 5.356235
R2708 n1_m1_561600_86400 n1_m1_564000_86400 2.678118
R2709 n1_m1_566400_86400 n1_m1_564000_86400 2.678118
R2710 n1_m1_566400_86400 n1_m1_571200_86400 5.356235
R2711 n1_m1_571200_86400 n1_m1_576000_86400 5.356235
R2712 n1_m1_576000_86400 n1_m1_580800_86400 5.356235
R2713 n1_m1_580800_86400 n1_m1_585600_86400 5.356235
R2714 n1_m1_585600_86400 n1_m1_590400_86400 5.356235
R2715 n1_m1_590400_86400 n1_m1_592000_86400 1.785412
R2716 n1_m1_595200_86400 n1_m1_592000_86400 3.570824
R2717 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R2718 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R2719 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R2720 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R2721 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R2722 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R2723 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R2724 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R2725 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R2726 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R2727 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R2728 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R2729 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R2730 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R2731 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R2732 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R2733 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R2734 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R2735 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R2736 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R2737 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R2738 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R2739 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R2740 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R2741 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R2742 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R2743 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R2744 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R2745 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R2746 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R2747 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R2748 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R2749 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R2750 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R2751 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R2752 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R2753 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R2754 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R2755 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R2756 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R2757 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R2758 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R2759 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R2760 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R2761 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R2762 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R2763 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R2764 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R2765 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R2766 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R2767 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R2768 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R2769 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R2770 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R2771 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R2772 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R2773 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R2774 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R2775 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R2776 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R2777 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R2778 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R2779 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R2780 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R2781 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R2782 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R2783 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R2784 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R2785 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R2786 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R2787 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R2788 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R2789 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R2790 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R2791 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R2792 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R2793 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R2794 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R2795 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R2796 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R2797 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R2798 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R2799 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R2800 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R2801 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R2802 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R2803 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R2804 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R2805 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R2806 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R2807 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R2808 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R2809 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R2810 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R2811 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R2812 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R2813 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R2814 n1_m1_403200_91200 n1_m1_408000_91200 5.356235
R2815 n1_m1_408000_91200 n1_m1_412800_91200 5.356235
R2816 n1_m1_412800_91200 n1_m1_417600_91200 5.356235
R2817 n1_m1_417600_91200 n1_m1_422400_91200 5.356235
R2818 n1_m1_422400_91200 n1_m1_424000_91200 1.785412
R2819 n1_m1_427200_91200 n1_m1_424000_91200 3.570824
R2820 n1_m1_427200_91200 n1_m1_432000_91200 5.356235
R2821 n1_m1_432000_91200 n1_m1_436800_91200 5.356235
R2822 n1_m1_436800_91200 n1_m1_441600_91200 5.356235
R2823 n1_m1_441600_91200 n1_m1_446400_91200 5.356235
R2824 n1_m1_446400_91200 n1_m1_451200_91200 5.356235
R2825 n1_m1_451200_91200 n1_m1_452000_91200 0.892706
R2826 n1_m1_456000_91200 n1_m1_452000_91200 4.463529
R2827 n1_m1_456000_91200 n1_m1_460800_91200 5.356235
R2828 n1_m1_460800_91200 n1_m1_465600_91200 5.356235
R2829 n1_m1_465600_91200 n1_m1_470400_91200 5.356235
R2830 n1_m1_470400_91200 n1_m1_475200_91200 5.356235
R2831 n1_m1_475200_91200 n1_m1_480000_91200 5.356235
R2832 n1_m1_480000_91200 n1_m1_484800_91200 5.356235
R2833 n1_m1_484800_91200 n1_m1_489600_91200 5.356235
R2834 n1_m1_489600_91200 n1_m1_494400_91200 5.356235
R2835 n1_m1_494400_91200 n1_m1_499200_91200 5.356235
R2836 n1_m1_499200_91200 n1_m1_504000_91200 5.356235
R2837 n1_m1_504000_91200 n1_m1_508000_91200 4.463529
R2838 n1_m1_508800_91200 n1_m1_508000_91200 0.892706
R2839 n1_m1_508800_91200 n1_m1_513600_91200 5.356235
R2840 n1_m1_513600_91200 n1_m1_518400_91200 5.356235
R2841 n1_m1_518400_91200 n1_m1_523200_91200 5.356235
R2842 n1_m1_523200_91200 n1_m1_528000_91200 5.356235
R2843 n1_m1_528000_91200 n1_m1_532800_91200 5.356235
R2844 n1_m1_532800_91200 n1_m1_536000_91200 3.570824
R2845 n1_m1_537600_91200 n1_m1_536000_91200 1.785412
R2846 n1_m1_537600_91200 n1_m1_542400_91200 5.356235
R2847 n1_m1_542400_91200 n1_m1_547200_91200 5.356235
R2848 n1_m1_547200_91200 n1_m1_552000_91200 5.356235
R2849 n1_m1_552000_91200 n1_m1_556800_91200 5.356235
R2850 n1_m1_556800_91200 n1_m1_561600_91200 5.356235
R2851 n1_m1_561600_91200 n1_m1_564000_91200 2.678118
R2852 n1_m1_566400_91200 n1_m1_564000_91200 2.678118
R2853 n1_m1_566400_91200 n1_m1_571200_91200 5.356235
R2854 n1_m1_571200_91200 n1_m1_576000_91200 5.356235
R2855 n1_m1_576000_91200 n1_m1_580800_91200 5.356235
R2856 n1_m1_580800_91200 n1_m1_585600_91200 5.356235
R2857 n1_m1_585600_91200 n1_m1_590400_91200 5.356235
R2858 n1_m1_590400_91200 n1_m1_592000_91200 1.785412
R2859 n1_m1_595200_91200 n1_m1_592000_91200 3.570824
R2860 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R2861 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R2862 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R2863 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R2864 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R2865 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R2866 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R2867 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R2868 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R2869 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R2870 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R2871 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R2872 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R2873 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R2874 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R2875 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R2876 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R2877 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R2878 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R2879 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R2880 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R2881 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R2882 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R2883 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R2884 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R2885 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R2886 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R2887 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R2888 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R2889 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R2890 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R2891 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R2892 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R2893 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R2894 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R2895 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R2896 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R2897 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R2898 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R2899 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R2900 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R2901 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R2902 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R2903 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R2904 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R2905 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R2906 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R2907 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R2908 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R2909 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R2910 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R2911 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R2912 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R2913 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R2914 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R2915 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R2916 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R2917 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R2918 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R2919 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2920 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2921 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2922 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2923 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2924 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2925 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2926 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2927 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2928 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2929 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2930 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2931 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2932 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2933 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2934 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2935 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2936 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2937 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2938 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2939 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2940 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2941 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2942 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2943 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2944 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2945 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2946 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2947 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2948 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2949 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2950 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2951 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2952 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2953 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2954 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2955 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2956 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2957 n1_m1_403200_96000 n1_m1_408000_96000 5.356235
R2958 n1_m1_408000_96000 n1_m1_412800_96000 5.356235
R2959 n1_m1_412800_96000 n1_m1_417600_96000 5.356235
R2960 n1_m1_417600_96000 n1_m1_422400_96000 5.356235
R2961 n1_m1_422400_96000 n1_m1_424000_96000 1.785412
R2962 n1_m1_427200_96000 n1_m1_424000_96000 3.570824
R2963 n1_m1_427200_96000 n1_m1_432000_96000 5.356235
R2964 n1_m1_432000_96000 n1_m1_436800_96000 5.356235
R2965 n1_m1_436800_96000 n1_m1_441600_96000 5.356235
R2966 n1_m1_441600_96000 n1_m1_446400_96000 5.356235
R2967 n1_m1_446400_96000 n1_m1_451200_96000 5.356235
R2968 n1_m1_451200_96000 n1_m1_452000_96000 0.892706
R2969 n1_m1_456000_96000 n1_m1_452000_96000 4.463529
R2970 n1_m1_456000_96000 n1_m1_460800_96000 5.356235
R2971 n1_m1_460800_96000 n1_m1_465600_96000 5.356235
R2972 n1_m1_465600_96000 n1_m1_470400_96000 5.356235
R2973 n1_m1_470400_96000 n1_m1_475200_96000 5.356235
R2974 n1_m1_475200_96000 n1_m1_480000_96000 5.356235
R2975 n1_m1_480000_96000 n1_m1_484800_96000 5.356235
R2976 n1_m1_484800_96000 n1_m1_489600_96000 5.356235
R2977 n1_m1_489600_96000 n1_m1_494400_96000 5.356235
R2978 n1_m1_494400_96000 n1_m1_499200_96000 5.356235
R2979 n1_m1_499200_96000 n1_m1_504000_96000 5.356235
R2980 n1_m1_504000_96000 n1_m1_508000_96000 4.463529
R2981 n1_m1_508800_96000 n1_m1_508000_96000 0.892706
R2982 n1_m1_508800_96000 n1_m1_513600_96000 5.356235
R2983 n1_m1_513600_96000 n1_m1_518400_96000 5.356235
R2984 n1_m1_518400_96000 n1_m1_523200_96000 5.356235
R2985 n1_m1_523200_96000 n1_m1_528000_96000 5.356235
R2986 n1_m1_528000_96000 n1_m1_532800_96000 5.356235
R2987 n1_m1_532800_96000 n1_m1_536000_96000 3.570824
R2988 n1_m1_537600_96000 n1_m1_536000_96000 1.785412
R2989 n1_m1_537600_96000 n1_m1_542400_96000 5.356235
R2990 n1_m1_542400_96000 n1_m1_547200_96000 5.356235
R2991 n1_m1_547200_96000 n1_m1_552000_96000 5.356235
R2992 n1_m1_552000_96000 n1_m1_556800_96000 5.356235
R2993 n1_m1_556800_96000 n1_m1_561600_96000 5.356235
R2994 n1_m1_561600_96000 n1_m1_564000_96000 2.678118
R2995 n1_m1_566400_96000 n1_m1_564000_96000 2.678118
R2996 n1_m1_566400_96000 n1_m1_571200_96000 5.356235
R2997 n1_m1_571200_96000 n1_m1_576000_96000 5.356235
R2998 n1_m1_576000_96000 n1_m1_580800_96000 5.356235
R2999 n1_m1_580800_96000 n1_m1_585600_96000 5.356235
R3000 n1_m1_585600_96000 n1_m1_590400_96000 5.356235
R3001 n1_m1_590400_96000 n1_m1_592000_96000 1.785412
R3002 n1_m1_595200_96000 n1_m1_592000_96000 3.570824
R3003 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R3004 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R3005 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R3006 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R3007 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R3008 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R3009 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R3010 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R3011 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R3012 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R3013 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R3014 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R3015 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R3016 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R3017 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R3018 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R3019 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R3020 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R3021 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R3022 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R3023 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R3024 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R3025 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R3026 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R3027 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R3028 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R3029 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R3030 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R3031 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R3032 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R3033 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R3034 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R3035 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R3036 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R3037 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R3038 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R3039 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R3040 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R3041 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R3042 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R3043 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R3044 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R3045 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R3046 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R3047 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R3048 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R3049 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R3050 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R3051 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R3052 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R3053 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R3054 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R3055 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R3056 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R3057 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R3058 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R3059 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R3060 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R3061 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R3062 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R3063 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R3064 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R3065 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R3066 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R3067 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R3068 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R3069 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R3070 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R3071 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R3072 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R3073 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R3074 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R3075 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R3076 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R3077 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R3078 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R3079 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R3080 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R3081 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R3082 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R3083 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R3084 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R3085 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R3086 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R3087 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R3088 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R3089 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R3090 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R3091 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R3092 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R3093 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R3094 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R3095 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R3096 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R3097 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R3098 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R3099 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R3100 n1_m1_403200_100800 n1_m1_408000_100800 5.356235
R3101 n1_m1_408000_100800 n1_m1_412800_100800 5.356235
R3102 n1_m1_412800_100800 n1_m1_417600_100800 5.356235
R3103 n1_m1_417600_100800 n1_m1_422400_100800 5.356235
R3104 n1_m1_422400_100800 n1_m1_424000_100800 1.785412
R3105 n1_m1_427200_100800 n1_m1_424000_100800 3.570824
R3106 n1_m1_427200_100800 n1_m1_432000_100800 5.356235
R3107 n1_m1_432000_100800 n1_m1_436800_100800 5.356235
R3108 n1_m1_436800_100800 n1_m1_441600_100800 5.356235
R3109 n1_m1_441600_100800 n1_m1_446400_100800 5.356235
R3110 n1_m1_446400_100800 n1_m1_451200_100800 5.356235
R3111 n1_m1_451200_100800 n1_m1_452000_100800 0.892706
R3112 n1_m1_456000_100800 n1_m1_452000_100800 4.463529
R3113 n1_m1_456000_100800 n1_m1_460800_100800 5.356235
R3114 n1_m1_460800_100800 n1_m1_465600_100800 5.356235
R3115 n1_m1_465600_100800 n1_m1_470400_100800 5.356235
R3116 n1_m1_470400_100800 n1_m1_475200_100800 5.356235
R3117 n1_m1_475200_100800 n1_m1_480000_100800 5.356235
R3118 n1_m1_480000_100800 n1_m1_484800_100800 5.356235
R3119 n1_m1_484800_100800 n1_m1_489600_100800 5.356235
R3120 n1_m1_489600_100800 n1_m1_494400_100800 5.356235
R3121 n1_m1_494400_100800 n1_m1_499200_100800 5.356235
R3122 n1_m1_499200_100800 n1_m1_504000_100800 5.356235
R3123 n1_m1_504000_100800 n1_m1_508000_100800 4.463529
R3124 n1_m1_508800_100800 n1_m1_508000_100800 0.892706
R3125 n1_m1_508800_100800 n1_m1_513600_100800 5.356235
R3126 n1_m1_513600_100800 n1_m1_518400_100800 5.356235
R3127 n1_m1_518400_100800 n1_m1_523200_100800 5.356235
R3128 n1_m1_523200_100800 n1_m1_528000_100800 5.356235
R3129 n1_m1_528000_100800 n1_m1_532800_100800 5.356235
R3130 n1_m1_532800_100800 n1_m1_536000_100800 3.570824
R3131 n1_m1_537600_100800 n1_m1_536000_100800 1.785412
R3132 n1_m1_537600_100800 n1_m1_542400_100800 5.356235
R3133 n1_m1_542400_100800 n1_m1_547200_100800 5.356235
R3134 n1_m1_547200_100800 n1_m1_552000_100800 5.356235
R3135 n1_m1_552000_100800 n1_m1_556800_100800 5.356235
R3136 n1_m1_556800_100800 n1_m1_561600_100800 5.356235
R3137 n1_m1_561600_100800 n1_m1_564000_100800 2.678118
R3138 n1_m1_566400_100800 n1_m1_564000_100800 2.678118
R3139 n1_m1_566400_100800 n1_m1_571200_100800 5.356235
R3140 n1_m1_571200_100800 n1_m1_576000_100800 5.356235
R3141 n1_m1_576000_100800 n1_m1_580800_100800 5.356235
R3142 n1_m1_580800_100800 n1_m1_585600_100800 5.356235
R3143 n1_m1_585600_100800 n1_m1_590400_100800 5.356235
R3144 n1_m1_590400_100800 n1_m1_592000_100800 1.785412
R3145 n1_m1_595200_100800 n1_m1_592000_100800 3.570824
R3146 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R3147 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R3148 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R3149 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R3150 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R3151 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R3152 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R3153 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R3154 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R3155 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R3156 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R3157 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R3158 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R3159 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R3160 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R3161 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R3162 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R3163 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R3164 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R3165 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R3166 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R3167 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R3168 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R3169 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R3170 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R3171 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R3172 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R3173 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R3174 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R3175 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R3176 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R3177 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R3178 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R3179 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R3180 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R3181 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R3182 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R3183 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R3184 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R3185 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R3186 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R3187 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R3188 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R3189 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R3190 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R3191 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R3192 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R3193 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R3194 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R3195 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R3196 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R3197 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R3198 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R3199 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R3200 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R3201 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R3202 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R3203 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R3204 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R3205 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R3206 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R3207 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R3208 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R3209 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R3210 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R3211 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R3212 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R3213 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R3214 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R3215 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R3216 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R3217 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R3218 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R3219 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R3220 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R3221 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R3222 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R3223 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R3224 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R3225 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R3226 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R3227 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R3228 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R3229 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R3230 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R3231 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R3232 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R3233 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R3234 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R3235 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R3236 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R3237 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R3238 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R3239 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R3240 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R3241 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R3242 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R3243 n1_m1_403200_105600 n1_m1_408000_105600 5.356235
R3244 n1_m1_408000_105600 n1_m1_412800_105600 5.356235
R3245 n1_m1_412800_105600 n1_m1_417600_105600 5.356235
R3246 n1_m1_417600_105600 n1_m1_422400_105600 5.356235
R3247 n1_m1_422400_105600 n1_m1_424000_105600 1.785412
R3248 n1_m1_427200_105600 n1_m1_424000_105600 3.570824
R3249 n1_m1_427200_105600 n1_m1_432000_105600 5.356235
R3250 n1_m1_432000_105600 n1_m1_436800_105600 5.356235
R3251 n1_m1_436800_105600 n1_m1_441600_105600 5.356235
R3252 n1_m1_441600_105600 n1_m1_446400_105600 5.356235
R3253 n1_m1_446400_105600 n1_m1_451200_105600 5.356235
R3254 n1_m1_451200_105600 n1_m1_452000_105600 0.892706
R3255 n1_m1_456000_105600 n1_m1_452000_105600 4.463529
R3256 n1_m1_456000_105600 n1_m1_460800_105600 5.356235
R3257 n1_m1_460800_105600 n1_m1_465600_105600 5.356235
R3258 n1_m1_465600_105600 n1_m1_470400_105600 5.356235
R3259 n1_m1_470400_105600 n1_m1_475200_105600 5.356235
R3260 n1_m1_475200_105600 n1_m1_480000_105600 5.356235
R3261 n1_m1_480000_105600 n1_m1_484800_105600 5.356235
R3262 n1_m1_484800_105600 n1_m1_489600_105600 5.356235
R3263 n1_m1_489600_105600 n1_m1_494400_105600 5.356235
R3264 n1_m1_494400_105600 n1_m1_499200_105600 5.356235
R3265 n1_m1_499200_105600 n1_m1_504000_105600 5.356235
R3266 n1_m1_504000_105600 n1_m1_508000_105600 4.463529
R3267 n1_m1_508800_105600 n1_m1_508000_105600 0.892706
R3268 n1_m1_508800_105600 n1_m1_513600_105600 5.356235
R3269 n1_m1_513600_105600 n1_m1_518400_105600 5.356235
R3270 n1_m1_518400_105600 n1_m1_523200_105600 5.356235
R3271 n1_m1_523200_105600 n1_m1_528000_105600 5.356235
R3272 n1_m1_528000_105600 n1_m1_532800_105600 5.356235
R3273 n1_m1_532800_105600 n1_m1_536000_105600 3.570824
R3274 n1_m1_537600_105600 n1_m1_536000_105600 1.785412
R3275 n1_m1_537600_105600 n1_m1_542400_105600 5.356235
R3276 n1_m1_542400_105600 n1_m1_547200_105600 5.356235
R3277 n1_m1_547200_105600 n1_m1_552000_105600 5.356235
R3278 n1_m1_552000_105600 n1_m1_556800_105600 5.356235
R3279 n1_m1_556800_105600 n1_m1_561600_105600 5.356235
R3280 n1_m1_561600_105600 n1_m1_564000_105600 2.678118
R3281 n1_m1_566400_105600 n1_m1_564000_105600 2.678118
R3282 n1_m1_566400_105600 n1_m1_571200_105600 5.356235
R3283 n1_m1_571200_105600 n1_m1_576000_105600 5.356235
R3284 n1_m1_576000_105600 n1_m1_580800_105600 5.356235
R3285 n1_m1_580800_105600 n1_m1_585600_105600 5.356235
R3286 n1_m1_585600_105600 n1_m1_590400_105600 5.356235
R3287 n1_m1_590400_105600 n1_m1_592000_105600 1.785412
R3288 n1_m1_595200_105600 n1_m1_592000_105600 3.570824
R3289 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R3290 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R3291 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R3292 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R3293 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R3294 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R3295 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R3296 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R3297 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R3298 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R3299 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R3300 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R3301 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R3302 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R3303 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R3304 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R3305 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R3306 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R3307 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R3308 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R3309 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R3310 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R3311 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R3312 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R3313 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R3314 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R3315 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R3316 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R3317 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R3318 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R3319 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R3320 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R3321 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R3322 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R3323 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R3324 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R3325 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R3326 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R3327 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R3328 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R3329 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R3330 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R3331 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R3332 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R3333 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R3334 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R3335 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R3336 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R3337 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R3338 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R3339 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R3340 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R3341 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R3342 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R3343 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R3344 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R3345 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R3346 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R3347 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R3348 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R3349 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R3350 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R3351 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R3352 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R3353 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R3354 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R3355 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R3356 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R3357 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R3358 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R3359 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R3360 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R3361 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R3362 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R3363 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R3364 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R3365 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R3366 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R3367 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R3368 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R3369 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R3370 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R3371 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R3372 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R3373 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R3374 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R3375 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R3376 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R3377 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R3378 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R3379 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R3380 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R3381 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R3382 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R3383 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R3384 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R3385 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R3386 n1_m1_403200_110400 n1_m1_408000_110400 5.356235
R3387 n1_m1_408000_110400 n1_m1_412800_110400 5.356235
R3388 n1_m1_412800_110400 n1_m1_417600_110400 5.356235
R3389 n1_m1_417600_110400 n1_m1_422400_110400 5.356235
R3390 n1_m1_422400_110400 n1_m1_424000_110400 1.785412
R3391 n1_m1_427200_110400 n1_m1_424000_110400 3.570824
R3392 n1_m1_427200_110400 n1_m1_432000_110400 5.356235
R3393 n1_m1_432000_110400 n1_m1_436800_110400 5.356235
R3394 n1_m1_436800_110400 n1_m1_441600_110400 5.356235
R3395 n1_m1_441600_110400 n1_m1_446400_110400 5.356235
R3396 n1_m1_446400_110400 n1_m1_451200_110400 5.356235
R3397 n1_m1_451200_110400 n1_m1_452000_110400 0.892706
R3398 n1_m1_456000_110400 n1_m1_452000_110400 4.463529
R3399 n1_m1_456000_110400 n1_m1_460800_110400 5.356235
R3400 n1_m1_460800_110400 n1_m1_465600_110400 5.356235
R3401 n1_m1_465600_110400 n1_m1_470400_110400 5.356235
R3402 n1_m1_470400_110400 n1_m1_475200_110400 5.356235
R3403 n1_m1_475200_110400 n1_m1_480000_110400 5.356235
R3404 n1_m1_480000_110400 n1_m1_484800_110400 5.356235
R3405 n1_m1_484800_110400 n1_m1_489600_110400 5.356235
R3406 n1_m1_489600_110400 n1_m1_494400_110400 5.356235
R3407 n1_m1_494400_110400 n1_m1_499200_110400 5.356235
R3408 n1_m1_499200_110400 n1_m1_504000_110400 5.356235
R3409 n1_m1_504000_110400 n1_m1_508000_110400 4.463529
R3410 n1_m1_508800_110400 n1_m1_508000_110400 0.892706
R3411 n1_m1_508800_110400 n1_m1_513600_110400 5.356235
R3412 n1_m1_513600_110400 n1_m1_518400_110400 5.356235
R3413 n1_m1_518400_110400 n1_m1_523200_110400 5.356235
R3414 n1_m1_523200_110400 n1_m1_528000_110400 5.356235
R3415 n1_m1_528000_110400 n1_m1_532800_110400 5.356235
R3416 n1_m1_532800_110400 n1_m1_536000_110400 3.570824
R3417 n1_m1_537600_110400 n1_m1_536000_110400 1.785412
R3418 n1_m1_537600_110400 n1_m1_542400_110400 5.356235
R3419 n1_m1_542400_110400 n1_m1_547200_110400 5.356235
R3420 n1_m1_547200_110400 n1_m1_552000_110400 5.356235
R3421 n1_m1_552000_110400 n1_m1_556800_110400 5.356235
R3422 n1_m1_556800_110400 n1_m1_561600_110400 5.356235
R3423 n1_m1_561600_110400 n1_m1_564000_110400 2.678118
R3424 n1_m1_566400_110400 n1_m1_564000_110400 2.678118
R3425 n1_m1_566400_110400 n1_m1_571200_110400 5.356235
R3426 n1_m1_571200_110400 n1_m1_576000_110400 5.356235
R3427 n1_m1_576000_110400 n1_m1_580800_110400 5.356235
R3428 n1_m1_580800_110400 n1_m1_585600_110400 5.356235
R3429 n1_m1_585600_110400 n1_m1_590400_110400 5.356235
R3430 n1_m1_590400_110400 n1_m1_592000_110400 1.785412
R3431 n1_m1_595200_110400 n1_m1_592000_110400 3.570824
R3432 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R3433 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R3434 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R3435 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R3436 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R3437 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R3438 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R3439 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R3440 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R3441 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R3442 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R3443 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R3444 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R3445 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R3446 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R3447 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R3448 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R3449 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R3450 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R3451 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R3452 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R3453 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R3454 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R3455 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R3456 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R3457 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R3458 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R3459 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R3460 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R3461 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R3462 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R3463 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R3464 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R3465 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R3466 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R3467 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R3468 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R3469 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R3470 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R3471 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R3472 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R3473 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R3474 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R3475 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R3476 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R3477 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R3478 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R3479 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R3480 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R3481 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R3482 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R3483 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R3484 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R3485 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R3486 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R3487 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R3488 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R3489 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R3490 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R3491 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R3492 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R3493 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R3494 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R3495 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R3496 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R3497 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R3498 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R3499 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R3500 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R3501 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R3502 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R3503 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R3504 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R3505 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R3506 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R3507 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R3508 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R3509 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R3510 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R3511 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R3512 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R3513 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R3514 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R3515 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R3516 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R3517 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R3518 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R3519 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R3520 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R3521 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R3522 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R3523 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R3524 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R3525 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R3526 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R3527 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R3528 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R3529 n1_m1_403200_115200 n1_m1_408000_115200 5.356235
R3530 n1_m1_408000_115200 n1_m1_412800_115200 5.356235
R3531 n1_m1_412800_115200 n1_m1_417600_115200 5.356235
R3532 n1_m1_417600_115200 n1_m1_422400_115200 5.356235
R3533 n1_m1_422400_115200 n1_m1_424000_115200 1.785412
R3534 n1_m1_427200_115200 n1_m1_424000_115200 3.570824
R3535 n1_m1_427200_115200 n1_m1_432000_115200 5.356235
R3536 n1_m1_432000_115200 n1_m1_436800_115200 5.356235
R3537 n1_m1_436800_115200 n1_m1_441600_115200 5.356235
R3538 n1_m1_441600_115200 n1_m1_446400_115200 5.356235
R3539 n1_m1_446400_115200 n1_m1_451200_115200 5.356235
R3540 n1_m1_451200_115200 n1_m1_452000_115200 0.892706
R3541 n1_m1_456000_115200 n1_m1_452000_115200 4.463529
R3542 n1_m1_456000_115200 n1_m1_460800_115200 5.356235
R3543 n1_m1_460800_115200 n1_m1_465600_115200 5.356235
R3544 n1_m1_465600_115200 n1_m1_470400_115200 5.356235
R3545 n1_m1_470400_115200 n1_m1_475200_115200 5.356235
R3546 n1_m1_475200_115200 n1_m1_480000_115200 5.356235
R3547 n1_m1_480000_115200 n1_m1_484800_115200 5.356235
R3548 n1_m1_484800_115200 n1_m1_489600_115200 5.356235
R3549 n1_m1_489600_115200 n1_m1_494400_115200 5.356235
R3550 n1_m1_494400_115200 n1_m1_499200_115200 5.356235
R3551 n1_m1_499200_115200 n1_m1_504000_115200 5.356235
R3552 n1_m1_504000_115200 n1_m1_508000_115200 4.463529
R3553 n1_m1_508800_115200 n1_m1_508000_115200 0.892706
R3554 n1_m1_508800_115200 n1_m1_513600_115200 5.356235
R3555 n1_m1_513600_115200 n1_m1_518400_115200 5.356235
R3556 n1_m1_518400_115200 n1_m1_523200_115200 5.356235
R3557 n1_m1_523200_115200 n1_m1_528000_115200 5.356235
R3558 n1_m1_528000_115200 n1_m1_532800_115200 5.356235
R3559 n1_m1_532800_115200 n1_m1_536000_115200 3.570824
R3560 n1_m1_537600_115200 n1_m1_536000_115200 1.785412
R3561 n1_m1_537600_115200 n1_m1_542400_115200 5.356235
R3562 n1_m1_542400_115200 n1_m1_547200_115200 5.356235
R3563 n1_m1_547200_115200 n1_m1_552000_115200 5.356235
R3564 n1_m1_552000_115200 n1_m1_556800_115200 5.356235
R3565 n1_m1_556800_115200 n1_m1_561600_115200 5.356235
R3566 n1_m1_561600_115200 n1_m1_564000_115200 2.678118
R3567 n1_m1_566400_115200 n1_m1_564000_115200 2.678118
R3568 n1_m1_566400_115200 n1_m1_571200_115200 5.356235
R3569 n1_m1_571200_115200 n1_m1_576000_115200 5.356235
R3570 n1_m1_576000_115200 n1_m1_580800_115200 5.356235
R3571 n1_m1_580800_115200 n1_m1_585600_115200 5.356235
R3572 n1_m1_585600_115200 n1_m1_590400_115200 5.356235
R3573 n1_m1_590400_115200 n1_m1_592000_115200 1.785412
R3574 n1_m1_595200_115200 n1_m1_592000_115200 3.570824
R3575 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R3576 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R3577 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R3578 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R3579 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R3580 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R3581 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R3582 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R3583 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R3584 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R3585 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R3586 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R3587 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R3588 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R3589 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R3590 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R3591 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R3592 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R3593 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R3594 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R3595 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R3596 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R3597 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R3598 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R3599 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R3600 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R3601 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R3602 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R3603 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R3604 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R3605 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R3606 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R3607 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R3608 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R3609 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R3610 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R3611 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R3612 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R3613 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R3614 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R3615 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R3616 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R3617 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R3618 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R3619 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R3620 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R3621 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R3622 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R3623 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R3624 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R3625 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R3626 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R3627 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R3628 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R3629 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R3630 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R3631 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R3632 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R3633 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R3634 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R3635 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R3636 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R3637 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R3638 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R3639 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R3640 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R3641 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R3642 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R3643 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R3644 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R3645 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R3646 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R3647 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R3648 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R3649 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R3650 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R3651 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R3652 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R3653 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R3654 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R3655 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R3656 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R3657 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R3658 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R3659 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R3660 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R3661 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R3662 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R3663 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R3664 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R3665 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R3666 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R3667 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R3668 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R3669 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R3670 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R3671 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R3672 n1_m1_403200_120000 n1_m1_408000_120000 5.356235
R3673 n1_m1_408000_120000 n1_m1_412800_120000 5.356235
R3674 n1_m1_412800_120000 n1_m1_417600_120000 5.356235
R3675 n1_m1_417600_120000 n1_m1_422400_120000 5.356235
R3676 n1_m1_422400_120000 n1_m1_424000_120000 1.785412
R3677 n1_m1_427200_120000 n1_m1_424000_120000 3.570824
R3678 n1_m1_427200_120000 n1_m1_432000_120000 5.356235
R3679 n1_m1_432000_120000 n1_m1_436800_120000 5.356235
R3680 n1_m1_436800_120000 n1_m1_441600_120000 5.356235
R3681 n1_m1_441600_120000 n1_m1_446400_120000 5.356235
R3682 n1_m1_446400_120000 n1_m1_451200_120000 5.356235
R3683 n1_m1_451200_120000 n1_m1_452000_120000 0.892706
R3684 n1_m1_456000_120000 n1_m1_452000_120000 4.463529
R3685 n1_m1_456000_120000 n1_m1_460800_120000 5.356235
R3686 n1_m1_460800_120000 n1_m1_465600_120000 5.356235
R3687 n1_m1_465600_120000 n1_m1_470400_120000 5.356235
R3688 n1_m1_470400_120000 n1_m1_475200_120000 5.356235
R3689 n1_m1_475200_120000 n1_m1_480000_120000 5.356235
R3690 n1_m1_480000_120000 n1_m1_484800_120000 5.356235
R3691 n1_m1_484800_120000 n1_m1_489600_120000 5.356235
R3692 n1_m1_489600_120000 n1_m1_494400_120000 5.356235
R3693 n1_m1_494400_120000 n1_m1_499200_120000 5.356235
R3694 n1_m1_499200_120000 n1_m1_504000_120000 5.356235
R3695 n1_m1_504000_120000 n1_m1_508000_120000 4.463529
R3696 n1_m1_508800_120000 n1_m1_508000_120000 0.892706
R3697 n1_m1_508800_120000 n1_m1_513600_120000 5.356235
R3698 n1_m1_513600_120000 n1_m1_518400_120000 5.356235
R3699 n1_m1_518400_120000 n1_m1_523200_120000 5.356235
R3700 n1_m1_523200_120000 n1_m1_528000_120000 5.356235
R3701 n1_m1_528000_120000 n1_m1_532800_120000 5.356235
R3702 n1_m1_532800_120000 n1_m1_536000_120000 3.570824
R3703 n1_m1_537600_120000 n1_m1_536000_120000 1.785412
R3704 n1_m1_537600_120000 n1_m1_542400_120000 5.356235
R3705 n1_m1_542400_120000 n1_m1_547200_120000 5.356235
R3706 n1_m1_547200_120000 n1_m1_552000_120000 5.356235
R3707 n1_m1_552000_120000 n1_m1_556800_120000 5.356235
R3708 n1_m1_556800_120000 n1_m1_561600_120000 5.356235
R3709 n1_m1_561600_120000 n1_m1_564000_120000 2.678118
R3710 n1_m1_566400_120000 n1_m1_564000_120000 2.678118
R3711 n1_m1_566400_120000 n1_m1_571200_120000 5.356235
R3712 n1_m1_571200_120000 n1_m1_576000_120000 5.356235
R3713 n1_m1_576000_120000 n1_m1_580800_120000 5.356235
R3714 n1_m1_580800_120000 n1_m1_585600_120000 5.356235
R3715 n1_m1_585600_120000 n1_m1_590400_120000 5.356235
R3716 n1_m1_590400_120000 n1_m1_592000_120000 1.785412
R3717 n1_m1_595200_120000 n1_m1_592000_120000 3.570824
R3718 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R3719 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R3720 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R3721 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R3722 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R3723 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R3724 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R3725 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R3726 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R3727 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R3728 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R3729 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R3730 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R3731 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R3732 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R3733 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R3734 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R3735 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R3736 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R3737 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R3738 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R3739 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R3740 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R3741 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R3742 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R3743 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R3744 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R3745 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R3746 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R3747 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R3748 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R3749 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R3750 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R3751 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R3752 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R3753 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R3754 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R3755 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R3756 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R3757 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R3758 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R3759 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R3760 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R3761 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R3762 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R3763 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R3764 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R3765 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R3766 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R3767 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R3768 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R3769 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R3770 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R3771 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R3772 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R3773 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R3774 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R3775 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R3776 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R3777 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R3778 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R3779 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R3780 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R3781 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R3782 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R3783 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R3784 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R3785 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R3786 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R3787 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R3788 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R3789 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R3790 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R3791 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R3792 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R3793 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R3794 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R3795 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R3796 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R3797 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R3798 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R3799 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R3800 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R3801 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R3802 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R3803 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R3804 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R3805 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R3806 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R3807 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R3808 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R3809 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R3810 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R3811 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R3812 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R3813 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R3814 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R3815 n1_m1_403200_124800 n1_m1_408000_124800 5.356235
R3816 n1_m1_408000_124800 n1_m1_412800_124800 5.356235
R3817 n1_m1_412800_124800 n1_m1_417600_124800 5.356235
R3818 n1_m1_417600_124800 n1_m1_422400_124800 5.356235
R3819 n1_m1_422400_124800 n1_m1_424000_124800 1.785412
R3820 n1_m1_427200_124800 n1_m1_424000_124800 3.570824
R3821 n1_m1_427200_124800 n1_m1_432000_124800 5.356235
R3822 n1_m1_432000_124800 n1_m1_436800_124800 5.356235
R3823 n1_m1_436800_124800 n1_m1_441600_124800 5.356235
R3824 n1_m1_441600_124800 n1_m1_446400_124800 5.356235
R3825 n1_m1_446400_124800 n1_m1_451200_124800 5.356235
R3826 n1_m1_451200_124800 n1_m1_452000_124800 0.892706
R3827 n1_m1_456000_124800 n1_m1_452000_124800 4.463529
R3828 n1_m1_456000_124800 n1_m1_460800_124800 5.356235
R3829 n1_m1_460800_124800 n1_m1_465600_124800 5.356235
R3830 n1_m1_465600_124800 n1_m1_470400_124800 5.356235
R3831 n1_m1_470400_124800 n1_m1_475200_124800 5.356235
R3832 n1_m1_475200_124800 n1_m1_480000_124800 5.356235
R3833 n1_m1_480000_124800 n1_m1_484800_124800 5.356235
R3834 n1_m1_484800_124800 n1_m1_489600_124800 5.356235
R3835 n1_m1_489600_124800 n1_m1_494400_124800 5.356235
R3836 n1_m1_494400_124800 n1_m1_499200_124800 5.356235
R3837 n1_m1_499200_124800 n1_m1_504000_124800 5.356235
R3838 n1_m1_504000_124800 n1_m1_508000_124800 4.463529
R3839 n1_m1_508800_124800 n1_m1_508000_124800 0.892706
R3840 n1_m1_508800_124800 n1_m1_513600_124800 5.356235
R3841 n1_m1_513600_124800 n1_m1_518400_124800 5.356235
R3842 n1_m1_518400_124800 n1_m1_523200_124800 5.356235
R3843 n1_m1_523200_124800 n1_m1_528000_124800 5.356235
R3844 n1_m1_528000_124800 n1_m1_532800_124800 5.356235
R3845 n1_m1_532800_124800 n1_m1_536000_124800 3.570824
R3846 n1_m1_537600_124800 n1_m1_536000_124800 1.785412
R3847 n1_m1_537600_124800 n1_m1_542400_124800 5.356235
R3848 n1_m1_542400_124800 n1_m1_547200_124800 5.356235
R3849 n1_m1_547200_124800 n1_m1_552000_124800 5.356235
R3850 n1_m1_552000_124800 n1_m1_556800_124800 5.356235
R3851 n1_m1_556800_124800 n1_m1_561600_124800 5.356235
R3852 n1_m1_561600_124800 n1_m1_564000_124800 2.678118
R3853 n1_m1_566400_124800 n1_m1_564000_124800 2.678118
R3854 n1_m1_566400_124800 n1_m1_571200_124800 5.356235
R3855 n1_m1_571200_124800 n1_m1_576000_124800 5.356235
R3856 n1_m1_576000_124800 n1_m1_580800_124800 5.356235
R3857 n1_m1_580800_124800 n1_m1_585600_124800 5.356235
R3858 n1_m1_585600_124800 n1_m1_590400_124800 5.356235
R3859 n1_m1_590400_124800 n1_m1_592000_124800 1.785412
R3860 n1_m1_595200_124800 n1_m1_592000_124800 3.570824
R3861 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R3862 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R3863 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R3864 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R3865 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R3866 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R3867 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R3868 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R3869 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R3870 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R3871 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R3872 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R3873 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R3874 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R3875 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R3876 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R3877 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R3878 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R3879 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R3880 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R3881 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R3882 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R3883 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R3884 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R3885 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R3886 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R3887 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R3888 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R3889 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R3890 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R3891 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R3892 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R3893 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R3894 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R3895 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R3896 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R3897 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R3898 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R3899 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R3900 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R3901 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R3902 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R3903 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R3904 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R3905 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R3906 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R3907 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R3908 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R3909 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R3910 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R3911 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R3912 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R3913 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R3914 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R3915 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R3916 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R3917 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R3918 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R3919 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R3920 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R3921 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R3922 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R3923 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R3924 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R3925 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R3926 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R3927 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R3928 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R3929 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R3930 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R3931 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R3932 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R3933 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R3934 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R3935 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R3936 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R3937 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R3938 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R3939 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R3940 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R3941 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R3942 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R3943 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R3944 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R3945 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R3946 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R3947 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R3948 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R3949 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R3950 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R3951 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R3952 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R3953 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R3954 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R3955 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R3956 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R3957 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R3958 n1_m1_403200_129600 n1_m1_408000_129600 5.356235
R3959 n1_m1_408000_129600 n1_m1_412800_129600 5.356235
R3960 n1_m1_412800_129600 n1_m1_417600_129600 5.356235
R3961 n1_m1_417600_129600 n1_m1_422400_129600 5.356235
R3962 n1_m1_422400_129600 n1_m1_424000_129600 1.785412
R3963 n1_m1_427200_129600 n1_m1_424000_129600 3.570824
R3964 n1_m1_427200_129600 n1_m1_432000_129600 5.356235
R3965 n1_m1_432000_129600 n1_m1_436800_129600 5.356235
R3966 n1_m1_436800_129600 n1_m1_441600_129600 5.356235
R3967 n1_m1_441600_129600 n1_m1_446400_129600 5.356235
R3968 n1_m1_446400_129600 n1_m1_451200_129600 5.356235
R3969 n1_m1_451200_129600 n1_m1_452000_129600 0.892706
R3970 n1_m1_456000_129600 n1_m1_452000_129600 4.463529
R3971 n1_m1_456000_129600 n1_m1_460800_129600 5.356235
R3972 n1_m1_460800_129600 n1_m1_465600_129600 5.356235
R3973 n1_m1_465600_129600 n1_m1_470400_129600 5.356235
R3974 n1_m1_470400_129600 n1_m1_475200_129600 5.356235
R3975 n1_m1_475200_129600 n1_m1_480000_129600 5.356235
R3976 n1_m1_480000_129600 n1_m1_484800_129600 5.356235
R3977 n1_m1_484800_129600 n1_m1_489600_129600 5.356235
R3978 n1_m1_489600_129600 n1_m1_494400_129600 5.356235
R3979 n1_m1_494400_129600 n1_m1_499200_129600 5.356235
R3980 n1_m1_499200_129600 n1_m1_504000_129600 5.356235
R3981 n1_m1_504000_129600 n1_m1_508000_129600 4.463529
R3982 n1_m1_508800_129600 n1_m1_508000_129600 0.892706
R3983 n1_m1_508800_129600 n1_m1_513600_129600 5.356235
R3984 n1_m1_513600_129600 n1_m1_518400_129600 5.356235
R3985 n1_m1_518400_129600 n1_m1_523200_129600 5.356235
R3986 n1_m1_523200_129600 n1_m1_528000_129600 5.356235
R3987 n1_m1_528000_129600 n1_m1_532800_129600 5.356235
R3988 n1_m1_532800_129600 n1_m1_536000_129600 3.570824
R3989 n1_m1_537600_129600 n1_m1_536000_129600 1.785412
R3990 n1_m1_537600_129600 n1_m1_542400_129600 5.356235
R3991 n1_m1_542400_129600 n1_m1_547200_129600 5.356235
R3992 n1_m1_547200_129600 n1_m1_552000_129600 5.356235
R3993 n1_m1_552000_129600 n1_m1_556800_129600 5.356235
R3994 n1_m1_556800_129600 n1_m1_561600_129600 5.356235
R3995 n1_m1_561600_129600 n1_m1_564000_129600 2.678118
R3996 n1_m1_566400_129600 n1_m1_564000_129600 2.678118
R3997 n1_m1_566400_129600 n1_m1_571200_129600 5.356235
R3998 n1_m1_571200_129600 n1_m1_576000_129600 5.356235
R3999 n1_m1_576000_129600 n1_m1_580800_129600 5.356235
R4000 n1_m1_580800_129600 n1_m1_585600_129600 5.356235
R4001 n1_m1_585600_129600 n1_m1_590400_129600 5.356235
R4002 n1_m1_590400_129600 n1_m1_592000_129600 1.785412
R4003 n1_m1_595200_129600 n1_m1_592000_129600 3.570824
R4004 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R4005 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R4006 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R4007 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R4008 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R4009 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R4010 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R4011 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R4012 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R4013 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R4014 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R4015 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R4016 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R4017 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R4018 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R4019 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R4020 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R4021 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R4022 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R4023 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R4024 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R4025 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R4026 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R4027 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R4028 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R4029 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R4030 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R4031 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R4032 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R4033 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R4034 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R4035 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R4036 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R4037 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R4038 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R4039 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R4040 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R4041 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R4042 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R4043 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R4044 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R4045 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R4046 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R4047 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R4048 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R4049 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R4050 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R4051 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R4052 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R4053 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R4054 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R4055 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R4056 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R4057 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R4058 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R4059 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R4060 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R4061 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R4062 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R4063 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R4064 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R4065 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R4066 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R4067 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R4068 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R4069 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R4070 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R4071 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R4072 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R4073 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R4074 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R4075 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R4076 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R4077 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R4078 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R4079 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R4080 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R4081 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R4082 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R4083 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R4084 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R4085 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R4086 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R4087 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R4088 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R4089 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R4090 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R4091 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R4092 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R4093 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R4094 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R4095 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R4096 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R4097 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R4098 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R4099 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R4100 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R4101 n1_m1_403200_134400 n1_m1_408000_134400 5.356235
R4102 n1_m1_408000_134400 n1_m1_412800_134400 5.356235
R4103 n1_m1_412800_134400 n1_m1_417600_134400 5.356235
R4104 n1_m1_417600_134400 n1_m1_422400_134400 5.356235
R4105 n1_m1_422400_134400 n1_m1_424000_134400 1.785412
R4106 n1_m1_427200_134400 n1_m1_424000_134400 3.570824
R4107 n1_m1_427200_134400 n1_m1_432000_134400 5.356235
R4108 n1_m1_432000_134400 n1_m1_436800_134400 5.356235
R4109 n1_m1_436800_134400 n1_m1_441600_134400 5.356235
R4110 n1_m1_441600_134400 n1_m1_446400_134400 5.356235
R4111 n1_m1_446400_134400 n1_m1_451200_134400 5.356235
R4112 n1_m1_451200_134400 n1_m1_452000_134400 0.892706
R4113 n1_m1_456000_134400 n1_m1_452000_134400 4.463529
R4114 n1_m1_456000_134400 n1_m1_460800_134400 5.356235
R4115 n1_m1_460800_134400 n1_m1_465600_134400 5.356235
R4116 n1_m1_465600_134400 n1_m1_470400_134400 5.356235
R4117 n1_m1_470400_134400 n1_m1_475200_134400 5.356235
R4118 n1_m1_475200_134400 n1_m1_480000_134400 5.356235
R4119 n1_m1_480000_134400 n1_m1_484800_134400 5.356235
R4120 n1_m1_484800_134400 n1_m1_489600_134400 5.356235
R4121 n1_m1_489600_134400 n1_m1_494400_134400 5.356235
R4122 n1_m1_494400_134400 n1_m1_499200_134400 5.356235
R4123 n1_m1_499200_134400 n1_m1_504000_134400 5.356235
R4124 n1_m1_504000_134400 n1_m1_508000_134400 4.463529
R4125 n1_m1_508800_134400 n1_m1_508000_134400 0.892706
R4126 n1_m1_508800_134400 n1_m1_513600_134400 5.356235
R4127 n1_m1_513600_134400 n1_m1_518400_134400 5.356235
R4128 n1_m1_518400_134400 n1_m1_523200_134400 5.356235
R4129 n1_m1_523200_134400 n1_m1_528000_134400 5.356235
R4130 n1_m1_528000_134400 n1_m1_532800_134400 5.356235
R4131 n1_m1_532800_134400 n1_m1_536000_134400 3.570824
R4132 n1_m1_537600_134400 n1_m1_536000_134400 1.785412
R4133 n1_m1_537600_134400 n1_m1_542400_134400 5.356235
R4134 n1_m1_542400_134400 n1_m1_547200_134400 5.356235
R4135 n1_m1_547200_134400 n1_m1_552000_134400 5.356235
R4136 n1_m1_552000_134400 n1_m1_556800_134400 5.356235
R4137 n1_m1_556800_134400 n1_m1_561600_134400 5.356235
R4138 n1_m1_561600_134400 n1_m1_564000_134400 2.678118
R4139 n1_m1_566400_134400 n1_m1_564000_134400 2.678118
R4140 n1_m1_566400_134400 n1_m1_571200_134400 5.356235
R4141 n1_m1_571200_134400 n1_m1_576000_134400 5.356235
R4142 n1_m1_576000_134400 n1_m1_580800_134400 5.356235
R4143 n1_m1_580800_134400 n1_m1_585600_134400 5.356235
R4144 n1_m1_585600_134400 n1_m1_590400_134400 5.356235
R4145 n1_m1_590400_134400 n1_m1_592000_134400 1.785412
R4146 n1_m1_595200_134400 n1_m1_592000_134400 3.570824
R4147 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R4148 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R4149 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R4150 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R4151 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R4152 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R4153 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R4154 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R4155 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R4156 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R4157 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R4158 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R4159 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R4160 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R4161 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R4162 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R4163 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R4164 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R4165 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R4166 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R4167 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R4168 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R4169 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R4170 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R4171 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R4172 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R4173 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R4174 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R4175 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R4176 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R4177 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R4178 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R4179 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R4180 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R4181 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R4182 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R4183 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R4184 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R4185 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R4186 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R4187 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R4188 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R4189 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R4190 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R4191 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R4192 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R4193 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R4194 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R4195 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R4196 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R4197 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R4198 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R4199 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R4200 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R4201 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R4202 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R4203 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R4204 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R4205 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R4206 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R4207 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R4208 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R4209 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R4210 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R4211 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R4212 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R4213 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R4214 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R4215 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R4216 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R4217 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R4218 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R4219 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R4220 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R4221 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R4222 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R4223 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R4224 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R4225 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R4226 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R4227 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R4228 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R4229 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R4230 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R4231 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R4232 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R4233 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R4234 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R4235 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R4236 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R4237 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R4238 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R4239 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R4240 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R4241 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R4242 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R4243 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R4244 n1_m1_403200_139200 n1_m1_408000_139200 5.356235
R4245 n1_m1_408000_139200 n1_m1_412800_139200 5.356235
R4246 n1_m1_412800_139200 n1_m1_417600_139200 5.356235
R4247 n1_m1_417600_139200 n1_m1_422400_139200 5.356235
R4248 n1_m1_422400_139200 n1_m1_424000_139200 1.785412
R4249 n1_m1_427200_139200 n1_m1_424000_139200 3.570824
R4250 n1_m1_427200_139200 n1_m1_432000_139200 5.356235
R4251 n1_m1_432000_139200 n1_m1_436800_139200 5.356235
R4252 n1_m1_436800_139200 n1_m1_441600_139200 5.356235
R4253 n1_m1_441600_139200 n1_m1_446400_139200 5.356235
R4254 n1_m1_446400_139200 n1_m1_451200_139200 5.356235
R4255 n1_m1_451200_139200 n1_m1_452000_139200 0.892706
R4256 n1_m1_456000_139200 n1_m1_452000_139200 4.463529
R4257 n1_m1_456000_139200 n1_m1_460800_139200 5.356235
R4258 n1_m1_460800_139200 n1_m1_465600_139200 5.356235
R4259 n1_m1_465600_139200 n1_m1_470400_139200 5.356235
R4260 n1_m1_470400_139200 n1_m1_475200_139200 5.356235
R4261 n1_m1_475200_139200 n1_m1_480000_139200 5.356235
R4262 n1_m1_480000_139200 n1_m1_484800_139200 5.356235
R4263 n1_m1_484800_139200 n1_m1_489600_139200 5.356235
R4264 n1_m1_489600_139200 n1_m1_494400_139200 5.356235
R4265 n1_m1_494400_139200 n1_m1_499200_139200 5.356235
R4266 n1_m1_499200_139200 n1_m1_504000_139200 5.356235
R4267 n1_m1_504000_139200 n1_m1_508000_139200 4.463529
R4268 n1_m1_508800_139200 n1_m1_508000_139200 0.892706
R4269 n1_m1_508800_139200 n1_m1_513600_139200 5.356235
R4270 n1_m1_513600_139200 n1_m1_518400_139200 5.356235
R4271 n1_m1_518400_139200 n1_m1_523200_139200 5.356235
R4272 n1_m1_523200_139200 n1_m1_528000_139200 5.356235
R4273 n1_m1_528000_139200 n1_m1_532800_139200 5.356235
R4274 n1_m1_532800_139200 n1_m1_536000_139200 3.570824
R4275 n1_m1_537600_139200 n1_m1_536000_139200 1.785412
R4276 n1_m1_537600_139200 n1_m1_542400_139200 5.356235
R4277 n1_m1_542400_139200 n1_m1_547200_139200 5.356235
R4278 n1_m1_547200_139200 n1_m1_552000_139200 5.356235
R4279 n1_m1_552000_139200 n1_m1_556800_139200 5.356235
R4280 n1_m1_556800_139200 n1_m1_561600_139200 5.356235
R4281 n1_m1_561600_139200 n1_m1_564000_139200 2.678118
R4282 n1_m1_566400_139200 n1_m1_564000_139200 2.678118
R4283 n1_m1_566400_139200 n1_m1_571200_139200 5.356235
R4284 n1_m1_571200_139200 n1_m1_576000_139200 5.356235
R4285 n1_m1_576000_139200 n1_m1_580800_139200 5.356235
R4286 n1_m1_580800_139200 n1_m1_585600_139200 5.356235
R4287 n1_m1_585600_139200 n1_m1_590400_139200 5.356235
R4288 n1_m1_590400_139200 n1_m1_592000_139200 1.785412
R4289 n1_m1_595200_139200 n1_m1_592000_139200 3.570824
R4290 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R4291 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R4292 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R4293 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R4294 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R4295 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R4296 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R4297 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R4298 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R4299 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R4300 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R4301 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R4302 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R4303 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R4304 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R4305 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R4306 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R4307 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R4308 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R4309 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R4310 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R4311 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R4312 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R4313 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R4314 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R4315 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R4316 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R4317 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R4318 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R4319 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R4320 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R4321 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R4322 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R4323 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R4324 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R4325 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R4326 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R4327 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R4328 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R4329 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R4330 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R4331 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R4332 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R4333 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R4334 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R4335 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R4336 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R4337 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R4338 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R4339 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R4340 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R4341 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R4342 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R4343 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R4344 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R4345 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R4346 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R4347 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R4348 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R4349 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R4350 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R4351 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R4352 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R4353 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R4354 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R4355 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R4356 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R4357 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R4358 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R4359 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R4360 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R4361 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R4362 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R4363 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R4364 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R4365 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R4366 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R4367 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R4368 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R4369 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R4370 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R4371 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R4372 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R4373 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R4374 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R4375 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R4376 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R4377 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R4378 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R4379 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R4380 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R4381 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R4382 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R4383 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R4384 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R4385 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R4386 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R4387 n1_m1_403200_144000 n1_m1_408000_144000 5.356235
R4388 n1_m1_408000_144000 n1_m1_412800_144000 5.356235
R4389 n1_m1_412800_144000 n1_m1_417600_144000 5.356235
R4390 n1_m1_417600_144000 n1_m1_422400_144000 5.356235
R4391 n1_m1_422400_144000 n1_m1_424000_144000 1.785412
R4392 n1_m1_427200_144000 n1_m1_424000_144000 3.570824
R4393 n1_m1_427200_144000 n1_m1_432000_144000 5.356235
R4394 n1_m1_432000_144000 n1_m1_436800_144000 5.356235
R4395 n1_m1_436800_144000 n1_m1_441600_144000 5.356235
R4396 n1_m1_441600_144000 n1_m1_446400_144000 5.356235
R4397 n1_m1_446400_144000 n1_m1_451200_144000 5.356235
R4398 n1_m1_451200_144000 n1_m1_452000_144000 0.892706
R4399 n1_m1_456000_144000 n1_m1_452000_144000 4.463529
R4400 n1_m1_456000_144000 n1_m1_460800_144000 5.356235
R4401 n1_m1_460800_144000 n1_m1_465600_144000 5.356235
R4402 n1_m1_465600_144000 n1_m1_470400_144000 5.356235
R4403 n1_m1_470400_144000 n1_m1_475200_144000 5.356235
R4404 n1_m1_475200_144000 n1_m1_480000_144000 5.356235
R4405 n1_m1_480000_144000 n1_m1_484800_144000 5.356235
R4406 n1_m1_484800_144000 n1_m1_489600_144000 5.356235
R4407 n1_m1_489600_144000 n1_m1_494400_144000 5.356235
R4408 n1_m1_494400_144000 n1_m1_499200_144000 5.356235
R4409 n1_m1_499200_144000 n1_m1_504000_144000 5.356235
R4410 n1_m1_504000_144000 n1_m1_508000_144000 4.463529
R4411 n1_m1_508800_144000 n1_m1_508000_144000 0.892706
R4412 n1_m1_508800_144000 n1_m1_513600_144000 5.356235
R4413 n1_m1_513600_144000 n1_m1_518400_144000 5.356235
R4414 n1_m1_518400_144000 n1_m1_523200_144000 5.356235
R4415 n1_m1_523200_144000 n1_m1_528000_144000 5.356235
R4416 n1_m1_528000_144000 n1_m1_532800_144000 5.356235
R4417 n1_m1_532800_144000 n1_m1_536000_144000 3.570824
R4418 n1_m1_537600_144000 n1_m1_536000_144000 1.785412
R4419 n1_m1_537600_144000 n1_m1_542400_144000 5.356235
R4420 n1_m1_542400_144000 n1_m1_547200_144000 5.356235
R4421 n1_m1_547200_144000 n1_m1_552000_144000 5.356235
R4422 n1_m1_552000_144000 n1_m1_556800_144000 5.356235
R4423 n1_m1_556800_144000 n1_m1_561600_144000 5.356235
R4424 n1_m1_561600_144000 n1_m1_564000_144000 2.678118
R4425 n1_m1_566400_144000 n1_m1_564000_144000 2.678118
R4426 n1_m1_566400_144000 n1_m1_571200_144000 5.356235
R4427 n1_m1_571200_144000 n1_m1_576000_144000 5.356235
R4428 n1_m1_576000_144000 n1_m1_580800_144000 5.356235
R4429 n1_m1_580800_144000 n1_m1_585600_144000 5.356235
R4430 n1_m1_585600_144000 n1_m1_590400_144000 5.356235
R4431 n1_m1_590400_144000 n1_m1_592000_144000 1.785412
R4432 n1_m1_595200_144000 n1_m1_592000_144000 3.570824
R4433 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R4434 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R4435 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R4436 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R4437 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R4438 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R4439 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R4440 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R4441 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R4442 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R4443 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R4444 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R4445 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R4446 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R4447 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R4448 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R4449 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R4450 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R4451 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R4452 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R4453 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R4454 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R4455 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R4456 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R4457 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R4458 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R4459 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R4460 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R4461 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R4462 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R4463 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R4464 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R4465 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R4466 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R4467 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R4468 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R4469 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R4470 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R4471 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R4472 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R4473 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R4474 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R4475 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R4476 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R4477 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R4478 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R4479 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R4480 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R4481 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R4482 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R4483 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R4484 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R4485 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R4486 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R4487 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R4488 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R4489 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R4490 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R4491 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R4492 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R4493 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R4494 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R4495 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R4496 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R4497 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R4498 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R4499 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R4500 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R4501 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R4502 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R4503 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R4504 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R4505 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R4506 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R4507 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R4508 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R4509 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R4510 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R4511 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R4512 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R4513 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R4514 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R4515 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R4516 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R4517 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R4518 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R4519 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R4520 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R4521 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R4522 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R4523 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R4524 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R4525 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R4526 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R4527 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R4528 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R4529 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R4530 n1_m1_403200_148800 n1_m1_408000_148800 5.356235
R4531 n1_m1_408000_148800 n1_m1_412800_148800 5.356235
R4532 n1_m1_412800_148800 n1_m1_417600_148800 5.356235
R4533 n1_m1_417600_148800 n1_m1_422400_148800 5.356235
R4534 n1_m1_422400_148800 n1_m1_424000_148800 1.785412
R4535 n1_m1_427200_148800 n1_m1_424000_148800 3.570824
R4536 n1_m1_427200_148800 n1_m1_432000_148800 5.356235
R4537 n1_m1_432000_148800 n1_m1_436800_148800 5.356235
R4538 n1_m1_436800_148800 n1_m1_441600_148800 5.356235
R4539 n1_m1_441600_148800 n1_m1_446400_148800 5.356235
R4540 n1_m1_446400_148800 n1_m1_451200_148800 5.356235
R4541 n1_m1_451200_148800 n1_m1_452000_148800 0.892706
R4542 n1_m1_456000_148800 n1_m1_452000_148800 4.463529
R4543 n1_m1_456000_148800 n1_m1_460800_148800 5.356235
R4544 n1_m1_460800_148800 n1_m1_465600_148800 5.356235
R4545 n1_m1_465600_148800 n1_m1_470400_148800 5.356235
R4546 n1_m1_470400_148800 n1_m1_475200_148800 5.356235
R4547 n1_m1_475200_148800 n1_m1_480000_148800 5.356235
R4548 n1_m1_480000_148800 n1_m1_484800_148800 5.356235
R4549 n1_m1_484800_148800 n1_m1_489600_148800 5.356235
R4550 n1_m1_489600_148800 n1_m1_494400_148800 5.356235
R4551 n1_m1_494400_148800 n1_m1_499200_148800 5.356235
R4552 n1_m1_499200_148800 n1_m1_504000_148800 5.356235
R4553 n1_m1_504000_148800 n1_m1_508000_148800 4.463529
R4554 n1_m1_508800_148800 n1_m1_508000_148800 0.892706
R4555 n1_m1_508800_148800 n1_m1_513600_148800 5.356235
R4556 n1_m1_513600_148800 n1_m1_518400_148800 5.356235
R4557 n1_m1_518400_148800 n1_m1_523200_148800 5.356235
R4558 n1_m1_523200_148800 n1_m1_528000_148800 5.356235
R4559 n1_m1_528000_148800 n1_m1_532800_148800 5.356235
R4560 n1_m1_532800_148800 n1_m1_536000_148800 3.570824
R4561 n1_m1_537600_148800 n1_m1_536000_148800 1.785412
R4562 n1_m1_537600_148800 n1_m1_542400_148800 5.356235
R4563 n1_m1_542400_148800 n1_m1_547200_148800 5.356235
R4564 n1_m1_547200_148800 n1_m1_552000_148800 5.356235
R4565 n1_m1_552000_148800 n1_m1_556800_148800 5.356235
R4566 n1_m1_556800_148800 n1_m1_561600_148800 5.356235
R4567 n1_m1_561600_148800 n1_m1_564000_148800 2.678118
R4568 n1_m1_566400_148800 n1_m1_564000_148800 2.678118
R4569 n1_m1_566400_148800 n1_m1_571200_148800 5.356235
R4570 n1_m1_571200_148800 n1_m1_576000_148800 5.356235
R4571 n1_m1_576000_148800 n1_m1_580800_148800 5.356235
R4572 n1_m1_580800_148800 n1_m1_585600_148800 5.356235
R4573 n1_m1_585600_148800 n1_m1_590400_148800 5.356235
R4574 n1_m1_590400_148800 n1_m1_592000_148800 1.785412
R4575 n1_m1_595200_148800 n1_m1_592000_148800 3.570824
R4576 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R4577 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R4578 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R4579 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R4580 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R4581 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R4582 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R4583 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R4584 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R4585 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R4586 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R4587 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R4588 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R4589 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R4590 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R4591 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R4592 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R4593 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R4594 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R4595 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R4596 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R4597 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R4598 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R4599 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R4600 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R4601 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R4602 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R4603 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R4604 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R4605 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R4606 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R4607 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R4608 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R4609 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R4610 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R4611 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R4612 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R4613 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R4614 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R4615 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R4616 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R4617 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R4618 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R4619 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R4620 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R4621 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R4622 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R4623 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R4624 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R4625 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R4626 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R4627 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R4628 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R4629 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R4630 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R4631 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R4632 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R4633 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R4634 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R4635 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R4636 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R4637 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R4638 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R4639 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R4640 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R4641 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R4642 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R4643 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R4644 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R4645 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R4646 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R4647 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R4648 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R4649 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R4650 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R4651 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R4652 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R4653 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R4654 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R4655 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R4656 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R4657 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R4658 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R4659 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R4660 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R4661 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R4662 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R4663 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R4664 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R4665 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R4666 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R4667 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R4668 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R4669 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R4670 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R4671 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R4672 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R4673 n1_m1_403200_153600 n1_m1_408000_153600 5.356235
R4674 n1_m1_408000_153600 n1_m1_412800_153600 5.356235
R4675 n1_m1_412800_153600 n1_m1_417600_153600 5.356235
R4676 n1_m1_417600_153600 n1_m1_422400_153600 5.356235
R4677 n1_m1_422400_153600 n1_m1_424000_153600 1.785412
R4678 n1_m1_427200_153600 n1_m1_424000_153600 3.570824
R4679 n1_m1_427200_153600 n1_m1_432000_153600 5.356235
R4680 n1_m1_432000_153600 n1_m1_436800_153600 5.356235
R4681 n1_m1_436800_153600 n1_m1_441600_153600 5.356235
R4682 n1_m1_441600_153600 n1_m1_446400_153600 5.356235
R4683 n1_m1_446400_153600 n1_m1_451200_153600 5.356235
R4684 n1_m1_451200_153600 n1_m1_452000_153600 0.892706
R4685 n1_m1_456000_153600 n1_m1_452000_153600 4.463529
R4686 n1_m1_456000_153600 n1_m1_460800_153600 5.356235
R4687 n1_m1_460800_153600 n1_m1_465600_153600 5.356235
R4688 n1_m1_465600_153600 n1_m1_470400_153600 5.356235
R4689 n1_m1_470400_153600 n1_m1_475200_153600 5.356235
R4690 n1_m1_475200_153600 n1_m1_480000_153600 5.356235
R4691 n1_m1_480000_153600 n1_m1_484800_153600 5.356235
R4692 n1_m1_484800_153600 n1_m1_489600_153600 5.356235
R4693 n1_m1_489600_153600 n1_m1_494400_153600 5.356235
R4694 n1_m1_494400_153600 n1_m1_499200_153600 5.356235
R4695 n1_m1_499200_153600 n1_m1_504000_153600 5.356235
R4696 n1_m1_504000_153600 n1_m1_508000_153600 4.463529
R4697 n1_m1_508800_153600 n1_m1_508000_153600 0.892706
R4698 n1_m1_508800_153600 n1_m1_513600_153600 5.356235
R4699 n1_m1_513600_153600 n1_m1_518400_153600 5.356235
R4700 n1_m1_518400_153600 n1_m1_523200_153600 5.356235
R4701 n1_m1_523200_153600 n1_m1_528000_153600 5.356235
R4702 n1_m1_528000_153600 n1_m1_532800_153600 5.356235
R4703 n1_m1_532800_153600 n1_m1_536000_153600 3.570824
R4704 n1_m1_537600_153600 n1_m1_536000_153600 1.785412
R4705 n1_m1_537600_153600 n1_m1_542400_153600 5.356235
R4706 n1_m1_542400_153600 n1_m1_547200_153600 5.356235
R4707 n1_m1_547200_153600 n1_m1_552000_153600 5.356235
R4708 n1_m1_552000_153600 n1_m1_556800_153600 5.356235
R4709 n1_m1_556800_153600 n1_m1_561600_153600 5.356235
R4710 n1_m1_561600_153600 n1_m1_564000_153600 2.678118
R4711 n1_m1_566400_153600 n1_m1_564000_153600 2.678118
R4712 n1_m1_566400_153600 n1_m1_571200_153600 5.356235
R4713 n1_m1_571200_153600 n1_m1_576000_153600 5.356235
R4714 n1_m1_576000_153600 n1_m1_580800_153600 5.356235
R4715 n1_m1_580800_153600 n1_m1_585600_153600 5.356235
R4716 n1_m1_585600_153600 n1_m1_590400_153600 5.356235
R4717 n1_m1_590400_153600 n1_m1_592000_153600 1.785412
R4718 n1_m1_595200_153600 n1_m1_592000_153600 3.570824
R4719 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R4720 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R4721 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R4722 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R4723 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R4724 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R4725 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R4726 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R4727 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R4728 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R4729 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R4730 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R4731 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R4732 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R4733 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R4734 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R4735 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R4736 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R4737 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R4738 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R4739 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R4740 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R4741 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R4742 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R4743 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R4744 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R4745 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R4746 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R4747 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R4748 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R4749 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R4750 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R4751 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R4752 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R4753 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R4754 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R4755 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R4756 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R4757 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R4758 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R4759 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R4760 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R4761 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R4762 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R4763 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R4764 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R4765 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R4766 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R4767 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R4768 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R4769 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R4770 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R4771 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R4772 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R4773 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R4774 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R4775 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R4776 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R4777 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R4778 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R4779 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R4780 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R4781 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R4782 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R4783 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R4784 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R4785 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R4786 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R4787 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R4788 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R4789 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R4790 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R4791 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R4792 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R4793 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R4794 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R4795 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R4796 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R4797 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R4798 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R4799 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R4800 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R4801 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R4802 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R4803 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R4804 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R4805 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R4806 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R4807 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R4808 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R4809 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R4810 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R4811 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R4812 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R4813 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R4814 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R4815 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R4816 n1_m1_403200_158400 n1_m1_408000_158400 5.356235
R4817 n1_m1_408000_158400 n1_m1_412800_158400 5.356235
R4818 n1_m1_412800_158400 n1_m1_417600_158400 5.356235
R4819 n1_m1_417600_158400 n1_m1_422400_158400 5.356235
R4820 n1_m1_422400_158400 n1_m1_424000_158400 1.785412
R4821 n1_m1_427200_158400 n1_m1_424000_158400 3.570824
R4822 n1_m1_427200_158400 n1_m1_432000_158400 5.356235
R4823 n1_m1_432000_158400 n1_m1_436800_158400 5.356235
R4824 n1_m1_436800_158400 n1_m1_441600_158400 5.356235
R4825 n1_m1_441600_158400 n1_m1_446400_158400 5.356235
R4826 n1_m1_446400_158400 n1_m1_451200_158400 5.356235
R4827 n1_m1_451200_158400 n1_m1_452000_158400 0.892706
R4828 n1_m1_456000_158400 n1_m1_452000_158400 4.463529
R4829 n1_m1_456000_158400 n1_m1_460800_158400 5.356235
R4830 n1_m1_460800_158400 n1_m1_465600_158400 5.356235
R4831 n1_m1_465600_158400 n1_m1_470400_158400 5.356235
R4832 n1_m1_470400_158400 n1_m1_475200_158400 5.356235
R4833 n1_m1_475200_158400 n1_m1_480000_158400 5.356235
R4834 n1_m1_480000_158400 n1_m1_484800_158400 5.356235
R4835 n1_m1_484800_158400 n1_m1_489600_158400 5.356235
R4836 n1_m1_489600_158400 n1_m1_494400_158400 5.356235
R4837 n1_m1_494400_158400 n1_m1_499200_158400 5.356235
R4838 n1_m1_499200_158400 n1_m1_504000_158400 5.356235
R4839 n1_m1_504000_158400 n1_m1_508000_158400 4.463529
R4840 n1_m1_508800_158400 n1_m1_508000_158400 0.892706
R4841 n1_m1_508800_158400 n1_m1_513600_158400 5.356235
R4842 n1_m1_513600_158400 n1_m1_518400_158400 5.356235
R4843 n1_m1_518400_158400 n1_m1_523200_158400 5.356235
R4844 n1_m1_523200_158400 n1_m1_528000_158400 5.356235
R4845 n1_m1_528000_158400 n1_m1_532800_158400 5.356235
R4846 n1_m1_532800_158400 n1_m1_536000_158400 3.570824
R4847 n1_m1_537600_158400 n1_m1_536000_158400 1.785412
R4848 n1_m1_537600_158400 n1_m1_542400_158400 5.356235
R4849 n1_m1_542400_158400 n1_m1_547200_158400 5.356235
R4850 n1_m1_547200_158400 n1_m1_552000_158400 5.356235
R4851 n1_m1_552000_158400 n1_m1_556800_158400 5.356235
R4852 n1_m1_556800_158400 n1_m1_561600_158400 5.356235
R4853 n1_m1_561600_158400 n1_m1_564000_158400 2.678118
R4854 n1_m1_566400_158400 n1_m1_564000_158400 2.678118
R4855 n1_m1_566400_158400 n1_m1_571200_158400 5.356235
R4856 n1_m1_571200_158400 n1_m1_576000_158400 5.356235
R4857 n1_m1_576000_158400 n1_m1_580800_158400 5.356235
R4858 n1_m1_580800_158400 n1_m1_585600_158400 5.356235
R4859 n1_m1_585600_158400 n1_m1_590400_158400 5.356235
R4860 n1_m1_590400_158400 n1_m1_592000_158400 1.785412
R4861 n1_m1_595200_158400 n1_m1_592000_158400 3.570824
R4862 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R4863 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R4864 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R4865 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R4866 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R4867 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R4868 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R4869 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R4870 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R4871 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R4872 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R4873 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R4874 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R4875 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R4876 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R4877 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R4878 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R4879 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R4880 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R4881 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R4882 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R4883 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R4884 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R4885 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R4886 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R4887 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R4888 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R4889 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R4890 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R4891 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R4892 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R4893 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R4894 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R4895 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R4896 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R4897 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R4898 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R4899 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R4900 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R4901 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R4902 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R4903 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R4904 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R4905 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R4906 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R4907 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R4908 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R4909 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R4910 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R4911 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R4912 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R4913 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R4914 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R4915 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R4916 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R4917 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R4918 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R4919 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R4920 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R4921 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R4922 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R4923 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R4924 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R4925 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R4926 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R4927 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R4928 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R4929 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R4930 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R4931 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R4932 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R4933 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R4934 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R4935 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R4936 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R4937 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R4938 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R4939 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R4940 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R4941 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R4942 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R4943 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R4944 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R4945 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R4946 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R4947 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R4948 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R4949 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R4950 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R4951 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R4952 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R4953 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R4954 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R4955 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R4956 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R4957 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R4958 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R4959 n1_m1_403200_163200 n1_m1_408000_163200 5.356235
R4960 n1_m1_408000_163200 n1_m1_412800_163200 5.356235
R4961 n1_m1_412800_163200 n1_m1_417600_163200 5.356235
R4962 n1_m1_417600_163200 n1_m1_422400_163200 5.356235
R4963 n1_m1_422400_163200 n1_m1_424000_163200 1.785412
R4964 n1_m1_427200_163200 n1_m1_424000_163200 3.570824
R4965 n1_m1_427200_163200 n1_m1_432000_163200 5.356235
R4966 n1_m1_432000_163200 n1_m1_436800_163200 5.356235
R4967 n1_m1_436800_163200 n1_m1_441600_163200 5.356235
R4968 n1_m1_441600_163200 n1_m1_446400_163200 5.356235
R4969 n1_m1_446400_163200 n1_m1_451200_163200 5.356235
R4970 n1_m1_451200_163200 n1_m1_452000_163200 0.892706
R4971 n1_m1_456000_163200 n1_m1_452000_163200 4.463529
R4972 n1_m1_456000_163200 n1_m1_460800_163200 5.356235
R4973 n1_m1_460800_163200 n1_m1_465600_163200 5.356235
R4974 n1_m1_465600_163200 n1_m1_470400_163200 5.356235
R4975 n1_m1_470400_163200 n1_m1_475200_163200 5.356235
R4976 n1_m1_475200_163200 n1_m1_480000_163200 5.356235
R4977 n1_m1_480000_163200 n1_m1_484800_163200 5.356235
R4978 n1_m1_484800_163200 n1_m1_489600_163200 5.356235
R4979 n1_m1_489600_163200 n1_m1_494400_163200 5.356235
R4980 n1_m1_494400_163200 n1_m1_499200_163200 5.356235
R4981 n1_m1_499200_163200 n1_m1_504000_163200 5.356235
R4982 n1_m1_504000_163200 n1_m1_508000_163200 4.463529
R4983 n1_m1_508800_163200 n1_m1_508000_163200 0.892706
R4984 n1_m1_508800_163200 n1_m1_513600_163200 5.356235
R4985 n1_m1_513600_163200 n1_m1_518400_163200 5.356235
R4986 n1_m1_518400_163200 n1_m1_523200_163200 5.356235
R4987 n1_m1_523200_163200 n1_m1_528000_163200 5.356235
R4988 n1_m1_528000_163200 n1_m1_532800_163200 5.356235
R4989 n1_m1_532800_163200 n1_m1_536000_163200 3.570824
R4990 n1_m1_537600_163200 n1_m1_536000_163200 1.785412
R4991 n1_m1_537600_163200 n1_m1_542400_163200 5.356235
R4992 n1_m1_542400_163200 n1_m1_547200_163200 5.356235
R4993 n1_m1_547200_163200 n1_m1_552000_163200 5.356235
R4994 n1_m1_552000_163200 n1_m1_556800_163200 5.356235
R4995 n1_m1_556800_163200 n1_m1_561600_163200 5.356235
R4996 n1_m1_561600_163200 n1_m1_564000_163200 2.678118
R4997 n1_m1_566400_163200 n1_m1_564000_163200 2.678118
R4998 n1_m1_566400_163200 n1_m1_571200_163200 5.356235
R4999 n1_m1_571200_163200 n1_m1_576000_163200 5.356235
R5000 n1_m1_576000_163200 n1_m1_580800_163200 5.356235
R5001 n1_m1_580800_163200 n1_m1_585600_163200 5.356235
R5002 n1_m1_585600_163200 n1_m1_590400_163200 5.356235
R5003 n1_m1_590400_163200 n1_m1_592000_163200 1.785412
R5004 n1_m1_595200_163200 n1_m1_592000_163200 3.570824
R5005 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R5006 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R5007 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R5008 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R5009 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R5010 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R5011 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R5012 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R5013 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R5014 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R5015 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R5016 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R5017 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R5018 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R5019 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R5020 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R5021 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R5022 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R5023 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R5024 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R5025 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R5026 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R5027 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R5028 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R5029 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R5030 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R5031 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R5032 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R5033 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R5034 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R5035 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R5036 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R5037 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R5038 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R5039 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R5040 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R5041 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R5042 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R5043 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R5044 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R5045 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R5046 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R5047 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R5048 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R5049 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R5050 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R5051 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R5052 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R5053 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R5054 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R5055 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R5056 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R5057 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R5058 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R5059 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R5060 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R5061 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R5062 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R5063 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R5064 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R5065 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R5066 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R5067 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R5068 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R5069 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R5070 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R5071 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R5072 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R5073 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R5074 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R5075 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R5076 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R5077 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R5078 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R5079 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R5080 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R5081 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R5082 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R5083 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R5084 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R5085 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R5086 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R5087 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R5088 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R5089 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R5090 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R5091 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R5092 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R5093 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R5094 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R5095 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R5096 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R5097 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R5098 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R5099 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R5100 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R5101 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R5102 n1_m1_403200_168000 n1_m1_408000_168000 5.356235
R5103 n1_m1_408000_168000 n1_m1_412800_168000 5.356235
R5104 n1_m1_412800_168000 n1_m1_417600_168000 5.356235
R5105 n1_m1_417600_168000 n1_m1_422400_168000 5.356235
R5106 n1_m1_422400_168000 n1_m1_424000_168000 1.785412
R5107 n1_m1_427200_168000 n1_m1_424000_168000 3.570824
R5108 n1_m1_427200_168000 n1_m1_432000_168000 5.356235
R5109 n1_m1_432000_168000 n1_m1_436800_168000 5.356235
R5110 n1_m1_436800_168000 n1_m1_441600_168000 5.356235
R5111 n1_m1_441600_168000 n1_m1_446400_168000 5.356235
R5112 n1_m1_446400_168000 n1_m1_451200_168000 5.356235
R5113 n1_m1_451200_168000 n1_m1_452000_168000 0.892706
R5114 n1_m1_456000_168000 n1_m1_452000_168000 4.463529
R5115 n1_m1_456000_168000 n1_m1_460800_168000 5.356235
R5116 n1_m1_460800_168000 n1_m1_465600_168000 5.356235
R5117 n1_m1_465600_168000 n1_m1_470400_168000 5.356235
R5118 n1_m1_470400_168000 n1_m1_475200_168000 5.356235
R5119 n1_m1_475200_168000 n1_m1_480000_168000 5.356235
R5120 n1_m1_480000_168000 n1_m1_484800_168000 5.356235
R5121 n1_m1_484800_168000 n1_m1_489600_168000 5.356235
R5122 n1_m1_489600_168000 n1_m1_494400_168000 5.356235
R5123 n1_m1_494400_168000 n1_m1_499200_168000 5.356235
R5124 n1_m1_499200_168000 n1_m1_504000_168000 5.356235
R5125 n1_m1_504000_168000 n1_m1_508000_168000 4.463529
R5126 n1_m1_508800_168000 n1_m1_508000_168000 0.892706
R5127 n1_m1_508800_168000 n1_m1_513600_168000 5.356235
R5128 n1_m1_513600_168000 n1_m1_518400_168000 5.356235
R5129 n1_m1_518400_168000 n1_m1_523200_168000 5.356235
R5130 n1_m1_523200_168000 n1_m1_528000_168000 5.356235
R5131 n1_m1_528000_168000 n1_m1_532800_168000 5.356235
R5132 n1_m1_532800_168000 n1_m1_536000_168000 3.570824
R5133 n1_m1_537600_168000 n1_m1_536000_168000 1.785412
R5134 n1_m1_537600_168000 n1_m1_542400_168000 5.356235
R5135 n1_m1_542400_168000 n1_m1_547200_168000 5.356235
R5136 n1_m1_547200_168000 n1_m1_552000_168000 5.356235
R5137 n1_m1_552000_168000 n1_m1_556800_168000 5.356235
R5138 n1_m1_556800_168000 n1_m1_561600_168000 5.356235
R5139 n1_m1_561600_168000 n1_m1_564000_168000 2.678118
R5140 n1_m1_566400_168000 n1_m1_564000_168000 2.678118
R5141 n1_m1_566400_168000 n1_m1_571200_168000 5.356235
R5142 n1_m1_571200_168000 n1_m1_576000_168000 5.356235
R5143 n1_m1_576000_168000 n1_m1_580800_168000 5.356235
R5144 n1_m1_580800_168000 n1_m1_585600_168000 5.356235
R5145 n1_m1_585600_168000 n1_m1_590400_168000 5.356235
R5146 n1_m1_590400_168000 n1_m1_592000_168000 1.785412
R5147 n1_m1_595200_168000 n1_m1_592000_168000 3.570824
R5148 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R5149 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R5150 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R5151 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R5152 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R5153 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R5154 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R5155 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R5156 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R5157 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R5158 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R5159 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R5160 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R5161 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R5162 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R5163 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R5164 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R5165 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R5166 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R5167 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R5168 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R5169 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R5170 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R5171 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R5172 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R5173 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R5174 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R5175 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R5176 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R5177 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R5178 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R5179 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R5180 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R5181 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R5182 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R5183 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R5184 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R5185 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R5186 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R5187 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R5188 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R5189 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R5190 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R5191 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R5192 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R5193 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R5194 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R5195 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R5196 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R5197 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R5198 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R5199 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R5200 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R5201 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R5202 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R5203 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R5204 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R5205 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R5206 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R5207 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R5208 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R5209 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R5210 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R5211 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R5212 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R5213 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R5214 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R5215 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R5216 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R5217 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R5218 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R5219 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R5220 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R5221 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R5222 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R5223 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R5224 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R5225 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R5226 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R5227 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R5228 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R5229 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R5230 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R5231 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R5232 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R5233 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R5234 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R5235 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R5236 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R5237 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R5238 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R5239 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R5240 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R5241 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R5242 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R5243 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R5244 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R5245 n1_m1_403200_172800 n1_m1_408000_172800 5.356235
R5246 n1_m1_408000_172800 n1_m1_412800_172800 5.356235
R5247 n1_m1_412800_172800 n1_m1_417600_172800 5.356235
R5248 n1_m1_417600_172800 n1_m1_422400_172800 5.356235
R5249 n1_m1_422400_172800 n1_m1_424000_172800 1.785412
R5250 n1_m1_427200_172800 n1_m1_424000_172800 3.570824
R5251 n1_m1_427200_172800 n1_m1_432000_172800 5.356235
R5252 n1_m1_432000_172800 n1_m1_436800_172800 5.356235
R5253 n1_m1_436800_172800 n1_m1_441600_172800 5.356235
R5254 n1_m1_441600_172800 n1_m1_446400_172800 5.356235
R5255 n1_m1_446400_172800 n1_m1_451200_172800 5.356235
R5256 n1_m1_451200_172800 n1_m1_452000_172800 0.892706
R5257 n1_m1_456000_172800 n1_m1_452000_172800 4.463529
R5258 n1_m1_456000_172800 n1_m1_460800_172800 5.356235
R5259 n1_m1_460800_172800 n1_m1_465600_172800 5.356235
R5260 n1_m1_465600_172800 n1_m1_470400_172800 5.356235
R5261 n1_m1_470400_172800 n1_m1_475200_172800 5.356235
R5262 n1_m1_475200_172800 n1_m1_480000_172800 5.356235
R5263 n1_m1_480000_172800 n1_m1_484800_172800 5.356235
R5264 n1_m1_484800_172800 n1_m1_489600_172800 5.356235
R5265 n1_m1_489600_172800 n1_m1_494400_172800 5.356235
R5266 n1_m1_494400_172800 n1_m1_499200_172800 5.356235
R5267 n1_m1_499200_172800 n1_m1_504000_172800 5.356235
R5268 n1_m1_504000_172800 n1_m1_508000_172800 4.463529
R5269 n1_m1_508800_172800 n1_m1_508000_172800 0.892706
R5270 n1_m1_508800_172800 n1_m1_513600_172800 5.356235
R5271 n1_m1_513600_172800 n1_m1_518400_172800 5.356235
R5272 n1_m1_518400_172800 n1_m1_523200_172800 5.356235
R5273 n1_m1_523200_172800 n1_m1_528000_172800 5.356235
R5274 n1_m1_528000_172800 n1_m1_532800_172800 5.356235
R5275 n1_m1_532800_172800 n1_m1_536000_172800 3.570824
R5276 n1_m1_537600_172800 n1_m1_536000_172800 1.785412
R5277 n1_m1_537600_172800 n1_m1_542400_172800 5.356235
R5278 n1_m1_542400_172800 n1_m1_547200_172800 5.356235
R5279 n1_m1_547200_172800 n1_m1_552000_172800 5.356235
R5280 n1_m1_552000_172800 n1_m1_556800_172800 5.356235
R5281 n1_m1_556800_172800 n1_m1_561600_172800 5.356235
R5282 n1_m1_561600_172800 n1_m1_564000_172800 2.678118
R5283 n1_m1_566400_172800 n1_m1_564000_172800 2.678118
R5284 n1_m1_566400_172800 n1_m1_571200_172800 5.356235
R5285 n1_m1_571200_172800 n1_m1_576000_172800 5.356235
R5286 n1_m1_576000_172800 n1_m1_580800_172800 5.356235
R5287 n1_m1_580800_172800 n1_m1_585600_172800 5.356235
R5288 n1_m1_585600_172800 n1_m1_590400_172800 5.356235
R5289 n1_m1_590400_172800 n1_m1_592000_172800 1.785412
R5290 n1_m1_595200_172800 n1_m1_592000_172800 3.570824
R5291 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R5292 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R5293 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R5294 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R5295 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R5296 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R5297 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R5298 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R5299 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R5300 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R5301 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R5302 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R5303 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R5304 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R5305 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R5306 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R5307 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R5308 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R5309 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R5310 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R5311 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R5312 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R5313 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R5314 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R5315 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R5316 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R5317 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R5318 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R5319 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R5320 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R5321 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R5322 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R5323 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R5324 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R5325 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R5326 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R5327 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R5328 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R5329 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R5330 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R5331 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R5332 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R5333 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R5334 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R5335 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R5336 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R5337 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R5338 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R5339 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R5340 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R5341 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R5342 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R5343 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R5344 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R5345 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R5346 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R5347 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R5348 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R5349 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R5350 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R5351 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R5352 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R5353 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R5354 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R5355 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R5356 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R5357 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R5358 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R5359 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R5360 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R5361 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R5362 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R5363 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R5364 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R5365 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R5366 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R5367 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R5368 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R5369 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R5370 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R5371 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R5372 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R5373 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R5374 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R5375 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R5376 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R5377 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R5378 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R5379 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R5380 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R5381 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R5382 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R5383 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R5384 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R5385 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R5386 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R5387 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R5388 n1_m1_403200_177600 n1_m1_408000_177600 5.356235
R5389 n1_m1_408000_177600 n1_m1_412800_177600 5.356235
R5390 n1_m1_412800_177600 n1_m1_417600_177600 5.356235
R5391 n1_m1_417600_177600 n1_m1_422400_177600 5.356235
R5392 n1_m1_422400_177600 n1_m1_424000_177600 1.785412
R5393 n1_m1_427200_177600 n1_m1_424000_177600 3.570824
R5394 n1_m1_427200_177600 n1_m1_432000_177600 5.356235
R5395 n1_m1_432000_177600 n1_m1_436800_177600 5.356235
R5396 n1_m1_436800_177600 n1_m1_441600_177600 5.356235
R5397 n1_m1_441600_177600 n1_m1_446400_177600 5.356235
R5398 n1_m1_446400_177600 n1_m1_451200_177600 5.356235
R5399 n1_m1_451200_177600 n1_m1_452000_177600 0.892706
R5400 n1_m1_456000_177600 n1_m1_452000_177600 4.463529
R5401 n1_m1_456000_177600 n1_m1_460800_177600 5.356235
R5402 n1_m1_460800_177600 n1_m1_465600_177600 5.356235
R5403 n1_m1_465600_177600 n1_m1_470400_177600 5.356235
R5404 n1_m1_470400_177600 n1_m1_475200_177600 5.356235
R5405 n1_m1_475200_177600 n1_m1_480000_177600 5.356235
R5406 n1_m1_480000_177600 n1_m1_484800_177600 5.356235
R5407 n1_m1_484800_177600 n1_m1_489600_177600 5.356235
R5408 n1_m1_489600_177600 n1_m1_494400_177600 5.356235
R5409 n1_m1_494400_177600 n1_m1_499200_177600 5.356235
R5410 n1_m1_499200_177600 n1_m1_504000_177600 5.356235
R5411 n1_m1_504000_177600 n1_m1_508000_177600 4.463529
R5412 n1_m1_508800_177600 n1_m1_508000_177600 0.892706
R5413 n1_m1_508800_177600 n1_m1_513600_177600 5.356235
R5414 n1_m1_513600_177600 n1_m1_518400_177600 5.356235
R5415 n1_m1_518400_177600 n1_m1_523200_177600 5.356235
R5416 n1_m1_523200_177600 n1_m1_528000_177600 5.356235
R5417 n1_m1_528000_177600 n1_m1_532800_177600 5.356235
R5418 n1_m1_532800_177600 n1_m1_536000_177600 3.570824
R5419 n1_m1_537600_177600 n1_m1_536000_177600 1.785412
R5420 n1_m1_537600_177600 n1_m1_542400_177600 5.356235
R5421 n1_m1_542400_177600 n1_m1_547200_177600 5.356235
R5422 n1_m1_547200_177600 n1_m1_552000_177600 5.356235
R5423 n1_m1_552000_177600 n1_m1_556800_177600 5.356235
R5424 n1_m1_556800_177600 n1_m1_561600_177600 5.356235
R5425 n1_m1_561600_177600 n1_m1_564000_177600 2.678118
R5426 n1_m1_566400_177600 n1_m1_564000_177600 2.678118
R5427 n1_m1_566400_177600 n1_m1_571200_177600 5.356235
R5428 n1_m1_571200_177600 n1_m1_576000_177600 5.356235
R5429 n1_m1_576000_177600 n1_m1_580800_177600 5.356235
R5430 n1_m1_580800_177600 n1_m1_585600_177600 5.356235
R5431 n1_m1_585600_177600 n1_m1_590400_177600 5.356235
R5432 n1_m1_590400_177600 n1_m1_592000_177600 1.785412
R5433 n1_m1_595200_177600 n1_m1_592000_177600 3.570824
R5434 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R5435 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R5436 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R5437 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R5438 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R5439 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R5440 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R5441 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R5442 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R5443 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R5444 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R5445 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R5446 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R5447 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R5448 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R5449 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R5450 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R5451 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R5452 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R5453 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R5454 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R5455 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R5456 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R5457 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R5458 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R5459 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R5460 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R5461 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R5462 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R5463 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R5464 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R5465 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R5466 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R5467 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R5468 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R5469 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R5470 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R5471 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R5472 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R5473 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R5474 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R5475 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R5476 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R5477 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R5478 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R5479 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R5480 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R5481 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R5482 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R5483 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R5484 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R5485 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R5486 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R5487 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R5488 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R5489 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R5490 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R5491 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R5492 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R5493 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R5494 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R5495 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R5496 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R5497 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R5498 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R5499 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R5500 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R5501 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R5502 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R5503 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R5504 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R5505 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R5506 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R5507 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R5508 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R5509 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R5510 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R5511 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R5512 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R5513 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R5514 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R5515 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R5516 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R5517 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R5518 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R5519 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R5520 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R5521 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R5522 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R5523 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R5524 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R5525 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R5526 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R5527 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R5528 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R5529 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R5530 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R5531 n1_m1_403200_182400 n1_m1_408000_182400 5.356235
R5532 n1_m1_408000_182400 n1_m1_412800_182400 5.356235
R5533 n1_m1_412800_182400 n1_m1_417600_182400 5.356235
R5534 n1_m1_417600_182400 n1_m1_422400_182400 5.356235
R5535 n1_m1_422400_182400 n1_m1_424000_182400 1.785412
R5536 n1_m1_427200_182400 n1_m1_424000_182400 3.570824
R5537 n1_m1_427200_182400 n1_m1_432000_182400 5.356235
R5538 n1_m1_432000_182400 n1_m1_436800_182400 5.356235
R5539 n1_m1_436800_182400 n1_m1_441600_182400 5.356235
R5540 n1_m1_441600_182400 n1_m1_446400_182400 5.356235
R5541 n1_m1_446400_182400 n1_m1_451200_182400 5.356235
R5542 n1_m1_451200_182400 n1_m1_452000_182400 0.892706
R5543 n1_m1_456000_182400 n1_m1_452000_182400 4.463529
R5544 n1_m1_456000_182400 n1_m1_460800_182400 5.356235
R5545 n1_m1_460800_182400 n1_m1_465600_182400 5.356235
R5546 n1_m1_465600_182400 n1_m1_470400_182400 5.356235
R5547 n1_m1_470400_182400 n1_m1_475200_182400 5.356235
R5548 n1_m1_475200_182400 n1_m1_480000_182400 5.356235
R5549 n1_m1_480000_182400 n1_m1_484800_182400 5.356235
R5550 n1_m1_484800_182400 n1_m1_489600_182400 5.356235
R5551 n1_m1_489600_182400 n1_m1_494400_182400 5.356235
R5552 n1_m1_494400_182400 n1_m1_499200_182400 5.356235
R5553 n1_m1_499200_182400 n1_m1_504000_182400 5.356235
R5554 n1_m1_504000_182400 n1_m1_508000_182400 4.463529
R5555 n1_m1_508800_182400 n1_m1_508000_182400 0.892706
R5556 n1_m1_508800_182400 n1_m1_513600_182400 5.356235
R5557 n1_m1_513600_182400 n1_m1_518400_182400 5.356235
R5558 n1_m1_518400_182400 n1_m1_523200_182400 5.356235
R5559 n1_m1_523200_182400 n1_m1_528000_182400 5.356235
R5560 n1_m1_528000_182400 n1_m1_532800_182400 5.356235
R5561 n1_m1_532800_182400 n1_m1_536000_182400 3.570824
R5562 n1_m1_537600_182400 n1_m1_536000_182400 1.785412
R5563 n1_m1_537600_182400 n1_m1_542400_182400 5.356235
R5564 n1_m1_542400_182400 n1_m1_547200_182400 5.356235
R5565 n1_m1_547200_182400 n1_m1_552000_182400 5.356235
R5566 n1_m1_552000_182400 n1_m1_556800_182400 5.356235
R5567 n1_m1_556800_182400 n1_m1_561600_182400 5.356235
R5568 n1_m1_561600_182400 n1_m1_564000_182400 2.678118
R5569 n1_m1_566400_182400 n1_m1_564000_182400 2.678118
R5570 n1_m1_566400_182400 n1_m1_571200_182400 5.356235
R5571 n1_m1_571200_182400 n1_m1_576000_182400 5.356235
R5572 n1_m1_576000_182400 n1_m1_580800_182400 5.356235
R5573 n1_m1_580800_182400 n1_m1_585600_182400 5.356235
R5574 n1_m1_585600_182400 n1_m1_590400_182400 5.356235
R5575 n1_m1_590400_182400 n1_m1_592000_182400 1.785412
R5576 n1_m1_595200_182400 n1_m1_592000_182400 3.570824
R5577 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R5578 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R5579 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R5580 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R5581 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R5582 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R5583 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R5584 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R5585 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R5586 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R5587 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R5588 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R5589 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R5590 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R5591 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R5592 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R5593 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R5594 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R5595 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R5596 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R5597 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R5598 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R5599 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R5600 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R5601 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R5602 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R5603 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R5604 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R5605 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R5606 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R5607 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R5608 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R5609 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R5610 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R5611 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R5612 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R5613 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R5614 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R5615 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R5616 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R5617 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R5618 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R5619 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R5620 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R5621 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R5622 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R5623 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R5624 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R5625 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R5626 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R5627 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R5628 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R5629 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R5630 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R5631 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R5632 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R5633 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R5634 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R5635 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R5636 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R5637 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R5638 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R5639 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R5640 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R5641 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R5642 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R5643 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R5644 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R5645 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R5646 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R5647 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R5648 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R5649 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R5650 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R5651 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R5652 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R5653 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R5654 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R5655 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R5656 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R5657 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R5658 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R5659 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R5660 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R5661 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R5662 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R5663 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R5664 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R5665 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R5666 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R5667 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R5668 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R5669 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R5670 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R5671 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R5672 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R5673 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R5674 n1_m1_403200_187200 n1_m1_408000_187200 5.356235
R5675 n1_m1_408000_187200 n1_m1_412800_187200 5.356235
R5676 n1_m1_412800_187200 n1_m1_417600_187200 5.356235
R5677 n1_m1_417600_187200 n1_m1_422400_187200 5.356235
R5678 n1_m1_422400_187200 n1_m1_424000_187200 1.785412
R5679 n1_m1_427200_187200 n1_m1_424000_187200 3.570824
R5680 n1_m1_427200_187200 n1_m1_432000_187200 5.356235
R5681 n1_m1_432000_187200 n1_m1_436800_187200 5.356235
R5682 n1_m1_436800_187200 n1_m1_441600_187200 5.356235
R5683 n1_m1_441600_187200 n1_m1_446400_187200 5.356235
R5684 n1_m1_446400_187200 n1_m1_451200_187200 5.356235
R5685 n1_m1_451200_187200 n1_m1_452000_187200 0.892706
R5686 n1_m1_456000_187200 n1_m1_452000_187200 4.463529
R5687 n1_m1_456000_187200 n1_m1_460800_187200 5.356235
R5688 n1_m1_460800_187200 n1_m1_465600_187200 5.356235
R5689 n1_m1_465600_187200 n1_m1_470400_187200 5.356235
R5690 n1_m1_470400_187200 n1_m1_475200_187200 5.356235
R5691 n1_m1_475200_187200 n1_m1_480000_187200 5.356235
R5692 n1_m1_480000_187200 n1_m1_484800_187200 5.356235
R5693 n1_m1_484800_187200 n1_m1_489600_187200 5.356235
R5694 n1_m1_489600_187200 n1_m1_494400_187200 5.356235
R5695 n1_m1_494400_187200 n1_m1_499200_187200 5.356235
R5696 n1_m1_499200_187200 n1_m1_504000_187200 5.356235
R5697 n1_m1_504000_187200 n1_m1_508000_187200 4.463529
R5698 n1_m1_508800_187200 n1_m1_508000_187200 0.892706
R5699 n1_m1_508800_187200 n1_m1_513600_187200 5.356235
R5700 n1_m1_513600_187200 n1_m1_518400_187200 5.356235
R5701 n1_m1_518400_187200 n1_m1_523200_187200 5.356235
R5702 n1_m1_523200_187200 n1_m1_528000_187200 5.356235
R5703 n1_m1_528000_187200 n1_m1_532800_187200 5.356235
R5704 n1_m1_532800_187200 n1_m1_536000_187200 3.570824
R5705 n1_m1_537600_187200 n1_m1_536000_187200 1.785412
R5706 n1_m1_537600_187200 n1_m1_542400_187200 5.356235
R5707 n1_m1_542400_187200 n1_m1_547200_187200 5.356235
R5708 n1_m1_547200_187200 n1_m1_552000_187200 5.356235
R5709 n1_m1_552000_187200 n1_m1_556800_187200 5.356235
R5710 n1_m1_556800_187200 n1_m1_561600_187200 5.356235
R5711 n1_m1_561600_187200 n1_m1_564000_187200 2.678118
R5712 n1_m1_566400_187200 n1_m1_564000_187200 2.678118
R5713 n1_m1_566400_187200 n1_m1_571200_187200 5.356235
R5714 n1_m1_571200_187200 n1_m1_576000_187200 5.356235
R5715 n1_m1_576000_187200 n1_m1_580800_187200 5.356235
R5716 n1_m1_580800_187200 n1_m1_585600_187200 5.356235
R5717 n1_m1_585600_187200 n1_m1_590400_187200 5.356235
R5718 n1_m1_590400_187200 n1_m1_592000_187200 1.785412
R5719 n1_m1_595200_187200 n1_m1_592000_187200 3.570824
R5720 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R5721 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R5722 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R5723 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R5724 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R5725 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R5726 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R5727 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R5728 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R5729 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R5730 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R5731 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R5732 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R5733 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R5734 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R5735 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R5736 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R5737 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R5738 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R5739 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R5740 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R5741 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R5742 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R5743 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R5744 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R5745 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R5746 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R5747 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R5748 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R5749 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R5750 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R5751 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R5752 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R5753 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R5754 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R5755 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R5756 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R5757 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R5758 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R5759 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R5760 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R5761 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R5762 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R5763 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R5764 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R5765 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R5766 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R5767 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R5768 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R5769 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R5770 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R5771 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R5772 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R5773 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R5774 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R5775 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R5776 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R5777 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R5778 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R5779 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R5780 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R5781 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R5782 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R5783 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R5784 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R5785 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R5786 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R5787 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R5788 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R5789 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R5790 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R5791 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R5792 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R5793 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R5794 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R5795 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R5796 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R5797 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R5798 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R5799 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R5800 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R5801 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R5802 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R5803 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R5804 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R5805 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R5806 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R5807 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R5808 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R5809 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R5810 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R5811 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R5812 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R5813 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R5814 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R5815 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R5816 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R5817 n1_m1_403200_192000 n1_m1_408000_192000 5.356235
R5818 n1_m1_408000_192000 n1_m1_412800_192000 5.356235
R5819 n1_m1_412800_192000 n1_m1_417600_192000 5.356235
R5820 n1_m1_417600_192000 n1_m1_422400_192000 5.356235
R5821 n1_m1_422400_192000 n1_m1_424000_192000 1.785412
R5822 n1_m1_427200_192000 n1_m1_424000_192000 3.570824
R5823 n1_m1_427200_192000 n1_m1_432000_192000 5.356235
R5824 n1_m1_432000_192000 n1_m1_436800_192000 5.356235
R5825 n1_m1_436800_192000 n1_m1_441600_192000 5.356235
R5826 n1_m1_441600_192000 n1_m1_446400_192000 5.356235
R5827 n1_m1_446400_192000 n1_m1_451200_192000 5.356235
R5828 n1_m1_451200_192000 n1_m1_452000_192000 0.892706
R5829 n1_m1_456000_192000 n1_m1_452000_192000 4.463529
R5830 n1_m1_456000_192000 n1_m1_460800_192000 5.356235
R5831 n1_m1_460800_192000 n1_m1_465600_192000 5.356235
R5832 n1_m1_465600_192000 n1_m1_470400_192000 5.356235
R5833 n1_m1_470400_192000 n1_m1_475200_192000 5.356235
R5834 n1_m1_475200_192000 n1_m1_480000_192000 5.356235
R5835 n1_m1_480000_192000 n1_m1_484800_192000 5.356235
R5836 n1_m1_484800_192000 n1_m1_489600_192000 5.356235
R5837 n1_m1_489600_192000 n1_m1_494400_192000 5.356235
R5838 n1_m1_494400_192000 n1_m1_499200_192000 5.356235
R5839 n1_m1_499200_192000 n1_m1_504000_192000 5.356235
R5840 n1_m1_504000_192000 n1_m1_508000_192000 4.463529
R5841 n1_m1_508800_192000 n1_m1_508000_192000 0.892706
R5842 n1_m1_508800_192000 n1_m1_513600_192000 5.356235
R5843 n1_m1_513600_192000 n1_m1_518400_192000 5.356235
R5844 n1_m1_518400_192000 n1_m1_523200_192000 5.356235
R5845 n1_m1_523200_192000 n1_m1_528000_192000 5.356235
R5846 n1_m1_528000_192000 n1_m1_532800_192000 5.356235
R5847 n1_m1_532800_192000 n1_m1_536000_192000 3.570824
R5848 n1_m1_537600_192000 n1_m1_536000_192000 1.785412
R5849 n1_m1_537600_192000 n1_m1_542400_192000 5.356235
R5850 n1_m1_542400_192000 n1_m1_547200_192000 5.356235
R5851 n1_m1_547200_192000 n1_m1_552000_192000 5.356235
R5852 n1_m1_552000_192000 n1_m1_556800_192000 5.356235
R5853 n1_m1_556800_192000 n1_m1_561600_192000 5.356235
R5854 n1_m1_561600_192000 n1_m1_564000_192000 2.678118
R5855 n1_m1_566400_192000 n1_m1_564000_192000 2.678118
R5856 n1_m1_566400_192000 n1_m1_571200_192000 5.356235
R5857 n1_m1_571200_192000 n1_m1_576000_192000 5.356235
R5858 n1_m1_576000_192000 n1_m1_580800_192000 5.356235
R5859 n1_m1_580800_192000 n1_m1_585600_192000 5.356235
R5860 n1_m1_585600_192000 n1_m1_590400_192000 5.356235
R5861 n1_m1_590400_192000 n1_m1_592000_192000 1.785412
R5862 n1_m1_595200_192000 n1_m1_592000_192000 3.570824
R5863 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R5864 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R5865 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R5866 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R5867 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R5868 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R5869 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R5870 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R5871 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R5872 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R5873 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R5874 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R5875 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R5876 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R5877 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R5878 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R5879 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R5880 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R5881 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R5882 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R5883 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R5884 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R5885 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R5886 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R5887 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R5888 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R5889 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R5890 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R5891 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R5892 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R5893 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R5894 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R5895 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R5896 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R5897 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R5898 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R5899 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R5900 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R5901 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R5902 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R5903 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R5904 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R5905 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R5906 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R5907 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R5908 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R5909 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R5910 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R5911 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R5912 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R5913 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R5914 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R5915 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R5916 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R5917 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R5918 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R5919 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R5920 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R5921 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R5922 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R5923 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R5924 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R5925 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R5926 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R5927 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R5928 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R5929 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R5930 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R5931 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R5932 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R5933 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R5934 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R5935 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R5936 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R5937 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R5938 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R5939 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R5940 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R5941 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R5942 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R5943 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R5944 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R5945 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R5946 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R5947 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R5948 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R5949 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R5950 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R5951 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R5952 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R5953 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R5954 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R5955 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R5956 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R5957 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R5958 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R5959 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R5960 n1_m1_403200_196800 n1_m1_408000_196800 5.356235
R5961 n1_m1_408000_196800 n1_m1_412800_196800 5.356235
R5962 n1_m1_412800_196800 n1_m1_417600_196800 5.356235
R5963 n1_m1_417600_196800 n1_m1_422400_196800 5.356235
R5964 n1_m1_422400_196800 n1_m1_424000_196800 1.785412
R5965 n1_m1_427200_196800 n1_m1_424000_196800 3.570824
R5966 n1_m1_427200_196800 n1_m1_432000_196800 5.356235
R5967 n1_m1_432000_196800 n1_m1_436800_196800 5.356235
R5968 n1_m1_436800_196800 n1_m1_441600_196800 5.356235
R5969 n1_m1_441600_196800 n1_m1_446400_196800 5.356235
R5970 n1_m1_446400_196800 n1_m1_451200_196800 5.356235
R5971 n1_m1_451200_196800 n1_m1_452000_196800 0.892706
R5972 n1_m1_456000_196800 n1_m1_452000_196800 4.463529
R5973 n1_m1_456000_196800 n1_m1_460800_196800 5.356235
R5974 n1_m1_460800_196800 n1_m1_465600_196800 5.356235
R5975 n1_m1_465600_196800 n1_m1_470400_196800 5.356235
R5976 n1_m1_470400_196800 n1_m1_475200_196800 5.356235
R5977 n1_m1_475200_196800 n1_m1_480000_196800 5.356235
R5978 n1_m1_480000_196800 n1_m1_484800_196800 5.356235
R5979 n1_m1_484800_196800 n1_m1_489600_196800 5.356235
R5980 n1_m1_489600_196800 n1_m1_494400_196800 5.356235
R5981 n1_m1_494400_196800 n1_m1_499200_196800 5.356235
R5982 n1_m1_499200_196800 n1_m1_504000_196800 5.356235
R5983 n1_m1_504000_196800 n1_m1_508000_196800 4.463529
R5984 n1_m1_508800_196800 n1_m1_508000_196800 0.892706
R5985 n1_m1_508800_196800 n1_m1_513600_196800 5.356235
R5986 n1_m1_513600_196800 n1_m1_518400_196800 5.356235
R5987 n1_m1_518400_196800 n1_m1_523200_196800 5.356235
R5988 n1_m1_523200_196800 n1_m1_528000_196800 5.356235
R5989 n1_m1_528000_196800 n1_m1_532800_196800 5.356235
R5990 n1_m1_532800_196800 n1_m1_536000_196800 3.570824
R5991 n1_m1_537600_196800 n1_m1_536000_196800 1.785412
R5992 n1_m1_537600_196800 n1_m1_542400_196800 5.356235
R5993 n1_m1_542400_196800 n1_m1_547200_196800 5.356235
R5994 n1_m1_547200_196800 n1_m1_552000_196800 5.356235
R5995 n1_m1_552000_196800 n1_m1_556800_196800 5.356235
R5996 n1_m1_556800_196800 n1_m1_561600_196800 5.356235
R5997 n1_m1_561600_196800 n1_m1_564000_196800 2.678118
R5998 n1_m1_566400_196800 n1_m1_564000_196800 2.678118
R5999 n1_m1_566400_196800 n1_m1_571200_196800 5.356235
R6000 n1_m1_571200_196800 n1_m1_576000_196800 5.356235
R6001 n1_m1_576000_196800 n1_m1_580800_196800 5.356235
R6002 n1_m1_580800_196800 n1_m1_585600_196800 5.356235
R6003 n1_m1_585600_196800 n1_m1_590400_196800 5.356235
R6004 n1_m1_590400_196800 n1_m1_592000_196800 1.785412
R6005 n1_m1_595200_196800 n1_m1_592000_196800 3.570824
R6006 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R6007 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R6008 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R6009 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R6010 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R6011 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R6012 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R6013 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R6014 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R6015 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R6016 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R6017 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R6018 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R6019 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R6020 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R6021 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R6022 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R6023 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R6024 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R6025 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R6026 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R6027 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R6028 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R6029 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R6030 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R6031 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R6032 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R6033 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R6034 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R6035 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R6036 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R6037 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R6038 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R6039 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R6040 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R6041 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R6042 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R6043 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R6044 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R6045 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R6046 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R6047 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R6048 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R6049 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R6050 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R6051 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R6052 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R6053 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R6054 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R6055 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R6056 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R6057 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R6058 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R6059 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R6060 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R6061 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R6062 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R6063 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R6064 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R6065 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R6066 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R6067 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R6068 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R6069 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R6070 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R6071 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R6072 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R6073 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R6074 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R6075 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R6076 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R6077 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R6078 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R6079 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R6080 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R6081 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R6082 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R6083 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R6084 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R6085 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R6086 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R6087 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R6088 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R6089 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R6090 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R6091 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R6092 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R6093 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R6094 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R6095 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R6096 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R6097 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R6098 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R6099 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R6100 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R6101 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R6102 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R6103 n1_m1_403200_201600 n1_m1_408000_201600 5.356235
R6104 n1_m1_408000_201600 n1_m1_412800_201600 5.356235
R6105 n1_m1_412800_201600 n1_m1_417600_201600 5.356235
R6106 n1_m1_417600_201600 n1_m1_422400_201600 5.356235
R6107 n1_m1_422400_201600 n1_m1_424000_201600 1.785412
R6108 n1_m1_427200_201600 n1_m1_424000_201600 3.570824
R6109 n1_m1_427200_201600 n1_m1_432000_201600 5.356235
R6110 n1_m1_432000_201600 n1_m1_436800_201600 5.356235
R6111 n1_m1_436800_201600 n1_m1_441600_201600 5.356235
R6112 n1_m1_441600_201600 n1_m1_446400_201600 5.356235
R6113 n1_m1_446400_201600 n1_m1_451200_201600 5.356235
R6114 n1_m1_451200_201600 n1_m1_452000_201600 0.892706
R6115 n1_m1_456000_201600 n1_m1_452000_201600 4.463529
R6116 n1_m1_456000_201600 n1_m1_460800_201600 5.356235
R6117 n1_m1_460800_201600 n1_m1_465600_201600 5.356235
R6118 n1_m1_465600_201600 n1_m1_470400_201600 5.356235
R6119 n1_m1_470400_201600 n1_m1_475200_201600 5.356235
R6120 n1_m1_475200_201600 n1_m1_480000_201600 5.356235
R6121 n1_m1_480000_201600 n1_m1_484800_201600 5.356235
R6122 n1_m1_484800_201600 n1_m1_489600_201600 5.356235
R6123 n1_m1_489600_201600 n1_m1_494400_201600 5.356235
R6124 n1_m1_494400_201600 n1_m1_499200_201600 5.356235
R6125 n1_m1_499200_201600 n1_m1_504000_201600 5.356235
R6126 n1_m1_504000_201600 n1_m1_508000_201600 4.463529
R6127 n1_m1_508800_201600 n1_m1_508000_201600 0.892706
R6128 n1_m1_508800_201600 n1_m1_513600_201600 5.356235
R6129 n1_m1_513600_201600 n1_m1_518400_201600 5.356235
R6130 n1_m1_518400_201600 n1_m1_523200_201600 5.356235
R6131 n1_m1_523200_201600 n1_m1_528000_201600 5.356235
R6132 n1_m1_528000_201600 n1_m1_532800_201600 5.356235
R6133 n1_m1_532800_201600 n1_m1_536000_201600 3.570824
R6134 n1_m1_537600_201600 n1_m1_536000_201600 1.785412
R6135 n1_m1_537600_201600 n1_m1_542400_201600 5.356235
R6136 n1_m1_542400_201600 n1_m1_547200_201600 5.356235
R6137 n1_m1_547200_201600 n1_m1_552000_201600 5.356235
R6138 n1_m1_552000_201600 n1_m1_556800_201600 5.356235
R6139 n1_m1_556800_201600 n1_m1_561600_201600 5.356235
R6140 n1_m1_561600_201600 n1_m1_564000_201600 2.678118
R6141 n1_m1_566400_201600 n1_m1_564000_201600 2.678118
R6142 n1_m1_566400_201600 n1_m1_571200_201600 5.356235
R6143 n1_m1_571200_201600 n1_m1_576000_201600 5.356235
R6144 n1_m1_576000_201600 n1_m1_580800_201600 5.356235
R6145 n1_m1_580800_201600 n1_m1_585600_201600 5.356235
R6146 n1_m1_585600_201600 n1_m1_590400_201600 5.356235
R6147 n1_m1_590400_201600 n1_m1_592000_201600 1.785412
R6148 n1_m1_595200_201600 n1_m1_592000_201600 3.570824
R6149 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R6150 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R6151 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R6152 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R6153 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R6154 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R6155 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R6156 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R6157 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R6158 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R6159 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R6160 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R6161 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R6162 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R6163 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R6164 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R6165 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R6166 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R6167 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R6168 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R6169 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R6170 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R6171 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R6172 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R6173 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R6174 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R6175 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R6176 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R6177 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R6178 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R6179 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R6180 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R6181 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R6182 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R6183 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R6184 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R6185 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R6186 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R6187 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R6188 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R6189 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R6190 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R6191 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R6192 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R6193 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R6194 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R6195 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R6196 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R6197 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R6198 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R6199 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R6200 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R6201 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R6202 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R6203 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R6204 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R6205 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R6206 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R6207 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R6208 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R6209 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R6210 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R6211 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R6212 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R6213 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R6214 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R6215 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R6216 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R6217 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R6218 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R6219 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R6220 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R6221 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R6222 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R6223 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R6224 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R6225 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R6226 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R6227 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R6228 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R6229 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R6230 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R6231 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R6232 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R6233 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R6234 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R6235 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R6236 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R6237 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R6238 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R6239 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R6240 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R6241 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R6242 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R6243 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R6244 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R6245 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R6246 n1_m1_403200_206400 n1_m1_408000_206400 5.356235
R6247 n1_m1_408000_206400 n1_m1_412800_206400 5.356235
R6248 n1_m1_412800_206400 n1_m1_417600_206400 5.356235
R6249 n1_m1_417600_206400 n1_m1_422400_206400 5.356235
R6250 n1_m1_422400_206400 n1_m1_424000_206400 1.785412
R6251 n1_m1_427200_206400 n1_m1_424000_206400 3.570824
R6252 n1_m1_427200_206400 n1_m1_432000_206400 5.356235
R6253 n1_m1_432000_206400 n1_m1_436800_206400 5.356235
R6254 n1_m1_436800_206400 n1_m1_441600_206400 5.356235
R6255 n1_m1_441600_206400 n1_m1_446400_206400 5.356235
R6256 n1_m1_446400_206400 n1_m1_451200_206400 5.356235
R6257 n1_m1_451200_206400 n1_m1_452000_206400 0.892706
R6258 n1_m1_456000_206400 n1_m1_452000_206400 4.463529
R6259 n1_m1_456000_206400 n1_m1_460800_206400 5.356235
R6260 n1_m1_460800_206400 n1_m1_465600_206400 5.356235
R6261 n1_m1_465600_206400 n1_m1_470400_206400 5.356235
R6262 n1_m1_470400_206400 n1_m1_475200_206400 5.356235
R6263 n1_m1_475200_206400 n1_m1_480000_206400 5.356235
R6264 n1_m1_480000_206400 n1_m1_484800_206400 5.356235
R6265 n1_m1_484800_206400 n1_m1_489600_206400 5.356235
R6266 n1_m1_489600_206400 n1_m1_494400_206400 5.356235
R6267 n1_m1_494400_206400 n1_m1_499200_206400 5.356235
R6268 n1_m1_499200_206400 n1_m1_504000_206400 5.356235
R6269 n1_m1_504000_206400 n1_m1_508000_206400 4.463529
R6270 n1_m1_508800_206400 n1_m1_508000_206400 0.892706
R6271 n1_m1_508800_206400 n1_m1_513600_206400 5.356235
R6272 n1_m1_513600_206400 n1_m1_518400_206400 5.356235
R6273 n1_m1_518400_206400 n1_m1_523200_206400 5.356235
R6274 n1_m1_523200_206400 n1_m1_528000_206400 5.356235
R6275 n1_m1_528000_206400 n1_m1_532800_206400 5.356235
R6276 n1_m1_532800_206400 n1_m1_536000_206400 3.570824
R6277 n1_m1_537600_206400 n1_m1_536000_206400 1.785412
R6278 n1_m1_537600_206400 n1_m1_542400_206400 5.356235
R6279 n1_m1_542400_206400 n1_m1_547200_206400 5.356235
R6280 n1_m1_547200_206400 n1_m1_552000_206400 5.356235
R6281 n1_m1_552000_206400 n1_m1_556800_206400 5.356235
R6282 n1_m1_556800_206400 n1_m1_561600_206400 5.356235
R6283 n1_m1_561600_206400 n1_m1_564000_206400 2.678118
R6284 n1_m1_566400_206400 n1_m1_564000_206400 2.678118
R6285 n1_m1_566400_206400 n1_m1_571200_206400 5.356235
R6286 n1_m1_571200_206400 n1_m1_576000_206400 5.356235
R6287 n1_m1_576000_206400 n1_m1_580800_206400 5.356235
R6288 n1_m1_580800_206400 n1_m1_585600_206400 5.356235
R6289 n1_m1_585600_206400 n1_m1_590400_206400 5.356235
R6290 n1_m1_590400_206400 n1_m1_592000_206400 1.785412
R6291 n1_m1_595200_206400 n1_m1_592000_206400 3.570824
R6292 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R6293 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R6294 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R6295 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R6296 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R6297 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R6298 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R6299 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R6300 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R6301 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R6302 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R6303 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R6304 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R6305 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R6306 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R6307 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R6308 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R6309 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R6310 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R6311 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R6312 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R6313 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R6314 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R6315 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R6316 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R6317 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R6318 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R6319 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R6320 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R6321 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R6322 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R6323 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R6324 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R6325 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R6326 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R6327 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R6328 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R6329 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R6330 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R6331 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R6332 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R6333 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R6334 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R6335 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R6336 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R6337 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R6338 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R6339 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R6340 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R6341 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R6342 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R6343 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R6344 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R6345 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R6346 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R6347 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R6348 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R6349 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R6350 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R6351 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R6352 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R6353 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R6354 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R6355 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R6356 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R6357 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R6358 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R6359 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R6360 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R6361 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R6362 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R6363 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R6364 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R6365 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R6366 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R6367 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R6368 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R6369 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R6370 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R6371 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R6372 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R6373 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R6374 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R6375 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R6376 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R6377 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R6378 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R6379 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R6380 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R6381 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R6382 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R6383 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R6384 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R6385 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R6386 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R6387 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R6388 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R6389 n1_m1_403200_211200 n1_m1_408000_211200 5.356235
R6390 n1_m1_408000_211200 n1_m1_412800_211200 5.356235
R6391 n1_m1_412800_211200 n1_m1_417600_211200 5.356235
R6392 n1_m1_417600_211200 n1_m1_422400_211200 5.356235
R6393 n1_m1_422400_211200 n1_m1_424000_211200 1.785412
R6394 n1_m1_427200_211200 n1_m1_424000_211200 3.570824
R6395 n1_m1_427200_211200 n1_m1_432000_211200 5.356235
R6396 n1_m1_432000_211200 n1_m1_436800_211200 5.356235
R6397 n1_m1_436800_211200 n1_m1_441600_211200 5.356235
R6398 n1_m1_441600_211200 n1_m1_446400_211200 5.356235
R6399 n1_m1_446400_211200 n1_m1_451200_211200 5.356235
R6400 n1_m1_451200_211200 n1_m1_452000_211200 0.892706
R6401 n1_m1_456000_211200 n1_m1_452000_211200 4.463529
R6402 n1_m1_456000_211200 n1_m1_460800_211200 5.356235
R6403 n1_m1_460800_211200 n1_m1_465600_211200 5.356235
R6404 n1_m1_465600_211200 n1_m1_470400_211200 5.356235
R6405 n1_m1_470400_211200 n1_m1_475200_211200 5.356235
R6406 n1_m1_475200_211200 n1_m1_480000_211200 5.356235
R6407 n1_m1_480000_211200 n1_m1_484800_211200 5.356235
R6408 n1_m1_484800_211200 n1_m1_489600_211200 5.356235
R6409 n1_m1_489600_211200 n1_m1_494400_211200 5.356235
R6410 n1_m1_494400_211200 n1_m1_499200_211200 5.356235
R6411 n1_m1_499200_211200 n1_m1_504000_211200 5.356235
R6412 n1_m1_504000_211200 n1_m1_508000_211200 4.463529
R6413 n1_m1_508800_211200 n1_m1_508000_211200 0.892706
R6414 n1_m1_508800_211200 n1_m1_513600_211200 5.356235
R6415 n1_m1_513600_211200 n1_m1_518400_211200 5.356235
R6416 n1_m1_518400_211200 n1_m1_523200_211200 5.356235
R6417 n1_m1_523200_211200 n1_m1_528000_211200 5.356235
R6418 n1_m1_528000_211200 n1_m1_532800_211200 5.356235
R6419 n1_m1_532800_211200 n1_m1_536000_211200 3.570824
R6420 n1_m1_537600_211200 n1_m1_536000_211200 1.785412
R6421 n1_m1_537600_211200 n1_m1_542400_211200 5.356235
R6422 n1_m1_542400_211200 n1_m1_547200_211200 5.356235
R6423 n1_m1_547200_211200 n1_m1_552000_211200 5.356235
R6424 n1_m1_552000_211200 n1_m1_556800_211200 5.356235
R6425 n1_m1_556800_211200 n1_m1_561600_211200 5.356235
R6426 n1_m1_561600_211200 n1_m1_564000_211200 2.678118
R6427 n1_m1_566400_211200 n1_m1_564000_211200 2.678118
R6428 n1_m1_566400_211200 n1_m1_571200_211200 5.356235
R6429 n1_m1_571200_211200 n1_m1_576000_211200 5.356235
R6430 n1_m1_576000_211200 n1_m1_580800_211200 5.356235
R6431 n1_m1_580800_211200 n1_m1_585600_211200 5.356235
R6432 n1_m1_585600_211200 n1_m1_590400_211200 5.356235
R6433 n1_m1_590400_211200 n1_m1_592000_211200 1.785412
R6434 n1_m1_595200_211200 n1_m1_592000_211200 3.570824
R6435 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R6436 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R6437 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R6438 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R6439 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R6440 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R6441 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R6442 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R6443 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R6444 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R6445 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R6446 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R6447 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R6448 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R6449 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R6450 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R6451 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R6452 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R6453 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R6454 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R6455 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R6456 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R6457 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R6458 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R6459 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R6460 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R6461 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R6462 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R6463 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R6464 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R6465 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R6466 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R6467 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R6468 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R6469 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R6470 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R6471 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R6472 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R6473 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R6474 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R6475 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R6476 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R6477 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R6478 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R6479 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R6480 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R6481 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R6482 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R6483 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R6484 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R6485 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R6486 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R6487 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R6488 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R6489 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R6490 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R6491 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R6492 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R6493 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R6494 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R6495 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R6496 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R6497 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R6498 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R6499 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R6500 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R6501 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R6502 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R6503 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R6504 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R6505 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R6506 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R6507 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R6508 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R6509 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R6510 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R6511 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R6512 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R6513 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R6514 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R6515 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R6516 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R6517 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R6518 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R6519 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R6520 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R6521 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R6522 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R6523 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R6524 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R6525 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R6526 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R6527 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R6528 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R6529 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R6530 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R6531 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R6532 n1_m1_403200_216000 n1_m1_408000_216000 5.356235
R6533 n1_m1_408000_216000 n1_m1_412800_216000 5.356235
R6534 n1_m1_412800_216000 n1_m1_417600_216000 5.356235
R6535 n1_m1_417600_216000 n1_m1_422400_216000 5.356235
R6536 n1_m1_422400_216000 n1_m1_424000_216000 1.785412
R6537 n1_m1_427200_216000 n1_m1_424000_216000 3.570824
R6538 n1_m1_427200_216000 n1_m1_432000_216000 5.356235
R6539 n1_m1_432000_216000 n1_m1_436800_216000 5.356235
R6540 n1_m1_436800_216000 n1_m1_441600_216000 5.356235
R6541 n1_m1_441600_216000 n1_m1_446400_216000 5.356235
R6542 n1_m1_446400_216000 n1_m1_451200_216000 5.356235
R6543 n1_m1_451200_216000 n1_m1_452000_216000 0.892706
R6544 n1_m1_456000_216000 n1_m1_452000_216000 4.463529
R6545 n1_m1_456000_216000 n1_m1_460800_216000 5.356235
R6546 n1_m1_460800_216000 n1_m1_465600_216000 5.356235
R6547 n1_m1_465600_216000 n1_m1_470400_216000 5.356235
R6548 n1_m1_470400_216000 n1_m1_475200_216000 5.356235
R6549 n1_m1_475200_216000 n1_m1_480000_216000 5.356235
R6550 n1_m1_480000_216000 n1_m1_484800_216000 5.356235
R6551 n1_m1_484800_216000 n1_m1_489600_216000 5.356235
R6552 n1_m1_489600_216000 n1_m1_494400_216000 5.356235
R6553 n1_m1_494400_216000 n1_m1_499200_216000 5.356235
R6554 n1_m1_499200_216000 n1_m1_504000_216000 5.356235
R6555 n1_m1_504000_216000 n1_m1_508000_216000 4.463529
R6556 n1_m1_508800_216000 n1_m1_508000_216000 0.892706
R6557 n1_m1_508800_216000 n1_m1_513600_216000 5.356235
R6558 n1_m1_513600_216000 n1_m1_518400_216000 5.356235
R6559 n1_m1_518400_216000 n1_m1_523200_216000 5.356235
R6560 n1_m1_523200_216000 n1_m1_528000_216000 5.356235
R6561 n1_m1_528000_216000 n1_m1_532800_216000 5.356235
R6562 n1_m1_532800_216000 n1_m1_536000_216000 3.570824
R6563 n1_m1_537600_216000 n1_m1_536000_216000 1.785412
R6564 n1_m1_537600_216000 n1_m1_542400_216000 5.356235
R6565 n1_m1_542400_216000 n1_m1_547200_216000 5.356235
R6566 n1_m1_547200_216000 n1_m1_552000_216000 5.356235
R6567 n1_m1_552000_216000 n1_m1_556800_216000 5.356235
R6568 n1_m1_556800_216000 n1_m1_561600_216000 5.356235
R6569 n1_m1_561600_216000 n1_m1_564000_216000 2.678118
R6570 n1_m1_566400_216000 n1_m1_564000_216000 2.678118
R6571 n1_m1_566400_216000 n1_m1_571200_216000 5.356235
R6572 n1_m1_571200_216000 n1_m1_576000_216000 5.356235
R6573 n1_m1_576000_216000 n1_m1_580800_216000 5.356235
R6574 n1_m1_580800_216000 n1_m1_585600_216000 5.356235
R6575 n1_m1_585600_216000 n1_m1_590400_216000 5.356235
R6576 n1_m1_590400_216000 n1_m1_592000_216000 1.785412
R6577 n1_m1_595200_216000 n1_m1_592000_216000 3.570824
R6578 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R6579 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R6580 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R6581 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R6582 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R6583 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R6584 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R6585 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R6586 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R6587 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R6588 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R6589 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R6590 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R6591 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R6592 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R6593 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R6594 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R6595 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R6596 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R6597 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R6598 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R6599 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R6600 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R6601 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R6602 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R6603 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R6604 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R6605 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R6606 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R6607 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R6608 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R6609 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R6610 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R6611 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R6612 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R6613 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R6614 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R6615 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R6616 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R6617 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R6618 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R6619 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R6620 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R6621 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R6622 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R6623 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R6624 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R6625 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R6626 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R6627 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R6628 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R6629 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R6630 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R6631 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R6632 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R6633 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R6634 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R6635 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R6636 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R6637 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R6638 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R6639 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R6640 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R6641 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R6642 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R6643 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R6644 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R6645 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R6646 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R6647 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R6648 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R6649 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R6650 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R6651 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R6652 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R6653 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R6654 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R6655 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R6656 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R6657 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R6658 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R6659 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R6660 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R6661 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R6662 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R6663 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R6664 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R6665 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R6666 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R6667 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R6668 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R6669 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R6670 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R6671 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R6672 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R6673 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R6674 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R6675 n1_m1_403200_220800 n1_m1_408000_220800 5.356235
R6676 n1_m1_408000_220800 n1_m1_412800_220800 5.356235
R6677 n1_m1_412800_220800 n1_m1_417600_220800 5.356235
R6678 n1_m1_417600_220800 n1_m1_422400_220800 5.356235
R6679 n1_m1_422400_220800 n1_m1_424000_220800 1.785412
R6680 n1_m1_427200_220800 n1_m1_424000_220800 3.570824
R6681 n1_m1_427200_220800 n1_m1_432000_220800 5.356235
R6682 n1_m1_432000_220800 n1_m1_436800_220800 5.356235
R6683 n1_m1_436800_220800 n1_m1_441600_220800 5.356235
R6684 n1_m1_441600_220800 n1_m1_446400_220800 5.356235
R6685 n1_m1_446400_220800 n1_m1_451200_220800 5.356235
R6686 n1_m1_451200_220800 n1_m1_452000_220800 0.892706
R6687 n1_m1_456000_220800 n1_m1_452000_220800 4.463529
R6688 n1_m1_456000_220800 n1_m1_460800_220800 5.356235
R6689 n1_m1_460800_220800 n1_m1_465600_220800 5.356235
R6690 n1_m1_465600_220800 n1_m1_470400_220800 5.356235
R6691 n1_m1_470400_220800 n1_m1_475200_220800 5.356235
R6692 n1_m1_475200_220800 n1_m1_480000_220800 5.356235
R6693 n1_m1_480000_220800 n1_m1_484800_220800 5.356235
R6694 n1_m1_484800_220800 n1_m1_489600_220800 5.356235
R6695 n1_m1_489600_220800 n1_m1_494400_220800 5.356235
R6696 n1_m1_494400_220800 n1_m1_499200_220800 5.356235
R6697 n1_m1_499200_220800 n1_m1_504000_220800 5.356235
R6698 n1_m1_504000_220800 n1_m1_508000_220800 4.463529
R6699 n1_m1_508800_220800 n1_m1_508000_220800 0.892706
R6700 n1_m1_508800_220800 n1_m1_513600_220800 5.356235
R6701 n1_m1_513600_220800 n1_m1_518400_220800 5.356235
R6702 n1_m1_518400_220800 n1_m1_523200_220800 5.356235
R6703 n1_m1_523200_220800 n1_m1_528000_220800 5.356235
R6704 n1_m1_528000_220800 n1_m1_532800_220800 5.356235
R6705 n1_m1_532800_220800 n1_m1_536000_220800 3.570824
R6706 n1_m1_537600_220800 n1_m1_536000_220800 1.785412
R6707 n1_m1_537600_220800 n1_m1_542400_220800 5.356235
R6708 n1_m1_542400_220800 n1_m1_547200_220800 5.356235
R6709 n1_m1_547200_220800 n1_m1_552000_220800 5.356235
R6710 n1_m1_552000_220800 n1_m1_556800_220800 5.356235
R6711 n1_m1_556800_220800 n1_m1_561600_220800 5.356235
R6712 n1_m1_561600_220800 n1_m1_564000_220800 2.678118
R6713 n1_m1_566400_220800 n1_m1_564000_220800 2.678118
R6714 n1_m1_566400_220800 n1_m1_571200_220800 5.356235
R6715 n1_m1_571200_220800 n1_m1_576000_220800 5.356235
R6716 n1_m1_576000_220800 n1_m1_580800_220800 5.356235
R6717 n1_m1_580800_220800 n1_m1_585600_220800 5.356235
R6718 n1_m1_585600_220800 n1_m1_590400_220800 5.356235
R6719 n1_m1_590400_220800 n1_m1_592000_220800 1.785412
R6720 n1_m1_595200_220800 n1_m1_592000_220800 3.570824
R6721 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R6722 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R6723 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R6724 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R6725 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R6726 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R6727 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R6728 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R6729 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R6730 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R6731 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R6732 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R6733 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R6734 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R6735 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R6736 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R6737 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R6738 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R6739 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R6740 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R6741 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R6742 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R6743 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R6744 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R6745 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R6746 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R6747 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R6748 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R6749 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R6750 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R6751 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R6752 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R6753 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R6754 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R6755 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R6756 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R6757 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R6758 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R6759 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R6760 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R6761 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R6762 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R6763 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R6764 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R6765 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R6766 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R6767 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R6768 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R6769 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R6770 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R6771 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R6772 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R6773 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R6774 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R6775 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R6776 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R6777 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R6778 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R6779 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R6780 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R6781 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R6782 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R6783 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R6784 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R6785 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R6786 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R6787 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R6788 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R6789 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R6790 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R6791 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R6792 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R6793 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R6794 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R6795 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R6796 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R6797 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R6798 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R6799 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R6800 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R6801 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R6802 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R6803 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R6804 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R6805 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R6806 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R6807 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R6808 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R6809 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R6810 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R6811 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R6812 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R6813 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R6814 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R6815 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R6816 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R6817 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R6818 n1_m1_403200_225600 n1_m1_408000_225600 5.356235
R6819 n1_m1_408000_225600 n1_m1_412800_225600 5.356235
R6820 n1_m1_412800_225600 n1_m1_417600_225600 5.356235
R6821 n1_m1_417600_225600 n1_m1_422400_225600 5.356235
R6822 n1_m1_422400_225600 n1_m1_424000_225600 1.785412
R6823 n1_m1_427200_225600 n1_m1_424000_225600 3.570824
R6824 n1_m1_427200_225600 n1_m1_432000_225600 5.356235
R6825 n1_m1_432000_225600 n1_m1_436800_225600 5.356235
R6826 n1_m1_436800_225600 n1_m1_441600_225600 5.356235
R6827 n1_m1_441600_225600 n1_m1_446400_225600 5.356235
R6828 n1_m1_446400_225600 n1_m1_451200_225600 5.356235
R6829 n1_m1_451200_225600 n1_m1_452000_225600 0.892706
R6830 n1_m1_456000_225600 n1_m1_452000_225600 4.463529
R6831 n1_m1_456000_225600 n1_m1_460800_225600 5.356235
R6832 n1_m1_460800_225600 n1_m1_465600_225600 5.356235
R6833 n1_m1_465600_225600 n1_m1_470400_225600 5.356235
R6834 n1_m1_470400_225600 n1_m1_475200_225600 5.356235
R6835 n1_m1_475200_225600 n1_m1_480000_225600 5.356235
R6836 n1_m1_480000_225600 n1_m1_484800_225600 5.356235
R6837 n1_m1_484800_225600 n1_m1_489600_225600 5.356235
R6838 n1_m1_489600_225600 n1_m1_494400_225600 5.356235
R6839 n1_m1_494400_225600 n1_m1_499200_225600 5.356235
R6840 n1_m1_499200_225600 n1_m1_504000_225600 5.356235
R6841 n1_m1_504000_225600 n1_m1_508000_225600 4.463529
R6842 n1_m1_508800_225600 n1_m1_508000_225600 0.892706
R6843 n1_m1_508800_225600 n1_m1_513600_225600 5.356235
R6844 n1_m1_513600_225600 n1_m1_518400_225600 5.356235
R6845 n1_m1_518400_225600 n1_m1_523200_225600 5.356235
R6846 n1_m1_523200_225600 n1_m1_528000_225600 5.356235
R6847 n1_m1_528000_225600 n1_m1_532800_225600 5.356235
R6848 n1_m1_532800_225600 n1_m1_536000_225600 3.570824
R6849 n1_m1_537600_225600 n1_m1_536000_225600 1.785412
R6850 n1_m1_537600_225600 n1_m1_542400_225600 5.356235
R6851 n1_m1_542400_225600 n1_m1_547200_225600 5.356235
R6852 n1_m1_547200_225600 n1_m1_552000_225600 5.356235
R6853 n1_m1_552000_225600 n1_m1_556800_225600 5.356235
R6854 n1_m1_556800_225600 n1_m1_561600_225600 5.356235
R6855 n1_m1_561600_225600 n1_m1_564000_225600 2.678118
R6856 n1_m1_566400_225600 n1_m1_564000_225600 2.678118
R6857 n1_m1_566400_225600 n1_m1_571200_225600 5.356235
R6858 n1_m1_571200_225600 n1_m1_576000_225600 5.356235
R6859 n1_m1_576000_225600 n1_m1_580800_225600 5.356235
R6860 n1_m1_580800_225600 n1_m1_585600_225600 5.356235
R6861 n1_m1_585600_225600 n1_m1_590400_225600 5.356235
R6862 n1_m1_590400_225600 n1_m1_592000_225600 1.785412
R6863 n1_m1_595200_225600 n1_m1_592000_225600 3.570824
R6864 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R6865 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R6866 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R6867 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R6868 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R6869 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R6870 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R6871 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R6872 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R6873 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R6874 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R6875 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R6876 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R6877 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R6878 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R6879 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R6880 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R6881 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R6882 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R6883 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R6884 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R6885 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R6886 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R6887 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R6888 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R6889 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R6890 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R6891 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R6892 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R6893 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R6894 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R6895 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R6896 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R6897 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R6898 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R6899 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R6900 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R6901 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R6902 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R6903 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R6904 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R6905 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R6906 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R6907 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R6908 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R6909 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R6910 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R6911 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R6912 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R6913 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R6914 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R6915 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R6916 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R6917 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R6918 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R6919 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R6920 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R6921 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R6922 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R6923 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R6924 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R6925 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R6926 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R6927 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R6928 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R6929 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R6930 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R6931 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R6932 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R6933 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R6934 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R6935 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R6936 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R6937 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R6938 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R6939 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R6940 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R6941 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R6942 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R6943 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R6944 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R6945 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R6946 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R6947 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R6948 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R6949 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R6950 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R6951 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R6952 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R6953 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R6954 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R6955 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R6956 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R6957 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R6958 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R6959 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R6960 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R6961 n1_m1_403200_230400 n1_m1_408000_230400 5.356235
R6962 n1_m1_408000_230400 n1_m1_412800_230400 5.356235
R6963 n1_m1_412800_230400 n1_m1_417600_230400 5.356235
R6964 n1_m1_417600_230400 n1_m1_422400_230400 5.356235
R6965 n1_m1_422400_230400 n1_m1_424000_230400 1.785412
R6966 n1_m1_427200_230400 n1_m1_424000_230400 3.570824
R6967 n1_m1_427200_230400 n1_m1_432000_230400 5.356235
R6968 n1_m1_432000_230400 n1_m1_436800_230400 5.356235
R6969 n1_m1_436800_230400 n1_m1_441600_230400 5.356235
R6970 n1_m1_441600_230400 n1_m1_446400_230400 5.356235
R6971 n1_m1_446400_230400 n1_m1_451200_230400 5.356235
R6972 n1_m1_451200_230400 n1_m1_452000_230400 0.892706
R6973 n1_m1_456000_230400 n1_m1_452000_230400 4.463529
R6974 n1_m1_456000_230400 n1_m1_460800_230400 5.356235
R6975 n1_m1_460800_230400 n1_m1_465600_230400 5.356235
R6976 n1_m1_465600_230400 n1_m1_470400_230400 5.356235
R6977 n1_m1_470400_230400 n1_m1_475200_230400 5.356235
R6978 n1_m1_475200_230400 n1_m1_480000_230400 5.356235
R6979 n1_m1_480000_230400 n1_m1_484800_230400 5.356235
R6980 n1_m1_484800_230400 n1_m1_489600_230400 5.356235
R6981 n1_m1_489600_230400 n1_m1_494400_230400 5.356235
R6982 n1_m1_494400_230400 n1_m1_499200_230400 5.356235
R6983 n1_m1_499200_230400 n1_m1_504000_230400 5.356235
R6984 n1_m1_504000_230400 n1_m1_508000_230400 4.463529
R6985 n1_m1_508800_230400 n1_m1_508000_230400 0.892706
R6986 n1_m1_508800_230400 n1_m1_513600_230400 5.356235
R6987 n1_m1_513600_230400 n1_m1_518400_230400 5.356235
R6988 n1_m1_518400_230400 n1_m1_523200_230400 5.356235
R6989 n1_m1_523200_230400 n1_m1_528000_230400 5.356235
R6990 n1_m1_528000_230400 n1_m1_532800_230400 5.356235
R6991 n1_m1_532800_230400 n1_m1_536000_230400 3.570824
R6992 n1_m1_537600_230400 n1_m1_536000_230400 1.785412
R6993 n1_m1_537600_230400 n1_m1_542400_230400 5.356235
R6994 n1_m1_542400_230400 n1_m1_547200_230400 5.356235
R6995 n1_m1_547200_230400 n1_m1_552000_230400 5.356235
R6996 n1_m1_552000_230400 n1_m1_556800_230400 5.356235
R6997 n1_m1_556800_230400 n1_m1_561600_230400 5.356235
R6998 n1_m1_561600_230400 n1_m1_564000_230400 2.678118
R6999 n1_m1_566400_230400 n1_m1_564000_230400 2.678118
R7000 n1_m1_566400_230400 n1_m1_571200_230400 5.356235
R7001 n1_m1_571200_230400 n1_m1_576000_230400 5.356235
R7002 n1_m1_576000_230400 n1_m1_580800_230400 5.356235
R7003 n1_m1_580800_230400 n1_m1_585600_230400 5.356235
R7004 n1_m1_585600_230400 n1_m1_590400_230400 5.356235
R7005 n1_m1_590400_230400 n1_m1_592000_230400 1.785412
R7006 n1_m1_595200_230400 n1_m1_592000_230400 3.570824
R7007 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R7008 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R7009 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R7010 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R7011 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R7012 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R7013 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R7014 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R7015 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R7016 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R7017 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R7018 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R7019 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R7020 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R7021 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R7022 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R7023 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R7024 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R7025 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R7026 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R7027 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R7028 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R7029 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R7030 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R7031 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R7032 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R7033 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R7034 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R7035 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R7036 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R7037 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R7038 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R7039 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R7040 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R7041 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R7042 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R7043 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R7044 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R7045 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R7046 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R7047 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R7048 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R7049 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R7050 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R7051 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R7052 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R7053 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R7054 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R7055 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R7056 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R7057 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R7058 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R7059 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R7060 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R7061 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R7062 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R7063 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R7064 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R7065 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R7066 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R7067 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R7068 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R7069 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R7070 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R7071 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R7072 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R7073 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R7074 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R7075 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R7076 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R7077 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R7078 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R7079 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R7080 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R7081 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R7082 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R7083 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R7084 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R7085 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R7086 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R7087 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R7088 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R7089 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R7090 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R7091 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R7092 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R7093 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R7094 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R7095 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R7096 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R7097 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R7098 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R7099 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R7100 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R7101 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R7102 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R7103 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R7104 n1_m1_403200_235200 n1_m1_408000_235200 5.356235
R7105 n1_m1_408000_235200 n1_m1_412800_235200 5.356235
R7106 n1_m1_412800_235200 n1_m1_417600_235200 5.356235
R7107 n1_m1_417600_235200 n1_m1_422400_235200 5.356235
R7108 n1_m1_422400_235200 n1_m1_424000_235200 1.785412
R7109 n1_m1_427200_235200 n1_m1_424000_235200 3.570824
R7110 n1_m1_427200_235200 n1_m1_432000_235200 5.356235
R7111 n1_m1_432000_235200 n1_m1_436800_235200 5.356235
R7112 n1_m1_436800_235200 n1_m1_441600_235200 5.356235
R7113 n1_m1_441600_235200 n1_m1_446400_235200 5.356235
R7114 n1_m1_446400_235200 n1_m1_451200_235200 5.356235
R7115 n1_m1_451200_235200 n1_m1_452000_235200 0.892706
R7116 n1_m1_456000_235200 n1_m1_452000_235200 4.463529
R7117 n1_m1_456000_235200 n1_m1_460800_235200 5.356235
R7118 n1_m1_460800_235200 n1_m1_465600_235200 5.356235
R7119 n1_m1_465600_235200 n1_m1_470400_235200 5.356235
R7120 n1_m1_470400_235200 n1_m1_475200_235200 5.356235
R7121 n1_m1_475200_235200 n1_m1_480000_235200 5.356235
R7122 n1_m1_480000_235200 n1_m1_484800_235200 5.356235
R7123 n1_m1_484800_235200 n1_m1_489600_235200 5.356235
R7124 n1_m1_489600_235200 n1_m1_494400_235200 5.356235
R7125 n1_m1_494400_235200 n1_m1_499200_235200 5.356235
R7126 n1_m1_499200_235200 n1_m1_504000_235200 5.356235
R7127 n1_m1_504000_235200 n1_m1_508000_235200 4.463529
R7128 n1_m1_508800_235200 n1_m1_508000_235200 0.892706
R7129 n1_m1_508800_235200 n1_m1_513600_235200 5.356235
R7130 n1_m1_513600_235200 n1_m1_518400_235200 5.356235
R7131 n1_m1_518400_235200 n1_m1_523200_235200 5.356235
R7132 n1_m1_523200_235200 n1_m1_528000_235200 5.356235
R7133 n1_m1_528000_235200 n1_m1_532800_235200 5.356235
R7134 n1_m1_532800_235200 n1_m1_536000_235200 3.570824
R7135 n1_m1_537600_235200 n1_m1_536000_235200 1.785412
R7136 n1_m1_537600_235200 n1_m1_542400_235200 5.356235
R7137 n1_m1_542400_235200 n1_m1_547200_235200 5.356235
R7138 n1_m1_547200_235200 n1_m1_552000_235200 5.356235
R7139 n1_m1_552000_235200 n1_m1_556800_235200 5.356235
R7140 n1_m1_556800_235200 n1_m1_561600_235200 5.356235
R7141 n1_m1_561600_235200 n1_m1_564000_235200 2.678118
R7142 n1_m1_566400_235200 n1_m1_564000_235200 2.678118
R7143 n1_m1_566400_235200 n1_m1_571200_235200 5.356235
R7144 n1_m1_571200_235200 n1_m1_576000_235200 5.356235
R7145 n1_m1_576000_235200 n1_m1_580800_235200 5.356235
R7146 n1_m1_580800_235200 n1_m1_585600_235200 5.356235
R7147 n1_m1_585600_235200 n1_m1_590400_235200 5.356235
R7148 n1_m1_590400_235200 n1_m1_592000_235200 1.785412
R7149 n1_m1_595200_235200 n1_m1_592000_235200 3.570824
R7150 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R7151 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R7152 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R7153 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R7154 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R7155 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R7156 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R7157 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R7158 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R7159 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R7160 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R7161 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R7162 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R7163 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R7164 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R7165 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R7166 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R7167 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R7168 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R7169 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R7170 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R7171 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R7172 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R7173 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R7174 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R7175 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R7176 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R7177 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R7178 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R7179 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R7180 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R7181 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R7182 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R7183 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R7184 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R7185 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R7186 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R7187 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R7188 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R7189 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R7190 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R7191 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R7192 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R7193 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R7194 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R7195 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R7196 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R7197 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R7198 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R7199 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R7200 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R7201 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R7202 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R7203 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R7204 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R7205 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R7206 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R7207 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R7208 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R7209 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R7210 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R7211 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R7212 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R7213 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R7214 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R7215 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R7216 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R7217 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R7218 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R7219 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R7220 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R7221 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R7222 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R7223 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R7224 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R7225 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R7226 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R7227 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R7228 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R7229 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R7230 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R7231 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R7232 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R7233 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R7234 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R7235 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R7236 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R7237 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R7238 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R7239 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R7240 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R7241 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R7242 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R7243 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R7244 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R7245 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R7246 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R7247 n1_m1_403200_240000 n1_m1_408000_240000 5.356235
R7248 n1_m1_408000_240000 n1_m1_412800_240000 5.356235
R7249 n1_m1_412800_240000 n1_m1_417600_240000 5.356235
R7250 n1_m1_417600_240000 n1_m1_422400_240000 5.356235
R7251 n1_m1_422400_240000 n1_m1_424000_240000 1.785412
R7252 n1_m1_427200_240000 n1_m1_424000_240000 3.570824
R7253 n1_m1_427200_240000 n1_m1_432000_240000 5.356235
R7254 n1_m1_432000_240000 n1_m1_436800_240000 5.356235
R7255 n1_m1_436800_240000 n1_m1_441600_240000 5.356235
R7256 n1_m1_441600_240000 n1_m1_446400_240000 5.356235
R7257 n1_m1_446400_240000 n1_m1_451200_240000 5.356235
R7258 n1_m1_451200_240000 n1_m1_452000_240000 0.892706
R7259 n1_m1_456000_240000 n1_m1_452000_240000 4.463529
R7260 n1_m1_456000_240000 n1_m1_460800_240000 5.356235
R7261 n1_m1_460800_240000 n1_m1_465600_240000 5.356235
R7262 n1_m1_465600_240000 n1_m1_470400_240000 5.356235
R7263 n1_m1_470400_240000 n1_m1_475200_240000 5.356235
R7264 n1_m1_475200_240000 n1_m1_480000_240000 5.356235
R7265 n1_m1_480000_240000 n1_m1_484800_240000 5.356235
R7266 n1_m1_484800_240000 n1_m1_489600_240000 5.356235
R7267 n1_m1_489600_240000 n1_m1_494400_240000 5.356235
R7268 n1_m1_494400_240000 n1_m1_499200_240000 5.356235
R7269 n1_m1_499200_240000 n1_m1_504000_240000 5.356235
R7270 n1_m1_504000_240000 n1_m1_508000_240000 4.463529
R7271 n1_m1_508800_240000 n1_m1_508000_240000 0.892706
R7272 n1_m1_508800_240000 n1_m1_513600_240000 5.356235
R7273 n1_m1_513600_240000 n1_m1_518400_240000 5.356235
R7274 n1_m1_518400_240000 n1_m1_523200_240000 5.356235
R7275 n1_m1_523200_240000 n1_m1_528000_240000 5.356235
R7276 n1_m1_528000_240000 n1_m1_532800_240000 5.356235
R7277 n1_m1_532800_240000 n1_m1_536000_240000 3.570824
R7278 n1_m1_537600_240000 n1_m1_536000_240000 1.785412
R7279 n1_m1_537600_240000 n1_m1_542400_240000 5.356235
R7280 n1_m1_542400_240000 n1_m1_547200_240000 5.356235
R7281 n1_m1_547200_240000 n1_m1_552000_240000 5.356235
R7282 n1_m1_552000_240000 n1_m1_556800_240000 5.356235
R7283 n1_m1_556800_240000 n1_m1_561600_240000 5.356235
R7284 n1_m1_561600_240000 n1_m1_564000_240000 2.678118
R7285 n1_m1_566400_240000 n1_m1_564000_240000 2.678118
R7286 n1_m1_566400_240000 n1_m1_571200_240000 5.356235
R7287 n1_m1_571200_240000 n1_m1_576000_240000 5.356235
R7288 n1_m1_576000_240000 n1_m1_580800_240000 5.356235
R7289 n1_m1_580800_240000 n1_m1_585600_240000 5.356235
R7290 n1_m1_585600_240000 n1_m1_590400_240000 5.356235
R7291 n1_m1_590400_240000 n1_m1_592000_240000 1.785412
R7292 n1_m1_595200_240000 n1_m1_592000_240000 3.570824
R7293 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R7294 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R7295 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R7296 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R7297 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R7298 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R7299 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R7300 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R7301 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R7302 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R7303 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R7304 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R7305 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R7306 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R7307 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R7308 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R7309 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R7310 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R7311 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R7312 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R7313 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R7314 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R7315 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R7316 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R7317 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R7318 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R7319 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R7320 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R7321 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R7322 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R7323 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R7324 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R7325 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R7326 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R7327 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R7328 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R7329 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R7330 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R7331 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R7332 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R7333 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R7334 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R7335 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R7336 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R7337 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R7338 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R7339 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R7340 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R7341 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R7342 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R7343 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R7344 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R7345 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R7346 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R7347 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R7348 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R7349 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R7350 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R7351 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R7352 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R7353 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R7354 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R7355 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R7356 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R7357 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R7358 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R7359 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R7360 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R7361 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R7362 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R7363 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R7364 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R7365 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R7366 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R7367 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R7368 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R7369 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R7370 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R7371 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R7372 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R7373 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R7374 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R7375 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R7376 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R7377 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R7378 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R7379 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R7380 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R7381 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R7382 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R7383 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R7384 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R7385 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R7386 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R7387 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R7388 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R7389 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R7390 n1_m1_403200_244800 n1_m1_408000_244800 5.356235
R7391 n1_m1_408000_244800 n1_m1_412800_244800 5.356235
R7392 n1_m1_412800_244800 n1_m1_417600_244800 5.356235
R7393 n1_m1_417600_244800 n1_m1_422400_244800 5.356235
R7394 n1_m1_422400_244800 n1_m1_424000_244800 1.785412
R7395 n1_m1_427200_244800 n1_m1_424000_244800 3.570824
R7396 n1_m1_427200_244800 n1_m1_432000_244800 5.356235
R7397 n1_m1_432000_244800 n1_m1_436800_244800 5.356235
R7398 n1_m1_436800_244800 n1_m1_441600_244800 5.356235
R7399 n1_m1_441600_244800 n1_m1_446400_244800 5.356235
R7400 n1_m1_446400_244800 n1_m1_451200_244800 5.356235
R7401 n1_m1_451200_244800 n1_m1_452000_244800 0.892706
R7402 n1_m1_456000_244800 n1_m1_452000_244800 4.463529
R7403 n1_m1_456000_244800 n1_m1_460800_244800 5.356235
R7404 n1_m1_460800_244800 n1_m1_465600_244800 5.356235
R7405 n1_m1_465600_244800 n1_m1_470400_244800 5.356235
R7406 n1_m1_470400_244800 n1_m1_475200_244800 5.356235
R7407 n1_m1_475200_244800 n1_m1_480000_244800 5.356235
R7408 n1_m1_480000_244800 n1_m1_484800_244800 5.356235
R7409 n1_m1_484800_244800 n1_m1_489600_244800 5.356235
R7410 n1_m1_489600_244800 n1_m1_494400_244800 5.356235
R7411 n1_m1_494400_244800 n1_m1_499200_244800 5.356235
R7412 n1_m1_499200_244800 n1_m1_504000_244800 5.356235
R7413 n1_m1_504000_244800 n1_m1_508000_244800 4.463529
R7414 n1_m1_508800_244800 n1_m1_508000_244800 0.892706
R7415 n1_m1_508800_244800 n1_m1_513600_244800 5.356235
R7416 n1_m1_513600_244800 n1_m1_518400_244800 5.356235
R7417 n1_m1_518400_244800 n1_m1_523200_244800 5.356235
R7418 n1_m1_523200_244800 n1_m1_528000_244800 5.356235
R7419 n1_m1_528000_244800 n1_m1_532800_244800 5.356235
R7420 n1_m1_532800_244800 n1_m1_536000_244800 3.570824
R7421 n1_m1_537600_244800 n1_m1_536000_244800 1.785412
R7422 n1_m1_537600_244800 n1_m1_542400_244800 5.356235
R7423 n1_m1_542400_244800 n1_m1_547200_244800 5.356235
R7424 n1_m1_547200_244800 n1_m1_552000_244800 5.356235
R7425 n1_m1_552000_244800 n1_m1_556800_244800 5.356235
R7426 n1_m1_556800_244800 n1_m1_561600_244800 5.356235
R7427 n1_m1_561600_244800 n1_m1_564000_244800 2.678118
R7428 n1_m1_566400_244800 n1_m1_564000_244800 2.678118
R7429 n1_m1_566400_244800 n1_m1_571200_244800 5.356235
R7430 n1_m1_571200_244800 n1_m1_576000_244800 5.356235
R7431 n1_m1_576000_244800 n1_m1_580800_244800 5.356235
R7432 n1_m1_580800_244800 n1_m1_585600_244800 5.356235
R7433 n1_m1_585600_244800 n1_m1_590400_244800 5.356235
R7434 n1_m1_590400_244800 n1_m1_592000_244800 1.785412
R7435 n1_m1_595200_244800 n1_m1_592000_244800 3.570824
R7436 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R7437 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R7438 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R7439 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R7440 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R7441 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R7442 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R7443 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R7444 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R7445 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R7446 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R7447 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R7448 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R7449 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R7450 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R7451 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R7452 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R7453 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R7454 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R7455 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R7456 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R7457 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R7458 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R7459 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R7460 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R7461 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R7462 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R7463 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R7464 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R7465 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R7466 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R7467 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R7468 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R7469 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R7470 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R7471 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R7472 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R7473 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R7474 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R7475 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R7476 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R7477 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R7478 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R7479 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R7480 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R7481 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R7482 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R7483 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R7484 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R7485 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R7486 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R7487 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R7488 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R7489 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R7490 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R7491 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R7492 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R7493 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R7494 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R7495 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R7496 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R7497 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R7498 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R7499 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R7500 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R7501 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R7502 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R7503 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R7504 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R7505 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R7506 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R7507 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R7508 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R7509 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R7510 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R7511 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R7512 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R7513 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R7514 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R7515 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R7516 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R7517 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R7518 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R7519 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R7520 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R7521 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R7522 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R7523 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R7524 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R7525 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R7526 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R7527 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R7528 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R7529 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R7530 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R7531 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R7532 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R7533 n1_m1_403200_249600 n1_m1_408000_249600 5.356235
R7534 n1_m1_408000_249600 n1_m1_412800_249600 5.356235
R7535 n1_m1_412800_249600 n1_m1_417600_249600 5.356235
R7536 n1_m1_417600_249600 n1_m1_422400_249600 5.356235
R7537 n1_m1_422400_249600 n1_m1_424000_249600 1.785412
R7538 n1_m1_427200_249600 n1_m1_424000_249600 3.570824
R7539 n1_m1_427200_249600 n1_m1_432000_249600 5.356235
R7540 n1_m1_432000_249600 n1_m1_436800_249600 5.356235
R7541 n1_m1_436800_249600 n1_m1_441600_249600 5.356235
R7542 n1_m1_441600_249600 n1_m1_446400_249600 5.356235
R7543 n1_m1_446400_249600 n1_m1_451200_249600 5.356235
R7544 n1_m1_451200_249600 n1_m1_452000_249600 0.892706
R7545 n1_m1_456000_249600 n1_m1_452000_249600 4.463529
R7546 n1_m1_456000_249600 n1_m1_460800_249600 5.356235
R7547 n1_m1_460800_249600 n1_m1_465600_249600 5.356235
R7548 n1_m1_465600_249600 n1_m1_470400_249600 5.356235
R7549 n1_m1_470400_249600 n1_m1_475200_249600 5.356235
R7550 n1_m1_475200_249600 n1_m1_480000_249600 5.356235
R7551 n1_m1_480000_249600 n1_m1_484800_249600 5.356235
R7552 n1_m1_484800_249600 n1_m1_489600_249600 5.356235
R7553 n1_m1_489600_249600 n1_m1_494400_249600 5.356235
R7554 n1_m1_494400_249600 n1_m1_499200_249600 5.356235
R7555 n1_m1_499200_249600 n1_m1_504000_249600 5.356235
R7556 n1_m1_504000_249600 n1_m1_508000_249600 4.463529
R7557 n1_m1_508800_249600 n1_m1_508000_249600 0.892706
R7558 n1_m1_508800_249600 n1_m1_513600_249600 5.356235
R7559 n1_m1_513600_249600 n1_m1_518400_249600 5.356235
R7560 n1_m1_518400_249600 n1_m1_523200_249600 5.356235
R7561 n1_m1_523200_249600 n1_m1_528000_249600 5.356235
R7562 n1_m1_528000_249600 n1_m1_532800_249600 5.356235
R7563 n1_m1_532800_249600 n1_m1_536000_249600 3.570824
R7564 n1_m1_537600_249600 n1_m1_536000_249600 1.785412
R7565 n1_m1_537600_249600 n1_m1_542400_249600 5.356235
R7566 n1_m1_542400_249600 n1_m1_547200_249600 5.356235
R7567 n1_m1_547200_249600 n1_m1_552000_249600 5.356235
R7568 n1_m1_552000_249600 n1_m1_556800_249600 5.356235
R7569 n1_m1_556800_249600 n1_m1_561600_249600 5.356235
R7570 n1_m1_561600_249600 n1_m1_564000_249600 2.678118
R7571 n1_m1_566400_249600 n1_m1_564000_249600 2.678118
R7572 n1_m1_566400_249600 n1_m1_571200_249600 5.356235
R7573 n1_m1_571200_249600 n1_m1_576000_249600 5.356235
R7574 n1_m1_576000_249600 n1_m1_580800_249600 5.356235
R7575 n1_m1_580800_249600 n1_m1_585600_249600 5.356235
R7576 n1_m1_585600_249600 n1_m1_590400_249600 5.356235
R7577 n1_m1_590400_249600 n1_m1_592000_249600 1.785412
R7578 n1_m1_595200_249600 n1_m1_592000_249600 3.570824
R7579 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R7580 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R7581 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R7582 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R7583 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R7584 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R7585 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R7586 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R7587 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R7588 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R7589 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R7590 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R7591 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R7592 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R7593 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R7594 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R7595 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R7596 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R7597 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R7598 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R7599 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R7600 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R7601 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R7602 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R7603 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R7604 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R7605 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R7606 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R7607 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R7608 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R7609 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R7610 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R7611 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R7612 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R7613 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R7614 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R7615 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R7616 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R7617 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R7618 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R7619 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R7620 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R7621 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R7622 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R7623 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R7624 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R7625 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R7626 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R7627 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R7628 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R7629 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R7630 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R7631 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R7632 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R7633 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R7634 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R7635 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R7636 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R7637 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R7638 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R7639 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R7640 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R7641 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R7642 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R7643 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R7644 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R7645 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R7646 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R7647 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R7648 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R7649 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R7650 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R7651 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R7652 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R7653 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R7654 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R7655 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R7656 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R7657 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R7658 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R7659 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R7660 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R7661 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R7662 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R7663 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R7664 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R7665 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R7666 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R7667 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R7668 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R7669 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R7670 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R7671 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R7672 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R7673 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R7674 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R7675 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R7676 n1_m1_403200_254400 n1_m1_408000_254400 5.356235
R7677 n1_m1_408000_254400 n1_m1_412800_254400 5.356235
R7678 n1_m1_412800_254400 n1_m1_417600_254400 5.356235
R7679 n1_m1_417600_254400 n1_m1_422400_254400 5.356235
R7680 n1_m1_422400_254400 n1_m1_424000_254400 1.785412
R7681 n1_m1_427200_254400 n1_m1_424000_254400 3.570824
R7682 n1_m1_427200_254400 n1_m1_432000_254400 5.356235
R7683 n1_m1_432000_254400 n1_m1_436800_254400 5.356235
R7684 n1_m1_436800_254400 n1_m1_441600_254400 5.356235
R7685 n1_m1_441600_254400 n1_m1_446400_254400 5.356235
R7686 n1_m1_446400_254400 n1_m1_451200_254400 5.356235
R7687 n1_m1_451200_254400 n1_m1_452000_254400 0.892706
R7688 n1_m1_456000_254400 n1_m1_452000_254400 4.463529
R7689 n1_m1_456000_254400 n1_m1_460800_254400 5.356235
R7690 n1_m1_460800_254400 n1_m1_465600_254400 5.356235
R7691 n1_m1_465600_254400 n1_m1_470400_254400 5.356235
R7692 n1_m1_470400_254400 n1_m1_475200_254400 5.356235
R7693 n1_m1_475200_254400 n1_m1_480000_254400 5.356235
R7694 n1_m1_480000_254400 n1_m1_484800_254400 5.356235
R7695 n1_m1_484800_254400 n1_m1_489600_254400 5.356235
R7696 n1_m1_489600_254400 n1_m1_494400_254400 5.356235
R7697 n1_m1_494400_254400 n1_m1_499200_254400 5.356235
R7698 n1_m1_499200_254400 n1_m1_504000_254400 5.356235
R7699 n1_m1_504000_254400 n1_m1_508000_254400 4.463529
R7700 n1_m1_508800_254400 n1_m1_508000_254400 0.892706
R7701 n1_m1_508800_254400 n1_m1_513600_254400 5.356235
R7702 n1_m1_513600_254400 n1_m1_518400_254400 5.356235
R7703 n1_m1_518400_254400 n1_m1_523200_254400 5.356235
R7704 n1_m1_523200_254400 n1_m1_528000_254400 5.356235
R7705 n1_m1_528000_254400 n1_m1_532800_254400 5.356235
R7706 n1_m1_532800_254400 n1_m1_536000_254400 3.570824
R7707 n1_m1_537600_254400 n1_m1_536000_254400 1.785412
R7708 n1_m1_537600_254400 n1_m1_542400_254400 5.356235
R7709 n1_m1_542400_254400 n1_m1_547200_254400 5.356235
R7710 n1_m1_547200_254400 n1_m1_552000_254400 5.356235
R7711 n1_m1_552000_254400 n1_m1_556800_254400 5.356235
R7712 n1_m1_556800_254400 n1_m1_561600_254400 5.356235
R7713 n1_m1_561600_254400 n1_m1_564000_254400 2.678118
R7714 n1_m1_566400_254400 n1_m1_564000_254400 2.678118
R7715 n1_m1_566400_254400 n1_m1_571200_254400 5.356235
R7716 n1_m1_571200_254400 n1_m1_576000_254400 5.356235
R7717 n1_m1_576000_254400 n1_m1_580800_254400 5.356235
R7718 n1_m1_580800_254400 n1_m1_585600_254400 5.356235
R7719 n1_m1_585600_254400 n1_m1_590400_254400 5.356235
R7720 n1_m1_590400_254400 n1_m1_592000_254400 1.785412
R7721 n1_m1_595200_254400 n1_m1_592000_254400 3.570824
R7722 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R7723 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R7724 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R7725 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R7726 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R7727 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R7728 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R7729 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R7730 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R7731 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R7732 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R7733 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R7734 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R7735 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R7736 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R7737 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R7738 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R7739 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R7740 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R7741 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R7742 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R7743 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R7744 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R7745 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R7746 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R7747 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R7748 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R7749 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R7750 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R7751 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R7752 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R7753 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R7754 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R7755 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R7756 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R7757 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R7758 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R7759 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R7760 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R7761 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R7762 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R7763 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R7764 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R7765 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R7766 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R7767 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R7768 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R7769 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R7770 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R7771 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R7772 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R7773 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R7774 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R7775 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R7776 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R7777 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R7778 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R7779 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R7780 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R7781 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R7782 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R7783 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R7784 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R7785 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R7786 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R7787 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R7788 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R7789 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R7790 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R7791 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R7792 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R7793 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R7794 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R7795 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R7796 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R7797 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R7798 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R7799 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R7800 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R7801 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R7802 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R7803 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R7804 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R7805 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R7806 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R7807 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R7808 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R7809 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R7810 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R7811 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R7812 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R7813 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R7814 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R7815 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R7816 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R7817 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R7818 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R7819 n1_m1_403200_259200 n1_m1_408000_259200 5.356235
R7820 n1_m1_408000_259200 n1_m1_412800_259200 5.356235
R7821 n1_m1_412800_259200 n1_m1_417600_259200 5.356235
R7822 n1_m1_417600_259200 n1_m1_422400_259200 5.356235
R7823 n1_m1_422400_259200 n1_m1_424000_259200 1.785412
R7824 n1_m1_427200_259200 n1_m1_424000_259200 3.570824
R7825 n1_m1_427200_259200 n1_m1_432000_259200 5.356235
R7826 n1_m1_432000_259200 n1_m1_436800_259200 5.356235
R7827 n1_m1_436800_259200 n1_m1_441600_259200 5.356235
R7828 n1_m1_441600_259200 n1_m1_446400_259200 5.356235
R7829 n1_m1_446400_259200 n1_m1_451200_259200 5.356235
R7830 n1_m1_451200_259200 n1_m1_452000_259200 0.892706
R7831 n1_m1_456000_259200 n1_m1_452000_259200 4.463529
R7832 n1_m1_456000_259200 n1_m1_460800_259200 5.356235
R7833 n1_m1_460800_259200 n1_m1_465600_259200 5.356235
R7834 n1_m1_465600_259200 n1_m1_470400_259200 5.356235
R7835 n1_m1_470400_259200 n1_m1_475200_259200 5.356235
R7836 n1_m1_475200_259200 n1_m1_480000_259200 5.356235
R7837 n1_m1_480000_259200 n1_m1_484800_259200 5.356235
R7838 n1_m1_484800_259200 n1_m1_489600_259200 5.356235
R7839 n1_m1_489600_259200 n1_m1_494400_259200 5.356235
R7840 n1_m1_494400_259200 n1_m1_499200_259200 5.356235
R7841 n1_m1_499200_259200 n1_m1_504000_259200 5.356235
R7842 n1_m1_504000_259200 n1_m1_508000_259200 4.463529
R7843 n1_m1_508800_259200 n1_m1_508000_259200 0.892706
R7844 n1_m1_508800_259200 n1_m1_513600_259200 5.356235
R7845 n1_m1_513600_259200 n1_m1_518400_259200 5.356235
R7846 n1_m1_518400_259200 n1_m1_523200_259200 5.356235
R7847 n1_m1_523200_259200 n1_m1_528000_259200 5.356235
R7848 n1_m1_528000_259200 n1_m1_532800_259200 5.356235
R7849 n1_m1_532800_259200 n1_m1_536000_259200 3.570824
R7850 n1_m1_537600_259200 n1_m1_536000_259200 1.785412
R7851 n1_m1_537600_259200 n1_m1_542400_259200 5.356235
R7852 n1_m1_542400_259200 n1_m1_547200_259200 5.356235
R7853 n1_m1_547200_259200 n1_m1_552000_259200 5.356235
R7854 n1_m1_552000_259200 n1_m1_556800_259200 5.356235
R7855 n1_m1_556800_259200 n1_m1_561600_259200 5.356235
R7856 n1_m1_561600_259200 n1_m1_564000_259200 2.678118
R7857 n1_m1_566400_259200 n1_m1_564000_259200 2.678118
R7858 n1_m1_566400_259200 n1_m1_571200_259200 5.356235
R7859 n1_m1_571200_259200 n1_m1_576000_259200 5.356235
R7860 n1_m1_576000_259200 n1_m1_580800_259200 5.356235
R7861 n1_m1_580800_259200 n1_m1_585600_259200 5.356235
R7862 n1_m1_585600_259200 n1_m1_590400_259200 5.356235
R7863 n1_m1_590400_259200 n1_m1_592000_259200 1.785412
R7864 n1_m1_595200_259200 n1_m1_592000_259200 3.570824
R7865 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R7866 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R7867 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R7868 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R7869 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R7870 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R7871 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R7872 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R7873 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R7874 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R7875 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R7876 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R7877 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R7878 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R7879 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R7880 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R7881 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R7882 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R7883 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R7884 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R7885 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R7886 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R7887 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R7888 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R7889 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R7890 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R7891 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R7892 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R7893 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R7894 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R7895 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R7896 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R7897 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R7898 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R7899 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R7900 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R7901 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R7902 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R7903 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R7904 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R7905 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R7906 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R7907 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R7908 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R7909 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R7910 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R7911 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R7912 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R7913 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R7914 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R7915 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R7916 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R7917 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R7918 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R7919 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R7920 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R7921 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R7922 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R7923 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R7924 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R7925 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R7926 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R7927 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R7928 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R7929 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R7930 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R7931 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R7932 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R7933 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R7934 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R7935 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R7936 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R7937 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R7938 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R7939 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R7940 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R7941 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R7942 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R7943 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R7944 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R7945 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R7946 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R7947 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R7948 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R7949 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R7950 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R7951 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R7952 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R7953 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R7954 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R7955 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R7956 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R7957 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R7958 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R7959 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R7960 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R7961 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R7962 n1_m1_403200_264000 n1_m1_408000_264000 5.356235
R7963 n1_m1_408000_264000 n1_m1_412800_264000 5.356235
R7964 n1_m1_412800_264000 n1_m1_417600_264000 5.356235
R7965 n1_m1_417600_264000 n1_m1_422400_264000 5.356235
R7966 n1_m1_422400_264000 n1_m1_424000_264000 1.785412
R7967 n1_m1_427200_264000 n1_m1_424000_264000 3.570824
R7968 n1_m1_427200_264000 n1_m1_432000_264000 5.356235
R7969 n1_m1_432000_264000 n1_m1_436800_264000 5.356235
R7970 n1_m1_436800_264000 n1_m1_441600_264000 5.356235
R7971 n1_m1_441600_264000 n1_m1_446400_264000 5.356235
R7972 n1_m1_446400_264000 n1_m1_451200_264000 5.356235
R7973 n1_m1_451200_264000 n1_m1_452000_264000 0.892706
R7974 n1_m1_456000_264000 n1_m1_452000_264000 4.463529
R7975 n1_m1_456000_264000 n1_m1_460800_264000 5.356235
R7976 n1_m1_460800_264000 n1_m1_465600_264000 5.356235
R7977 n1_m1_465600_264000 n1_m1_470400_264000 5.356235
R7978 n1_m1_470400_264000 n1_m1_475200_264000 5.356235
R7979 n1_m1_475200_264000 n1_m1_480000_264000 5.356235
R7980 n1_m1_480000_264000 n1_m1_484800_264000 5.356235
R7981 n1_m1_484800_264000 n1_m1_489600_264000 5.356235
R7982 n1_m1_489600_264000 n1_m1_494400_264000 5.356235
R7983 n1_m1_494400_264000 n1_m1_499200_264000 5.356235
R7984 n1_m1_499200_264000 n1_m1_504000_264000 5.356235
R7985 n1_m1_504000_264000 n1_m1_508000_264000 4.463529
R7986 n1_m1_508800_264000 n1_m1_508000_264000 0.892706
R7987 n1_m1_508800_264000 n1_m1_513600_264000 5.356235
R7988 n1_m1_513600_264000 n1_m1_518400_264000 5.356235
R7989 n1_m1_518400_264000 n1_m1_523200_264000 5.356235
R7990 n1_m1_523200_264000 n1_m1_528000_264000 5.356235
R7991 n1_m1_528000_264000 n1_m1_532800_264000 5.356235
R7992 n1_m1_532800_264000 n1_m1_536000_264000 3.570824
R7993 n1_m1_537600_264000 n1_m1_536000_264000 1.785412
R7994 n1_m1_537600_264000 n1_m1_542400_264000 5.356235
R7995 n1_m1_542400_264000 n1_m1_547200_264000 5.356235
R7996 n1_m1_547200_264000 n1_m1_552000_264000 5.356235
R7997 n1_m1_552000_264000 n1_m1_556800_264000 5.356235
R7998 n1_m1_556800_264000 n1_m1_561600_264000 5.356235
R7999 n1_m1_561600_264000 n1_m1_564000_264000 2.678118
R8000 n1_m1_566400_264000 n1_m1_564000_264000 2.678118
R8001 n1_m1_566400_264000 n1_m1_571200_264000 5.356235
R8002 n1_m1_571200_264000 n1_m1_576000_264000 5.356235
R8003 n1_m1_576000_264000 n1_m1_580800_264000 5.356235
R8004 n1_m1_580800_264000 n1_m1_585600_264000 5.356235
R8005 n1_m1_585600_264000 n1_m1_590400_264000 5.356235
R8006 n1_m1_590400_264000 n1_m1_592000_264000 1.785412
R8007 n1_m1_595200_264000 n1_m1_592000_264000 3.570824
R8008 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R8009 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R8010 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R8011 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R8012 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R8013 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R8014 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R8015 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R8016 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R8017 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R8018 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R8019 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R8020 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R8021 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R8022 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R8023 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R8024 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R8025 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R8026 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R8027 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R8028 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R8029 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R8030 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R8031 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R8032 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R8033 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R8034 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R8035 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R8036 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R8037 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R8038 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R8039 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R8040 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R8041 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R8042 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R8043 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R8044 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R8045 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R8046 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R8047 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R8048 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R8049 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R8050 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R8051 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R8052 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R8053 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R8054 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R8055 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R8056 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R8057 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R8058 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R8059 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R8060 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R8061 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R8062 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R8063 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R8064 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R8065 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R8066 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R8067 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R8068 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R8069 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R8070 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R8071 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R8072 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R8073 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R8074 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R8075 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R8076 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R8077 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R8078 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R8079 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R8080 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R8081 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R8082 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R8083 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R8084 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R8085 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R8086 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R8087 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R8088 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R8089 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R8090 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R8091 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R8092 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R8093 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R8094 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R8095 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R8096 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R8097 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R8098 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R8099 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R8100 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R8101 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R8102 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R8103 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R8104 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R8105 n1_m1_403200_268800 n1_m1_408000_268800 5.356235
R8106 n1_m1_408000_268800 n1_m1_412800_268800 5.356235
R8107 n1_m1_412800_268800 n1_m1_417600_268800 5.356235
R8108 n1_m1_417600_268800 n1_m1_422400_268800 5.356235
R8109 n1_m1_422400_268800 n1_m1_424000_268800 1.785412
R8110 n1_m1_427200_268800 n1_m1_424000_268800 3.570824
R8111 n1_m1_427200_268800 n1_m1_432000_268800 5.356235
R8112 n1_m1_432000_268800 n1_m1_436800_268800 5.356235
R8113 n1_m1_436800_268800 n1_m1_441600_268800 5.356235
R8114 n1_m1_441600_268800 n1_m1_446400_268800 5.356235
R8115 n1_m1_446400_268800 n1_m1_451200_268800 5.356235
R8116 n1_m1_451200_268800 n1_m1_452000_268800 0.892706
R8117 n1_m1_456000_268800 n1_m1_452000_268800 4.463529
R8118 n1_m1_456000_268800 n1_m1_460800_268800 5.356235
R8119 n1_m1_460800_268800 n1_m1_465600_268800 5.356235
R8120 n1_m1_465600_268800 n1_m1_470400_268800 5.356235
R8121 n1_m1_470400_268800 n1_m1_475200_268800 5.356235
R8122 n1_m1_475200_268800 n1_m1_480000_268800 5.356235
R8123 n1_m1_480000_268800 n1_m1_484800_268800 5.356235
R8124 n1_m1_484800_268800 n1_m1_489600_268800 5.356235
R8125 n1_m1_489600_268800 n1_m1_494400_268800 5.356235
R8126 n1_m1_494400_268800 n1_m1_499200_268800 5.356235
R8127 n1_m1_499200_268800 n1_m1_504000_268800 5.356235
R8128 n1_m1_504000_268800 n1_m1_508000_268800 4.463529
R8129 n1_m1_508800_268800 n1_m1_508000_268800 0.892706
R8130 n1_m1_508800_268800 n1_m1_513600_268800 5.356235
R8131 n1_m1_513600_268800 n1_m1_518400_268800 5.356235
R8132 n1_m1_518400_268800 n1_m1_523200_268800 5.356235
R8133 n1_m1_523200_268800 n1_m1_528000_268800 5.356235
R8134 n1_m1_528000_268800 n1_m1_532800_268800 5.356235
R8135 n1_m1_532800_268800 n1_m1_536000_268800 3.570824
R8136 n1_m1_537600_268800 n1_m1_536000_268800 1.785412
R8137 n1_m1_537600_268800 n1_m1_542400_268800 5.356235
R8138 n1_m1_542400_268800 n1_m1_547200_268800 5.356235
R8139 n1_m1_547200_268800 n1_m1_552000_268800 5.356235
R8140 n1_m1_552000_268800 n1_m1_556800_268800 5.356235
R8141 n1_m1_556800_268800 n1_m1_561600_268800 5.356235
R8142 n1_m1_561600_268800 n1_m1_564000_268800 2.678118
R8143 n1_m1_566400_268800 n1_m1_564000_268800 2.678118
R8144 n1_m1_566400_268800 n1_m1_571200_268800 5.356235
R8145 n1_m1_571200_268800 n1_m1_576000_268800 5.356235
R8146 n1_m1_576000_268800 n1_m1_580800_268800 5.356235
R8147 n1_m1_580800_268800 n1_m1_585600_268800 5.356235
R8148 n1_m1_585600_268800 n1_m1_590400_268800 5.356235
R8149 n1_m1_590400_268800 n1_m1_592000_268800 1.785412
R8150 n1_m1_595200_268800 n1_m1_592000_268800 3.570824
R8151 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R8152 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R8153 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R8154 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R8155 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R8156 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R8157 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R8158 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R8159 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R8160 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R8161 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R8162 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R8163 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R8164 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R8165 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R8166 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R8167 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R8168 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R8169 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R8170 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R8171 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R8172 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R8173 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R8174 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R8175 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R8176 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R8177 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R8178 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R8179 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R8180 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R8181 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R8182 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R8183 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R8184 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R8185 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R8186 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R8187 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R8188 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R8189 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R8190 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R8191 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R8192 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R8193 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R8194 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R8195 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R8196 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R8197 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R8198 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R8199 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R8200 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R8201 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R8202 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R8203 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R8204 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R8205 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R8206 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R8207 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R8208 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R8209 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R8210 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R8211 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R8212 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R8213 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R8214 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R8215 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R8216 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R8217 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R8218 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R8219 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R8220 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R8221 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R8222 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R8223 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R8224 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R8225 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R8226 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R8227 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R8228 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R8229 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R8230 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R8231 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R8232 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R8233 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R8234 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R8235 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R8236 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R8237 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R8238 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R8239 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R8240 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R8241 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R8242 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R8243 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R8244 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R8245 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R8246 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R8247 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R8248 n1_m1_403200_273600 n1_m1_408000_273600 5.356235
R8249 n1_m1_408000_273600 n1_m1_412800_273600 5.356235
R8250 n1_m1_412800_273600 n1_m1_417600_273600 5.356235
R8251 n1_m1_417600_273600 n1_m1_422400_273600 5.356235
R8252 n1_m1_422400_273600 n1_m1_424000_273600 1.785412
R8253 n1_m1_427200_273600 n1_m1_424000_273600 3.570824
R8254 n1_m1_427200_273600 n1_m1_432000_273600 5.356235
R8255 n1_m1_432000_273600 n1_m1_436800_273600 5.356235
R8256 n1_m1_436800_273600 n1_m1_441600_273600 5.356235
R8257 n1_m1_441600_273600 n1_m1_446400_273600 5.356235
R8258 n1_m1_446400_273600 n1_m1_451200_273600 5.356235
R8259 n1_m1_451200_273600 n1_m1_452000_273600 0.892706
R8260 n1_m1_456000_273600 n1_m1_452000_273600 4.463529
R8261 n1_m1_456000_273600 n1_m1_460800_273600 5.356235
R8262 n1_m1_460800_273600 n1_m1_465600_273600 5.356235
R8263 n1_m1_465600_273600 n1_m1_470400_273600 5.356235
R8264 n1_m1_470400_273600 n1_m1_475200_273600 5.356235
R8265 n1_m1_475200_273600 n1_m1_480000_273600 5.356235
R8266 n1_m1_480000_273600 n1_m1_484800_273600 5.356235
R8267 n1_m1_484800_273600 n1_m1_489600_273600 5.356235
R8268 n1_m1_489600_273600 n1_m1_494400_273600 5.356235
R8269 n1_m1_494400_273600 n1_m1_499200_273600 5.356235
R8270 n1_m1_499200_273600 n1_m1_504000_273600 5.356235
R8271 n1_m1_504000_273600 n1_m1_508000_273600 4.463529
R8272 n1_m1_508800_273600 n1_m1_508000_273600 0.892706
R8273 n1_m1_508800_273600 n1_m1_513600_273600 5.356235
R8274 n1_m1_513600_273600 n1_m1_518400_273600 5.356235
R8275 n1_m1_518400_273600 n1_m1_523200_273600 5.356235
R8276 n1_m1_523200_273600 n1_m1_528000_273600 5.356235
R8277 n1_m1_528000_273600 n1_m1_532800_273600 5.356235
R8278 n1_m1_532800_273600 n1_m1_536000_273600 3.570824
R8279 n1_m1_537600_273600 n1_m1_536000_273600 1.785412
R8280 n1_m1_537600_273600 n1_m1_542400_273600 5.356235
R8281 n1_m1_542400_273600 n1_m1_547200_273600 5.356235
R8282 n1_m1_547200_273600 n1_m1_552000_273600 5.356235
R8283 n1_m1_552000_273600 n1_m1_556800_273600 5.356235
R8284 n1_m1_556800_273600 n1_m1_561600_273600 5.356235
R8285 n1_m1_561600_273600 n1_m1_564000_273600 2.678118
R8286 n1_m1_566400_273600 n1_m1_564000_273600 2.678118
R8287 n1_m1_566400_273600 n1_m1_571200_273600 5.356235
R8288 n1_m1_571200_273600 n1_m1_576000_273600 5.356235
R8289 n1_m1_576000_273600 n1_m1_580800_273600 5.356235
R8290 n1_m1_580800_273600 n1_m1_585600_273600 5.356235
R8291 n1_m1_585600_273600 n1_m1_590400_273600 5.356235
R8292 n1_m1_590400_273600 n1_m1_592000_273600 1.785412
R8293 n1_m1_595200_273600 n1_m1_592000_273600 3.570824
R8294 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R8295 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R8296 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R8297 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R8298 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R8299 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R8300 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R8301 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R8302 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R8303 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R8304 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R8305 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R8306 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R8307 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R8308 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R8309 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R8310 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R8311 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R8312 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R8313 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R8314 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R8315 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R8316 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R8317 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R8318 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R8319 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R8320 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R8321 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R8322 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R8323 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R8324 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R8325 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R8326 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R8327 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R8328 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R8329 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R8330 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R8331 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R8332 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R8333 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R8334 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R8335 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R8336 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R8337 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R8338 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R8339 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R8340 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R8341 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R8342 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R8343 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R8344 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R8345 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R8346 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R8347 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R8348 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R8349 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R8350 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R8351 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R8352 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R8353 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R8354 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R8355 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R8356 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R8357 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R8358 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R8359 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R8360 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R8361 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R8362 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R8363 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R8364 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R8365 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R8366 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R8367 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R8368 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R8369 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R8370 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R8371 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R8372 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R8373 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R8374 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R8375 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R8376 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R8377 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R8378 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R8379 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R8380 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R8381 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R8382 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R8383 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R8384 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R8385 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R8386 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R8387 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R8388 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R8389 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R8390 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R8391 n1_m1_403200_278400 n1_m1_408000_278400 5.356235
R8392 n1_m1_408000_278400 n1_m1_412800_278400 5.356235
R8393 n1_m1_412800_278400 n1_m1_417600_278400 5.356235
R8394 n1_m1_417600_278400 n1_m1_422400_278400 5.356235
R8395 n1_m1_422400_278400 n1_m1_424000_278400 1.785412
R8396 n1_m1_427200_278400 n1_m1_424000_278400 3.570824
R8397 n1_m1_427200_278400 n1_m1_432000_278400 5.356235
R8398 n1_m1_432000_278400 n1_m1_436800_278400 5.356235
R8399 n1_m1_436800_278400 n1_m1_441600_278400 5.356235
R8400 n1_m1_441600_278400 n1_m1_446400_278400 5.356235
R8401 n1_m1_446400_278400 n1_m1_451200_278400 5.356235
R8402 n1_m1_451200_278400 n1_m1_452000_278400 0.892706
R8403 n1_m1_456000_278400 n1_m1_452000_278400 4.463529
R8404 n1_m1_456000_278400 n1_m1_460800_278400 5.356235
R8405 n1_m1_460800_278400 n1_m1_465600_278400 5.356235
R8406 n1_m1_465600_278400 n1_m1_470400_278400 5.356235
R8407 n1_m1_470400_278400 n1_m1_475200_278400 5.356235
R8408 n1_m1_475200_278400 n1_m1_480000_278400 5.356235
R8409 n1_m1_480000_278400 n1_m1_484800_278400 5.356235
R8410 n1_m1_484800_278400 n1_m1_489600_278400 5.356235
R8411 n1_m1_489600_278400 n1_m1_494400_278400 5.356235
R8412 n1_m1_494400_278400 n1_m1_499200_278400 5.356235
R8413 n1_m1_499200_278400 n1_m1_504000_278400 5.356235
R8414 n1_m1_504000_278400 n1_m1_508000_278400 4.463529
R8415 n1_m1_508800_278400 n1_m1_508000_278400 0.892706
R8416 n1_m1_508800_278400 n1_m1_513600_278400 5.356235
R8417 n1_m1_513600_278400 n1_m1_518400_278400 5.356235
R8418 n1_m1_518400_278400 n1_m1_523200_278400 5.356235
R8419 n1_m1_523200_278400 n1_m1_528000_278400 5.356235
R8420 n1_m1_528000_278400 n1_m1_532800_278400 5.356235
R8421 n1_m1_532800_278400 n1_m1_536000_278400 3.570824
R8422 n1_m1_537600_278400 n1_m1_536000_278400 1.785412
R8423 n1_m1_537600_278400 n1_m1_542400_278400 5.356235
R8424 n1_m1_542400_278400 n1_m1_547200_278400 5.356235
R8425 n1_m1_547200_278400 n1_m1_552000_278400 5.356235
R8426 n1_m1_552000_278400 n1_m1_556800_278400 5.356235
R8427 n1_m1_556800_278400 n1_m1_561600_278400 5.356235
R8428 n1_m1_561600_278400 n1_m1_564000_278400 2.678118
R8429 n1_m1_566400_278400 n1_m1_564000_278400 2.678118
R8430 n1_m1_566400_278400 n1_m1_571200_278400 5.356235
R8431 n1_m1_571200_278400 n1_m1_576000_278400 5.356235
R8432 n1_m1_576000_278400 n1_m1_580800_278400 5.356235
R8433 n1_m1_580800_278400 n1_m1_585600_278400 5.356235
R8434 n1_m1_585600_278400 n1_m1_590400_278400 5.356235
R8435 n1_m1_590400_278400 n1_m1_592000_278400 1.785412
R8436 n1_m1_595200_278400 n1_m1_592000_278400 3.570824
R8437 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R8438 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R8439 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R8440 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R8441 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R8442 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R8443 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R8444 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R8445 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R8446 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R8447 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R8448 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R8449 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R8450 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R8451 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R8452 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R8453 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R8454 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R8455 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R8456 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R8457 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R8458 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R8459 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R8460 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R8461 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R8462 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R8463 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R8464 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R8465 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R8466 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R8467 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R8468 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R8469 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R8470 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R8471 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R8472 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R8473 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R8474 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R8475 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R8476 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R8477 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R8478 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R8479 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R8480 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R8481 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R8482 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R8483 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R8484 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R8485 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R8486 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R8487 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R8488 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R8489 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R8490 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R8491 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R8492 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R8493 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R8494 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R8495 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R8496 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R8497 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R8498 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R8499 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R8500 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R8501 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R8502 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R8503 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R8504 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R8505 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R8506 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R8507 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R8508 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R8509 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R8510 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R8511 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R8512 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R8513 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R8514 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R8515 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R8516 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R8517 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R8518 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R8519 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R8520 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R8521 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R8522 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R8523 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R8524 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R8525 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R8526 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R8527 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R8528 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R8529 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R8530 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R8531 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R8532 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R8533 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R8534 n1_m1_403200_283200 n1_m1_408000_283200 5.356235
R8535 n1_m1_408000_283200 n1_m1_412800_283200 5.356235
R8536 n1_m1_412800_283200 n1_m1_417600_283200 5.356235
R8537 n1_m1_417600_283200 n1_m1_422400_283200 5.356235
R8538 n1_m1_422400_283200 n1_m1_424000_283200 1.785412
R8539 n1_m1_427200_283200 n1_m1_424000_283200 3.570824
R8540 n1_m1_427200_283200 n1_m1_432000_283200 5.356235
R8541 n1_m1_432000_283200 n1_m1_436800_283200 5.356235
R8542 n1_m1_436800_283200 n1_m1_441600_283200 5.356235
R8543 n1_m1_441600_283200 n1_m1_446400_283200 5.356235
R8544 n1_m1_446400_283200 n1_m1_451200_283200 5.356235
R8545 n1_m1_451200_283200 n1_m1_452000_283200 0.892706
R8546 n1_m1_456000_283200 n1_m1_452000_283200 4.463529
R8547 n1_m1_456000_283200 n1_m1_460800_283200 5.356235
R8548 n1_m1_460800_283200 n1_m1_465600_283200 5.356235
R8549 n1_m1_465600_283200 n1_m1_470400_283200 5.356235
R8550 n1_m1_470400_283200 n1_m1_475200_283200 5.356235
R8551 n1_m1_475200_283200 n1_m1_480000_283200 5.356235
R8552 n1_m1_480000_283200 n1_m1_484800_283200 5.356235
R8553 n1_m1_484800_283200 n1_m1_489600_283200 5.356235
R8554 n1_m1_489600_283200 n1_m1_494400_283200 5.356235
R8555 n1_m1_494400_283200 n1_m1_499200_283200 5.356235
R8556 n1_m1_499200_283200 n1_m1_504000_283200 5.356235
R8557 n1_m1_504000_283200 n1_m1_508000_283200 4.463529
R8558 n1_m1_508800_283200 n1_m1_508000_283200 0.892706
R8559 n1_m1_508800_283200 n1_m1_513600_283200 5.356235
R8560 n1_m1_513600_283200 n1_m1_518400_283200 5.356235
R8561 n1_m1_518400_283200 n1_m1_523200_283200 5.356235
R8562 n1_m1_523200_283200 n1_m1_528000_283200 5.356235
R8563 n1_m1_528000_283200 n1_m1_532800_283200 5.356235
R8564 n1_m1_532800_283200 n1_m1_536000_283200 3.570824
R8565 n1_m1_537600_283200 n1_m1_536000_283200 1.785412
R8566 n1_m1_537600_283200 n1_m1_542400_283200 5.356235
R8567 n1_m1_542400_283200 n1_m1_547200_283200 5.356235
R8568 n1_m1_547200_283200 n1_m1_552000_283200 5.356235
R8569 n1_m1_552000_283200 n1_m1_556800_283200 5.356235
R8570 n1_m1_556800_283200 n1_m1_561600_283200 5.356235
R8571 n1_m1_561600_283200 n1_m1_564000_283200 2.678118
R8572 n1_m1_566400_283200 n1_m1_564000_283200 2.678118
R8573 n1_m1_566400_283200 n1_m1_571200_283200 5.356235
R8574 n1_m1_571200_283200 n1_m1_576000_283200 5.356235
R8575 n1_m1_576000_283200 n1_m1_580800_283200 5.356235
R8576 n1_m1_580800_283200 n1_m1_585600_283200 5.356235
R8577 n1_m1_585600_283200 n1_m1_590400_283200 5.356235
R8578 n1_m1_590400_283200 n1_m1_592000_283200 1.785412
R8579 n1_m1_595200_283200 n1_m1_592000_283200 3.570824
R8580 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R8581 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R8582 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R8583 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R8584 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R8585 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R8586 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R8587 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R8588 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R8589 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R8590 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R8591 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R8592 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R8593 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R8594 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R8595 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R8596 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R8597 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R8598 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R8599 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R8600 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R8601 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R8602 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R8603 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R8604 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R8605 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R8606 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R8607 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R8608 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R8609 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R8610 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R8611 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R8612 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R8613 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R8614 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R8615 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R8616 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R8617 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R8618 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R8619 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R8620 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R8621 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R8622 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R8623 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R8624 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R8625 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R8626 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R8627 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R8628 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R8629 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R8630 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R8631 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R8632 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R8633 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R8634 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R8635 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R8636 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R8637 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R8638 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R8639 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R8640 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R8641 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R8642 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R8643 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R8644 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R8645 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R8646 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R8647 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R8648 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R8649 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R8650 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R8651 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R8652 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R8653 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R8654 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R8655 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R8656 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R8657 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R8658 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R8659 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R8660 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R8661 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R8662 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R8663 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R8664 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R8665 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R8666 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R8667 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R8668 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R8669 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R8670 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R8671 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R8672 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R8673 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R8674 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R8675 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R8676 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R8677 n1_m1_403200_288000 n1_m1_408000_288000 5.356235
R8678 n1_m1_408000_288000 n1_m1_412800_288000 5.356235
R8679 n1_m1_412800_288000 n1_m1_417600_288000 5.356235
R8680 n1_m1_417600_288000 n1_m1_422400_288000 5.356235
R8681 n1_m1_422400_288000 n1_m1_424000_288000 1.785412
R8682 n1_m1_427200_288000 n1_m1_424000_288000 3.570824
R8683 n1_m1_427200_288000 n1_m1_432000_288000 5.356235
R8684 n1_m1_432000_288000 n1_m1_436800_288000 5.356235
R8685 n1_m1_436800_288000 n1_m1_441600_288000 5.356235
R8686 n1_m1_441600_288000 n1_m1_446400_288000 5.356235
R8687 n1_m1_446400_288000 n1_m1_451200_288000 5.356235
R8688 n1_m1_451200_288000 n1_m1_452000_288000 0.892706
R8689 n1_m1_456000_288000 n1_m1_452000_288000 4.463529
R8690 n1_m1_456000_288000 n1_m1_460800_288000 5.356235
R8691 n1_m1_460800_288000 n1_m1_465600_288000 5.356235
R8692 n1_m1_465600_288000 n1_m1_470400_288000 5.356235
R8693 n1_m1_470400_288000 n1_m1_475200_288000 5.356235
R8694 n1_m1_475200_288000 n1_m1_480000_288000 5.356235
R8695 n1_m1_480000_288000 n1_m1_484800_288000 5.356235
R8696 n1_m1_484800_288000 n1_m1_489600_288000 5.356235
R8697 n1_m1_489600_288000 n1_m1_494400_288000 5.356235
R8698 n1_m1_494400_288000 n1_m1_499200_288000 5.356235
R8699 n1_m1_499200_288000 n1_m1_504000_288000 5.356235
R8700 n1_m1_504000_288000 n1_m1_508000_288000 4.463529
R8701 n1_m1_508800_288000 n1_m1_508000_288000 0.892706
R8702 n1_m1_508800_288000 n1_m1_513600_288000 5.356235
R8703 n1_m1_513600_288000 n1_m1_518400_288000 5.356235
R8704 n1_m1_518400_288000 n1_m1_523200_288000 5.356235
R8705 n1_m1_523200_288000 n1_m1_528000_288000 5.356235
R8706 n1_m1_528000_288000 n1_m1_532800_288000 5.356235
R8707 n1_m1_532800_288000 n1_m1_536000_288000 3.570824
R8708 n1_m1_537600_288000 n1_m1_536000_288000 1.785412
R8709 n1_m1_537600_288000 n1_m1_542400_288000 5.356235
R8710 n1_m1_542400_288000 n1_m1_547200_288000 5.356235
R8711 n1_m1_547200_288000 n1_m1_552000_288000 5.356235
R8712 n1_m1_552000_288000 n1_m1_556800_288000 5.356235
R8713 n1_m1_556800_288000 n1_m1_561600_288000 5.356235
R8714 n1_m1_561600_288000 n1_m1_564000_288000 2.678118
R8715 n1_m1_566400_288000 n1_m1_564000_288000 2.678118
R8716 n1_m1_566400_288000 n1_m1_571200_288000 5.356235
R8717 n1_m1_571200_288000 n1_m1_576000_288000 5.356235
R8718 n1_m1_576000_288000 n1_m1_580800_288000 5.356235
R8719 n1_m1_580800_288000 n1_m1_585600_288000 5.356235
R8720 n1_m1_585600_288000 n1_m1_590400_288000 5.356235
R8721 n1_m1_590400_288000 n1_m1_592000_288000 1.785412
R8722 n1_m1_595200_288000 n1_m1_592000_288000 3.570824
R8723 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R8724 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R8725 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R8726 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R8727 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R8728 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R8729 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R8730 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R8731 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R8732 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R8733 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R8734 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R8735 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R8736 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R8737 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R8738 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R8739 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R8740 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R8741 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R8742 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R8743 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R8744 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R8745 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R8746 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R8747 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R8748 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R8749 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R8750 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R8751 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R8752 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R8753 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R8754 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R8755 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R8756 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R8757 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R8758 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R8759 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R8760 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R8761 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R8762 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R8763 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R8764 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R8765 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R8766 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R8767 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R8768 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R8769 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R8770 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R8771 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R8772 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R8773 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R8774 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R8775 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R8776 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R8777 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R8778 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R8779 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R8780 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R8781 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R8782 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R8783 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R8784 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R8785 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R8786 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R8787 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R8788 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R8789 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R8790 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R8791 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R8792 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R8793 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R8794 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R8795 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R8796 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R8797 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R8798 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R8799 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R8800 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R8801 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R8802 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R8803 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R8804 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R8805 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R8806 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R8807 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R8808 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R8809 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R8810 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R8811 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R8812 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R8813 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R8814 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R8815 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R8816 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R8817 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R8818 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R8819 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R8820 n1_m1_403200_292800 n1_m1_408000_292800 5.356235
R8821 n1_m1_408000_292800 n1_m1_412800_292800 5.356235
R8822 n1_m1_412800_292800 n1_m1_417600_292800 5.356235
R8823 n1_m1_417600_292800 n1_m1_422400_292800 5.356235
R8824 n1_m1_422400_292800 n1_m1_424000_292800 1.785412
R8825 n1_m1_427200_292800 n1_m1_424000_292800 3.570824
R8826 n1_m1_427200_292800 n1_m1_432000_292800 5.356235
R8827 n1_m1_432000_292800 n1_m1_436800_292800 5.356235
R8828 n1_m1_436800_292800 n1_m1_441600_292800 5.356235
R8829 n1_m1_441600_292800 n1_m1_446400_292800 5.356235
R8830 n1_m1_446400_292800 n1_m1_451200_292800 5.356235
R8831 n1_m1_451200_292800 n1_m1_452000_292800 0.892706
R8832 n1_m1_456000_292800 n1_m1_452000_292800 4.463529
R8833 n1_m1_456000_292800 n1_m1_460800_292800 5.356235
R8834 n1_m1_460800_292800 n1_m1_465600_292800 5.356235
R8835 n1_m1_465600_292800 n1_m1_470400_292800 5.356235
R8836 n1_m1_470400_292800 n1_m1_475200_292800 5.356235
R8837 n1_m1_475200_292800 n1_m1_480000_292800 5.356235
R8838 n1_m1_480000_292800 n1_m1_484800_292800 5.356235
R8839 n1_m1_484800_292800 n1_m1_489600_292800 5.356235
R8840 n1_m1_489600_292800 n1_m1_494400_292800 5.356235
R8841 n1_m1_494400_292800 n1_m1_499200_292800 5.356235
R8842 n1_m1_499200_292800 n1_m1_504000_292800 5.356235
R8843 n1_m1_504000_292800 n1_m1_508000_292800 4.463529
R8844 n1_m1_508800_292800 n1_m1_508000_292800 0.892706
R8845 n1_m1_508800_292800 n1_m1_513600_292800 5.356235
R8846 n1_m1_513600_292800 n1_m1_518400_292800 5.356235
R8847 n1_m1_518400_292800 n1_m1_523200_292800 5.356235
R8848 n1_m1_523200_292800 n1_m1_528000_292800 5.356235
R8849 n1_m1_528000_292800 n1_m1_532800_292800 5.356235
R8850 n1_m1_532800_292800 n1_m1_536000_292800 3.570824
R8851 n1_m1_537600_292800 n1_m1_536000_292800 1.785412
R8852 n1_m1_537600_292800 n1_m1_542400_292800 5.356235
R8853 n1_m1_542400_292800 n1_m1_547200_292800 5.356235
R8854 n1_m1_547200_292800 n1_m1_552000_292800 5.356235
R8855 n1_m1_552000_292800 n1_m1_556800_292800 5.356235
R8856 n1_m1_556800_292800 n1_m1_561600_292800 5.356235
R8857 n1_m1_561600_292800 n1_m1_564000_292800 2.678118
R8858 n1_m1_566400_292800 n1_m1_564000_292800 2.678118
R8859 n1_m1_566400_292800 n1_m1_571200_292800 5.356235
R8860 n1_m1_571200_292800 n1_m1_576000_292800 5.356235
R8861 n1_m1_576000_292800 n1_m1_580800_292800 5.356235
R8862 n1_m1_580800_292800 n1_m1_585600_292800 5.356235
R8863 n1_m1_585600_292800 n1_m1_590400_292800 5.356235
R8864 n1_m1_590400_292800 n1_m1_592000_292800 1.785412
R8865 n1_m1_595200_292800 n1_m1_592000_292800 3.570824
R8866 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R8867 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R8868 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R8869 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R8870 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R8871 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R8872 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R8873 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R8874 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R8875 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R8876 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R8877 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R8878 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R8879 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R8880 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R8881 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R8882 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R8883 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R8884 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R8885 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R8886 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R8887 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R8888 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R8889 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R8890 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R8891 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R8892 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R8893 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R8894 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R8895 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R8896 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R8897 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R8898 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R8899 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R8900 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R8901 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R8902 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R8903 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R8904 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R8905 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R8906 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R8907 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R8908 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R8909 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R8910 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R8911 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R8912 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R8913 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R8914 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R8915 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R8916 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R8917 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R8918 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R8919 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R8920 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R8921 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R8922 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R8923 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R8924 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R8925 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R8926 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R8927 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R8928 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R8929 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R8930 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R8931 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R8932 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R8933 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R8934 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R8935 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R8936 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R8937 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R8938 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R8939 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R8940 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R8941 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R8942 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R8943 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R8944 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R8945 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R8946 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R8947 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R8948 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R8949 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R8950 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R8951 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R8952 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R8953 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R8954 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R8955 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R8956 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R8957 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R8958 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R8959 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R8960 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R8961 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R8962 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R8963 n1_m1_403200_297600 n1_m1_408000_297600 5.356235
R8964 n1_m1_408000_297600 n1_m1_412800_297600 5.356235
R8965 n1_m1_412800_297600 n1_m1_417600_297600 5.356235
R8966 n1_m1_417600_297600 n1_m1_422400_297600 5.356235
R8967 n1_m1_422400_297600 n1_m1_424000_297600 1.785412
R8968 n1_m1_427200_297600 n1_m1_424000_297600 3.570824
R8969 n1_m1_427200_297600 n1_m1_432000_297600 5.356235
R8970 n1_m1_432000_297600 n1_m1_436800_297600 5.356235
R8971 n1_m1_436800_297600 n1_m1_441600_297600 5.356235
R8972 n1_m1_441600_297600 n1_m1_446400_297600 5.356235
R8973 n1_m1_446400_297600 n1_m1_451200_297600 5.356235
R8974 n1_m1_451200_297600 n1_m1_452000_297600 0.892706
R8975 n1_m1_456000_297600 n1_m1_452000_297600 4.463529
R8976 n1_m1_456000_297600 n1_m1_460800_297600 5.356235
R8977 n1_m1_460800_297600 n1_m1_465600_297600 5.356235
R8978 n1_m1_465600_297600 n1_m1_470400_297600 5.356235
R8979 n1_m1_470400_297600 n1_m1_475200_297600 5.356235
R8980 n1_m1_475200_297600 n1_m1_480000_297600 5.356235
R8981 n1_m1_480000_297600 n1_m1_484800_297600 5.356235
R8982 n1_m1_484800_297600 n1_m1_489600_297600 5.356235
R8983 n1_m1_489600_297600 n1_m1_494400_297600 5.356235
R8984 n1_m1_494400_297600 n1_m1_499200_297600 5.356235
R8985 n1_m1_499200_297600 n1_m1_504000_297600 5.356235
R8986 n1_m1_504000_297600 n1_m1_508000_297600 4.463529
R8987 n1_m1_508800_297600 n1_m1_508000_297600 0.892706
R8988 n1_m1_508800_297600 n1_m1_513600_297600 5.356235
R8989 n1_m1_513600_297600 n1_m1_518400_297600 5.356235
R8990 n1_m1_518400_297600 n1_m1_523200_297600 5.356235
R8991 n1_m1_523200_297600 n1_m1_528000_297600 5.356235
R8992 n1_m1_528000_297600 n1_m1_532800_297600 5.356235
R8993 n1_m1_532800_297600 n1_m1_536000_297600 3.570824
R8994 n1_m1_537600_297600 n1_m1_536000_297600 1.785412
R8995 n1_m1_537600_297600 n1_m1_542400_297600 5.356235
R8996 n1_m1_542400_297600 n1_m1_547200_297600 5.356235
R8997 n1_m1_547200_297600 n1_m1_552000_297600 5.356235
R8998 n1_m1_552000_297600 n1_m1_556800_297600 5.356235
R8999 n1_m1_556800_297600 n1_m1_561600_297600 5.356235
R9000 n1_m1_561600_297600 n1_m1_564000_297600 2.678118
R9001 n1_m1_566400_297600 n1_m1_564000_297600 2.678118
R9002 n1_m1_566400_297600 n1_m1_571200_297600 5.356235
R9003 n1_m1_571200_297600 n1_m1_576000_297600 5.356235
R9004 n1_m1_576000_297600 n1_m1_580800_297600 5.356235
R9005 n1_m1_580800_297600 n1_m1_585600_297600 5.356235
R9006 n1_m1_585600_297600 n1_m1_590400_297600 5.356235
R9007 n1_m1_590400_297600 n1_m1_592000_297600 1.785412
R9008 n1_m1_595200_297600 n1_m1_592000_297600 3.570824
R9009 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R9010 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R9011 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R9012 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R9013 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R9014 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R9015 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R9016 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R9017 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R9018 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R9019 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R9020 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R9021 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R9022 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R9023 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R9024 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R9025 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R9026 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R9027 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R9028 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R9029 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R9030 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R9031 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R9032 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R9033 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R9034 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R9035 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R9036 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R9037 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R9038 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R9039 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R9040 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R9041 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R9042 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R9043 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R9044 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R9045 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R9046 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R9047 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R9048 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R9049 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R9050 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R9051 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R9052 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R9053 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R9054 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R9055 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R9056 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R9057 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R9058 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R9059 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R9060 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R9061 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R9062 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R9063 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R9064 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R9065 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R9066 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R9067 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R9068 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R9069 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R9070 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R9071 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R9072 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R9073 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R9074 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R9075 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R9076 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R9077 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R9078 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R9079 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R9080 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R9081 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R9082 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R9083 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R9084 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R9085 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R9086 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R9087 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R9088 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R9089 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R9090 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R9091 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R9092 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R9093 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R9094 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R9095 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R9096 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R9097 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R9098 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R9099 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R9100 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R9101 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R9102 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R9103 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R9104 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R9105 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R9106 n1_m1_403200_302400 n1_m1_408000_302400 5.356235
R9107 n1_m1_408000_302400 n1_m1_412800_302400 5.356235
R9108 n1_m1_412800_302400 n1_m1_417600_302400 5.356235
R9109 n1_m1_417600_302400 n1_m1_422400_302400 5.356235
R9110 n1_m1_422400_302400 n1_m1_424000_302400 1.785412
R9111 n1_m1_427200_302400 n1_m1_424000_302400 3.570824
R9112 n1_m1_427200_302400 n1_m1_432000_302400 5.356235
R9113 n1_m1_432000_302400 n1_m1_436800_302400 5.356235
R9114 n1_m1_436800_302400 n1_m1_441600_302400 5.356235
R9115 n1_m1_441600_302400 n1_m1_446400_302400 5.356235
R9116 n1_m1_446400_302400 n1_m1_451200_302400 5.356235
R9117 n1_m1_451200_302400 n1_m1_452000_302400 0.892706
R9118 n1_m1_456000_302400 n1_m1_452000_302400 4.463529
R9119 n1_m1_456000_302400 n1_m1_460800_302400 5.356235
R9120 n1_m1_460800_302400 n1_m1_465600_302400 5.356235
R9121 n1_m1_465600_302400 n1_m1_470400_302400 5.356235
R9122 n1_m1_470400_302400 n1_m1_475200_302400 5.356235
R9123 n1_m1_475200_302400 n1_m1_480000_302400 5.356235
R9124 n1_m1_480000_302400 n1_m1_484800_302400 5.356235
R9125 n1_m1_484800_302400 n1_m1_489600_302400 5.356235
R9126 n1_m1_489600_302400 n1_m1_494400_302400 5.356235
R9127 n1_m1_494400_302400 n1_m1_499200_302400 5.356235
R9128 n1_m1_499200_302400 n1_m1_504000_302400 5.356235
R9129 n1_m1_504000_302400 n1_m1_508000_302400 4.463529
R9130 n1_m1_508800_302400 n1_m1_508000_302400 0.892706
R9131 n1_m1_508800_302400 n1_m1_513600_302400 5.356235
R9132 n1_m1_513600_302400 n1_m1_518400_302400 5.356235
R9133 n1_m1_518400_302400 n1_m1_523200_302400 5.356235
R9134 n1_m1_523200_302400 n1_m1_528000_302400 5.356235
R9135 n1_m1_528000_302400 n1_m1_532800_302400 5.356235
R9136 n1_m1_532800_302400 n1_m1_536000_302400 3.570824
R9137 n1_m1_537600_302400 n1_m1_536000_302400 1.785412
R9138 n1_m1_537600_302400 n1_m1_542400_302400 5.356235
R9139 n1_m1_542400_302400 n1_m1_547200_302400 5.356235
R9140 n1_m1_547200_302400 n1_m1_552000_302400 5.356235
R9141 n1_m1_552000_302400 n1_m1_556800_302400 5.356235
R9142 n1_m1_556800_302400 n1_m1_561600_302400 5.356235
R9143 n1_m1_561600_302400 n1_m1_564000_302400 2.678118
R9144 n1_m1_566400_302400 n1_m1_564000_302400 2.678118
R9145 n1_m1_566400_302400 n1_m1_571200_302400 5.356235
R9146 n1_m1_571200_302400 n1_m1_576000_302400 5.356235
R9147 n1_m1_576000_302400 n1_m1_580800_302400 5.356235
R9148 n1_m1_580800_302400 n1_m1_585600_302400 5.356235
R9149 n1_m1_585600_302400 n1_m1_590400_302400 5.356235
R9150 n1_m1_590400_302400 n1_m1_592000_302400 1.785412
R9151 n1_m1_595200_302400 n1_m1_592000_302400 3.570824
R9152 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R9153 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R9154 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R9155 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R9156 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R9157 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R9158 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R9159 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R9160 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R9161 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R9162 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R9163 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R9164 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R9165 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R9166 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R9167 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R9168 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R9169 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R9170 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R9171 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R9172 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R9173 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R9174 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R9175 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R9176 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R9177 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R9178 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R9179 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R9180 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R9181 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R9182 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R9183 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R9184 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R9185 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R9186 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R9187 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R9188 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R9189 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R9190 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R9191 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R9192 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R9193 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R9194 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R9195 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R9196 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R9197 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R9198 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R9199 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R9200 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R9201 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R9202 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R9203 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R9204 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R9205 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R9206 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R9207 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R9208 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R9209 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R9210 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R9211 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R9212 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R9213 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R9214 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R9215 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R9216 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R9217 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R9218 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R9219 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R9220 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R9221 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R9222 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R9223 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R9224 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R9225 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R9226 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R9227 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R9228 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R9229 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R9230 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R9231 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R9232 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R9233 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R9234 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R9235 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R9236 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R9237 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R9238 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R9239 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R9240 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R9241 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R9242 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R9243 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R9244 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R9245 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R9246 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R9247 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R9248 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R9249 n1_m1_403200_307200 n1_m1_408000_307200 5.356235
R9250 n1_m1_408000_307200 n1_m1_412800_307200 5.356235
R9251 n1_m1_412800_307200 n1_m1_417600_307200 5.356235
R9252 n1_m1_417600_307200 n1_m1_422400_307200 5.356235
R9253 n1_m1_422400_307200 n1_m1_424000_307200 1.785412
R9254 n1_m1_427200_307200 n1_m1_424000_307200 3.570824
R9255 n1_m1_427200_307200 n1_m1_432000_307200 5.356235
R9256 n1_m1_432000_307200 n1_m1_436800_307200 5.356235
R9257 n1_m1_436800_307200 n1_m1_441600_307200 5.356235
R9258 n1_m1_441600_307200 n1_m1_446400_307200 5.356235
R9259 n1_m1_446400_307200 n1_m1_451200_307200 5.356235
R9260 n1_m1_451200_307200 n1_m1_452000_307200 0.892706
R9261 n1_m1_456000_307200 n1_m1_452000_307200 4.463529
R9262 n1_m1_456000_307200 n1_m1_460800_307200 5.356235
R9263 n1_m1_460800_307200 n1_m1_465600_307200 5.356235
R9264 n1_m1_465600_307200 n1_m1_470400_307200 5.356235
R9265 n1_m1_470400_307200 n1_m1_475200_307200 5.356235
R9266 n1_m1_475200_307200 n1_m1_480000_307200 5.356235
R9267 n1_m1_480000_307200 n1_m1_484800_307200 5.356235
R9268 n1_m1_484800_307200 n1_m1_489600_307200 5.356235
R9269 n1_m1_489600_307200 n1_m1_494400_307200 5.356235
R9270 n1_m1_494400_307200 n1_m1_499200_307200 5.356235
R9271 n1_m1_499200_307200 n1_m1_504000_307200 5.356235
R9272 n1_m1_504000_307200 n1_m1_508000_307200 4.463529
R9273 n1_m1_508800_307200 n1_m1_508000_307200 0.892706
R9274 n1_m1_508800_307200 n1_m1_513600_307200 5.356235
R9275 n1_m1_513600_307200 n1_m1_518400_307200 5.356235
R9276 n1_m1_518400_307200 n1_m1_523200_307200 5.356235
R9277 n1_m1_523200_307200 n1_m1_528000_307200 5.356235
R9278 n1_m1_528000_307200 n1_m1_532800_307200 5.356235
R9279 n1_m1_532800_307200 n1_m1_536000_307200 3.570824
R9280 n1_m1_537600_307200 n1_m1_536000_307200 1.785412
R9281 n1_m1_537600_307200 n1_m1_542400_307200 5.356235
R9282 n1_m1_542400_307200 n1_m1_547200_307200 5.356235
R9283 n1_m1_547200_307200 n1_m1_552000_307200 5.356235
R9284 n1_m1_552000_307200 n1_m1_556800_307200 5.356235
R9285 n1_m1_556800_307200 n1_m1_561600_307200 5.356235
R9286 n1_m1_561600_307200 n1_m1_564000_307200 2.678118
R9287 n1_m1_566400_307200 n1_m1_564000_307200 2.678118
R9288 n1_m1_566400_307200 n1_m1_571200_307200 5.356235
R9289 n1_m1_571200_307200 n1_m1_576000_307200 5.356235
R9290 n1_m1_576000_307200 n1_m1_580800_307200 5.356235
R9291 n1_m1_580800_307200 n1_m1_585600_307200 5.356235
R9292 n1_m1_585600_307200 n1_m1_590400_307200 5.356235
R9293 n1_m1_590400_307200 n1_m1_592000_307200 1.785412
R9294 n1_m1_595200_307200 n1_m1_592000_307200 3.570824
R9295 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R9296 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R9297 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R9298 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R9299 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R9300 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R9301 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R9302 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R9303 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R9304 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R9305 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R9306 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R9307 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R9308 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R9309 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R9310 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R9311 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R9312 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R9313 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R9314 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R9315 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R9316 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R9317 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R9318 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R9319 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R9320 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R9321 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R9322 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R9323 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R9324 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R9325 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R9326 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R9327 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R9328 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R9329 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R9330 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R9331 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R9332 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R9333 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R9334 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R9335 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R9336 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R9337 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R9338 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R9339 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R9340 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R9341 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R9342 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R9343 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R9344 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R9345 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R9346 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R9347 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R9348 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R9349 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R9350 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R9351 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R9352 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R9353 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R9354 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R9355 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R9356 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R9357 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R9358 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R9359 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R9360 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R9361 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R9362 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R9363 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R9364 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R9365 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R9366 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R9367 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R9368 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R9369 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R9370 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R9371 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R9372 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R9373 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R9374 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R9375 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R9376 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R9377 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R9378 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R9379 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R9380 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R9381 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R9382 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R9383 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R9384 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R9385 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R9386 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R9387 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R9388 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R9389 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R9390 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R9391 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R9392 n1_m1_403200_312000 n1_m1_408000_312000 5.356235
R9393 n1_m1_408000_312000 n1_m1_412800_312000 5.356235
R9394 n1_m1_412800_312000 n1_m1_417600_312000 5.356235
R9395 n1_m1_417600_312000 n1_m1_422400_312000 5.356235
R9396 n1_m1_422400_312000 n1_m1_424000_312000 1.785412
R9397 n1_m1_427200_312000 n1_m1_424000_312000 3.570824
R9398 n1_m1_427200_312000 n1_m1_432000_312000 5.356235
R9399 n1_m1_432000_312000 n1_m1_436800_312000 5.356235
R9400 n1_m1_436800_312000 n1_m1_441600_312000 5.356235
R9401 n1_m1_441600_312000 n1_m1_446400_312000 5.356235
R9402 n1_m1_446400_312000 n1_m1_451200_312000 5.356235
R9403 n1_m1_451200_312000 n1_m1_452000_312000 0.892706
R9404 n1_m1_456000_312000 n1_m1_452000_312000 4.463529
R9405 n1_m1_456000_312000 n1_m1_460800_312000 5.356235
R9406 n1_m1_460800_312000 n1_m1_465600_312000 5.356235
R9407 n1_m1_465600_312000 n1_m1_470400_312000 5.356235
R9408 n1_m1_470400_312000 n1_m1_475200_312000 5.356235
R9409 n1_m1_475200_312000 n1_m1_480000_312000 5.356235
R9410 n1_m1_480000_312000 n1_m1_484800_312000 5.356235
R9411 n1_m1_484800_312000 n1_m1_489600_312000 5.356235
R9412 n1_m1_489600_312000 n1_m1_494400_312000 5.356235
R9413 n1_m1_494400_312000 n1_m1_499200_312000 5.356235
R9414 n1_m1_499200_312000 n1_m1_504000_312000 5.356235
R9415 n1_m1_504000_312000 n1_m1_508000_312000 4.463529
R9416 n1_m1_508800_312000 n1_m1_508000_312000 0.892706
R9417 n1_m1_508800_312000 n1_m1_513600_312000 5.356235
R9418 n1_m1_513600_312000 n1_m1_518400_312000 5.356235
R9419 n1_m1_518400_312000 n1_m1_523200_312000 5.356235
R9420 n1_m1_523200_312000 n1_m1_528000_312000 5.356235
R9421 n1_m1_528000_312000 n1_m1_532800_312000 5.356235
R9422 n1_m1_532800_312000 n1_m1_536000_312000 3.570824
R9423 n1_m1_537600_312000 n1_m1_536000_312000 1.785412
R9424 n1_m1_537600_312000 n1_m1_542400_312000 5.356235
R9425 n1_m1_542400_312000 n1_m1_547200_312000 5.356235
R9426 n1_m1_547200_312000 n1_m1_552000_312000 5.356235
R9427 n1_m1_552000_312000 n1_m1_556800_312000 5.356235
R9428 n1_m1_556800_312000 n1_m1_561600_312000 5.356235
R9429 n1_m1_561600_312000 n1_m1_564000_312000 2.678118
R9430 n1_m1_566400_312000 n1_m1_564000_312000 2.678118
R9431 n1_m1_566400_312000 n1_m1_571200_312000 5.356235
R9432 n1_m1_571200_312000 n1_m1_576000_312000 5.356235
R9433 n1_m1_576000_312000 n1_m1_580800_312000 5.356235
R9434 n1_m1_580800_312000 n1_m1_585600_312000 5.356235
R9435 n1_m1_585600_312000 n1_m1_590400_312000 5.356235
R9436 n1_m1_590400_312000 n1_m1_592000_312000 1.785412
R9437 n1_m1_595200_312000 n1_m1_592000_312000 3.570824
R9438 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R9439 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R9440 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R9441 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R9442 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R9443 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R9444 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R9445 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R9446 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R9447 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R9448 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R9449 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R9450 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R9451 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R9452 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R9453 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R9454 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R9455 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R9456 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R9457 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R9458 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R9459 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R9460 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R9461 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R9462 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R9463 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R9464 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R9465 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R9466 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R9467 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R9468 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R9469 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R9470 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R9471 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R9472 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R9473 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R9474 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R9475 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R9476 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R9477 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R9478 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R9479 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R9480 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R9481 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R9482 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R9483 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R9484 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R9485 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R9486 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R9487 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R9488 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R9489 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R9490 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R9491 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R9492 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R9493 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R9494 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R9495 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R9496 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R9497 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R9498 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R9499 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R9500 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R9501 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R9502 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R9503 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R9504 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R9505 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R9506 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R9507 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R9508 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R9509 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R9510 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R9511 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R9512 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R9513 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R9514 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R9515 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R9516 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R9517 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R9518 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R9519 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R9520 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R9521 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R9522 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R9523 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R9524 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R9525 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R9526 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R9527 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R9528 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R9529 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R9530 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R9531 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R9532 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R9533 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R9534 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R9535 n1_m1_403200_316800 n1_m1_408000_316800 5.356235
R9536 n1_m1_408000_316800 n1_m1_412800_316800 5.356235
R9537 n1_m1_412800_316800 n1_m1_417600_316800 5.356235
R9538 n1_m1_417600_316800 n1_m1_422400_316800 5.356235
R9539 n1_m1_422400_316800 n1_m1_424000_316800 1.785412
R9540 n1_m1_427200_316800 n1_m1_424000_316800 3.570824
R9541 n1_m1_427200_316800 n1_m1_432000_316800 5.356235
R9542 n1_m1_432000_316800 n1_m1_436800_316800 5.356235
R9543 n1_m1_436800_316800 n1_m1_441600_316800 5.356235
R9544 n1_m1_441600_316800 n1_m1_446400_316800 5.356235
R9545 n1_m1_446400_316800 n1_m1_451200_316800 5.356235
R9546 n1_m1_451200_316800 n1_m1_452000_316800 0.892706
R9547 n1_m1_456000_316800 n1_m1_452000_316800 4.463529
R9548 n1_m1_456000_316800 n1_m1_460800_316800 5.356235
R9549 n1_m1_460800_316800 n1_m1_465600_316800 5.356235
R9550 n1_m1_465600_316800 n1_m1_470400_316800 5.356235
R9551 n1_m1_470400_316800 n1_m1_475200_316800 5.356235
R9552 n1_m1_475200_316800 n1_m1_480000_316800 5.356235
R9553 n1_m1_480000_316800 n1_m1_484800_316800 5.356235
R9554 n1_m1_484800_316800 n1_m1_489600_316800 5.356235
R9555 n1_m1_489600_316800 n1_m1_494400_316800 5.356235
R9556 n1_m1_494400_316800 n1_m1_499200_316800 5.356235
R9557 n1_m1_499200_316800 n1_m1_504000_316800 5.356235
R9558 n1_m1_504000_316800 n1_m1_508000_316800 4.463529
R9559 n1_m1_508800_316800 n1_m1_508000_316800 0.892706
R9560 n1_m1_508800_316800 n1_m1_513600_316800 5.356235
R9561 n1_m1_513600_316800 n1_m1_518400_316800 5.356235
R9562 n1_m1_518400_316800 n1_m1_523200_316800 5.356235
R9563 n1_m1_523200_316800 n1_m1_528000_316800 5.356235
R9564 n1_m1_528000_316800 n1_m1_532800_316800 5.356235
R9565 n1_m1_532800_316800 n1_m1_536000_316800 3.570824
R9566 n1_m1_537600_316800 n1_m1_536000_316800 1.785412
R9567 n1_m1_537600_316800 n1_m1_542400_316800 5.356235
R9568 n1_m1_542400_316800 n1_m1_547200_316800 5.356235
R9569 n1_m1_547200_316800 n1_m1_552000_316800 5.356235
R9570 n1_m1_552000_316800 n1_m1_556800_316800 5.356235
R9571 n1_m1_556800_316800 n1_m1_561600_316800 5.356235
R9572 n1_m1_561600_316800 n1_m1_564000_316800 2.678118
R9573 n1_m1_566400_316800 n1_m1_564000_316800 2.678118
R9574 n1_m1_566400_316800 n1_m1_571200_316800 5.356235
R9575 n1_m1_571200_316800 n1_m1_576000_316800 5.356235
R9576 n1_m1_576000_316800 n1_m1_580800_316800 5.356235
R9577 n1_m1_580800_316800 n1_m1_585600_316800 5.356235
R9578 n1_m1_585600_316800 n1_m1_590400_316800 5.356235
R9579 n1_m1_590400_316800 n1_m1_592000_316800 1.785412
R9580 n1_m1_595200_316800 n1_m1_592000_316800 3.570824
R9581 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R9582 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R9583 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R9584 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R9585 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R9586 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R9587 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R9588 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R9589 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R9590 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R9591 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R9592 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R9593 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R9594 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R9595 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R9596 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R9597 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R9598 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R9599 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R9600 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R9601 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R9602 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R9603 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R9604 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R9605 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R9606 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R9607 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R9608 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R9609 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R9610 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R9611 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R9612 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R9613 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R9614 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R9615 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R9616 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R9617 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R9618 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R9619 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R9620 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R9621 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R9622 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R9623 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R9624 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R9625 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R9626 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R9627 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R9628 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R9629 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R9630 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R9631 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R9632 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R9633 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R9634 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R9635 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R9636 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R9637 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R9638 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R9639 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R9640 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R9641 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R9642 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R9643 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R9644 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R9645 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R9646 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R9647 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R9648 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R9649 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R9650 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R9651 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R9652 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R9653 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R9654 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R9655 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R9656 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R9657 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R9658 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R9659 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R9660 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R9661 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R9662 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R9663 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R9664 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R9665 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R9666 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R9667 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R9668 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R9669 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R9670 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R9671 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R9672 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R9673 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R9674 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R9675 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R9676 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R9677 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R9678 n1_m1_403200_321600 n1_m1_408000_321600 5.356235
R9679 n1_m1_408000_321600 n1_m1_412800_321600 5.356235
R9680 n1_m1_412800_321600 n1_m1_417600_321600 5.356235
R9681 n1_m1_417600_321600 n1_m1_422400_321600 5.356235
R9682 n1_m1_422400_321600 n1_m1_424000_321600 1.785412
R9683 n1_m1_427200_321600 n1_m1_424000_321600 3.570824
R9684 n1_m1_427200_321600 n1_m1_432000_321600 5.356235
R9685 n1_m1_432000_321600 n1_m1_436800_321600 5.356235
R9686 n1_m1_436800_321600 n1_m1_441600_321600 5.356235
R9687 n1_m1_441600_321600 n1_m1_446400_321600 5.356235
R9688 n1_m1_446400_321600 n1_m1_451200_321600 5.356235
R9689 n1_m1_451200_321600 n1_m1_452000_321600 0.892706
R9690 n1_m1_456000_321600 n1_m1_452000_321600 4.463529
R9691 n1_m1_456000_321600 n1_m1_460800_321600 5.356235
R9692 n1_m1_460800_321600 n1_m1_465600_321600 5.356235
R9693 n1_m1_465600_321600 n1_m1_470400_321600 5.356235
R9694 n1_m1_470400_321600 n1_m1_475200_321600 5.356235
R9695 n1_m1_475200_321600 n1_m1_480000_321600 5.356235
R9696 n1_m1_480000_321600 n1_m1_484800_321600 5.356235
R9697 n1_m1_484800_321600 n1_m1_489600_321600 5.356235
R9698 n1_m1_489600_321600 n1_m1_494400_321600 5.356235
R9699 n1_m1_494400_321600 n1_m1_499200_321600 5.356235
R9700 n1_m1_499200_321600 n1_m1_504000_321600 5.356235
R9701 n1_m1_504000_321600 n1_m1_508000_321600 4.463529
R9702 n1_m1_508800_321600 n1_m1_508000_321600 0.892706
R9703 n1_m1_508800_321600 n1_m1_513600_321600 5.356235
R9704 n1_m1_513600_321600 n1_m1_518400_321600 5.356235
R9705 n1_m1_518400_321600 n1_m1_523200_321600 5.356235
R9706 n1_m1_523200_321600 n1_m1_528000_321600 5.356235
R9707 n1_m1_528000_321600 n1_m1_532800_321600 5.356235
R9708 n1_m1_532800_321600 n1_m1_536000_321600 3.570824
R9709 n1_m1_537600_321600 n1_m1_536000_321600 1.785412
R9710 n1_m1_537600_321600 n1_m1_542400_321600 5.356235
R9711 n1_m1_542400_321600 n1_m1_547200_321600 5.356235
R9712 n1_m1_547200_321600 n1_m1_552000_321600 5.356235
R9713 n1_m1_552000_321600 n1_m1_556800_321600 5.356235
R9714 n1_m1_556800_321600 n1_m1_561600_321600 5.356235
R9715 n1_m1_561600_321600 n1_m1_564000_321600 2.678118
R9716 n1_m1_566400_321600 n1_m1_564000_321600 2.678118
R9717 n1_m1_566400_321600 n1_m1_571200_321600 5.356235
R9718 n1_m1_571200_321600 n1_m1_576000_321600 5.356235
R9719 n1_m1_576000_321600 n1_m1_580800_321600 5.356235
R9720 n1_m1_580800_321600 n1_m1_585600_321600 5.356235
R9721 n1_m1_585600_321600 n1_m1_590400_321600 5.356235
R9722 n1_m1_590400_321600 n1_m1_592000_321600 1.785412
R9723 n1_m1_595200_321600 n1_m1_592000_321600 3.570824
R9724 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R9725 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R9726 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R9727 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R9728 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R9729 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R9730 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R9731 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R9732 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R9733 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R9734 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R9735 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R9736 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R9737 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R9738 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R9739 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R9740 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R9741 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R9742 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R9743 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R9744 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R9745 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R9746 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R9747 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R9748 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R9749 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R9750 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R9751 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R9752 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R9753 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R9754 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R9755 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R9756 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R9757 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R9758 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R9759 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R9760 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R9761 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R9762 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R9763 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R9764 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R9765 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R9766 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R9767 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R9768 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R9769 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R9770 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R9771 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R9772 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R9773 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R9774 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R9775 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R9776 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R9777 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R9778 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R9779 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R9780 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R9781 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R9782 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R9783 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R9784 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R9785 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R9786 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R9787 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R9788 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R9789 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R9790 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R9791 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R9792 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R9793 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R9794 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R9795 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R9796 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R9797 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R9798 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R9799 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R9800 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R9801 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R9802 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R9803 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R9804 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R9805 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R9806 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R9807 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R9808 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R9809 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R9810 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R9811 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R9812 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R9813 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R9814 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R9815 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R9816 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R9817 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R9818 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R9819 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R9820 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R9821 n1_m1_403200_326400 n1_m1_408000_326400 5.356235
R9822 n1_m1_408000_326400 n1_m1_412800_326400 5.356235
R9823 n1_m1_412800_326400 n1_m1_417600_326400 5.356235
R9824 n1_m1_417600_326400 n1_m1_422400_326400 5.356235
R9825 n1_m1_422400_326400 n1_m1_424000_326400 1.785412
R9826 n1_m1_427200_326400 n1_m1_424000_326400 3.570824
R9827 n1_m1_427200_326400 n1_m1_432000_326400 5.356235
R9828 n1_m1_432000_326400 n1_m1_436800_326400 5.356235
R9829 n1_m1_436800_326400 n1_m1_441600_326400 5.356235
R9830 n1_m1_441600_326400 n1_m1_446400_326400 5.356235
R9831 n1_m1_446400_326400 n1_m1_451200_326400 5.356235
R9832 n1_m1_451200_326400 n1_m1_452000_326400 0.892706
R9833 n1_m1_456000_326400 n1_m1_452000_326400 4.463529
R9834 n1_m1_456000_326400 n1_m1_460800_326400 5.356235
R9835 n1_m1_460800_326400 n1_m1_465600_326400 5.356235
R9836 n1_m1_465600_326400 n1_m1_470400_326400 5.356235
R9837 n1_m1_470400_326400 n1_m1_475200_326400 5.356235
R9838 n1_m1_475200_326400 n1_m1_480000_326400 5.356235
R9839 n1_m1_480000_326400 n1_m1_484800_326400 5.356235
R9840 n1_m1_484800_326400 n1_m1_489600_326400 5.356235
R9841 n1_m1_489600_326400 n1_m1_494400_326400 5.356235
R9842 n1_m1_494400_326400 n1_m1_499200_326400 5.356235
R9843 n1_m1_499200_326400 n1_m1_504000_326400 5.356235
R9844 n1_m1_504000_326400 n1_m1_508000_326400 4.463529
R9845 n1_m1_508800_326400 n1_m1_508000_326400 0.892706
R9846 n1_m1_508800_326400 n1_m1_513600_326400 5.356235
R9847 n1_m1_513600_326400 n1_m1_518400_326400 5.356235
R9848 n1_m1_518400_326400 n1_m1_523200_326400 5.356235
R9849 n1_m1_523200_326400 n1_m1_528000_326400 5.356235
R9850 n1_m1_528000_326400 n1_m1_532800_326400 5.356235
R9851 n1_m1_532800_326400 n1_m1_536000_326400 3.570824
R9852 n1_m1_537600_326400 n1_m1_536000_326400 1.785412
R9853 n1_m1_537600_326400 n1_m1_542400_326400 5.356235
R9854 n1_m1_542400_326400 n1_m1_547200_326400 5.356235
R9855 n1_m1_547200_326400 n1_m1_552000_326400 5.356235
R9856 n1_m1_552000_326400 n1_m1_556800_326400 5.356235
R9857 n1_m1_556800_326400 n1_m1_561600_326400 5.356235
R9858 n1_m1_561600_326400 n1_m1_564000_326400 2.678118
R9859 n1_m1_566400_326400 n1_m1_564000_326400 2.678118
R9860 n1_m1_566400_326400 n1_m1_571200_326400 5.356235
R9861 n1_m1_571200_326400 n1_m1_576000_326400 5.356235
R9862 n1_m1_576000_326400 n1_m1_580800_326400 5.356235
R9863 n1_m1_580800_326400 n1_m1_585600_326400 5.356235
R9864 n1_m1_585600_326400 n1_m1_590400_326400 5.356235
R9865 n1_m1_590400_326400 n1_m1_592000_326400 1.785412
R9866 n1_m1_595200_326400 n1_m1_592000_326400 3.570824
R9867 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R9868 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R9869 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R9870 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R9871 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R9872 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R9873 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R9874 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R9875 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R9876 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R9877 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R9878 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R9879 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R9880 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R9881 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R9882 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R9883 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R9884 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R9885 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R9886 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R9887 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R9888 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R9889 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R9890 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R9891 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R9892 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R9893 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R9894 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R9895 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R9896 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R9897 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R9898 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R9899 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R9900 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R9901 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R9902 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R9903 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R9904 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R9905 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R9906 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R9907 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R9908 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R9909 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R9910 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R9911 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R9912 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R9913 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R9914 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R9915 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R9916 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R9917 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R9918 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R9919 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R9920 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R9921 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R9922 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R9923 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R9924 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R9925 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R9926 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R9927 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R9928 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R9929 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R9930 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R9931 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R9932 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R9933 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R9934 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R9935 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R9936 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R9937 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R9938 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R9939 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R9940 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R9941 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R9942 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R9943 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R9944 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R9945 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R9946 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R9947 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R9948 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R9949 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R9950 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R9951 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R9952 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R9953 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R9954 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R9955 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R9956 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R9957 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R9958 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R9959 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R9960 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R9961 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R9962 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R9963 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R9964 n1_m1_403200_331200 n1_m1_408000_331200 5.356235
R9965 n1_m1_408000_331200 n1_m1_412800_331200 5.356235
R9966 n1_m1_412800_331200 n1_m1_417600_331200 5.356235
R9967 n1_m1_417600_331200 n1_m1_422400_331200 5.356235
R9968 n1_m1_422400_331200 n1_m1_424000_331200 1.785412
R9969 n1_m1_427200_331200 n1_m1_424000_331200 3.570824
R9970 n1_m1_427200_331200 n1_m1_432000_331200 5.356235
R9971 n1_m1_432000_331200 n1_m1_436800_331200 5.356235
R9972 n1_m1_436800_331200 n1_m1_441600_331200 5.356235
R9973 n1_m1_441600_331200 n1_m1_446400_331200 5.356235
R9974 n1_m1_446400_331200 n1_m1_451200_331200 5.356235
R9975 n1_m1_451200_331200 n1_m1_452000_331200 0.892706
R9976 n1_m1_456000_331200 n1_m1_452000_331200 4.463529
R9977 n1_m1_456000_331200 n1_m1_460800_331200 5.356235
R9978 n1_m1_460800_331200 n1_m1_465600_331200 5.356235
R9979 n1_m1_465600_331200 n1_m1_470400_331200 5.356235
R9980 n1_m1_470400_331200 n1_m1_475200_331200 5.356235
R9981 n1_m1_475200_331200 n1_m1_480000_331200 5.356235
R9982 n1_m1_480000_331200 n1_m1_484800_331200 5.356235
R9983 n1_m1_484800_331200 n1_m1_489600_331200 5.356235
R9984 n1_m1_489600_331200 n1_m1_494400_331200 5.356235
R9985 n1_m1_494400_331200 n1_m1_499200_331200 5.356235
R9986 n1_m1_499200_331200 n1_m1_504000_331200 5.356235
R9987 n1_m1_504000_331200 n1_m1_508000_331200 4.463529
R9988 n1_m1_508800_331200 n1_m1_508000_331200 0.892706
R9989 n1_m1_508800_331200 n1_m1_513600_331200 5.356235
R9990 n1_m1_513600_331200 n1_m1_518400_331200 5.356235
R9991 n1_m1_518400_331200 n1_m1_523200_331200 5.356235
R9992 n1_m1_523200_331200 n1_m1_528000_331200 5.356235
R9993 n1_m1_528000_331200 n1_m1_532800_331200 5.356235
R9994 n1_m1_532800_331200 n1_m1_536000_331200 3.570824
R9995 n1_m1_537600_331200 n1_m1_536000_331200 1.785412
R9996 n1_m1_537600_331200 n1_m1_542400_331200 5.356235
R9997 n1_m1_542400_331200 n1_m1_547200_331200 5.356235
R9998 n1_m1_547200_331200 n1_m1_552000_331200 5.356235
R9999 n1_m1_552000_331200 n1_m1_556800_331200 5.356235
R10000 n1_m1_556800_331200 n1_m1_561600_331200 5.356235
R10001 n1_m1_561600_331200 n1_m1_564000_331200 2.678118
R10002 n1_m1_566400_331200 n1_m1_564000_331200 2.678118
R10003 n1_m1_566400_331200 n1_m1_571200_331200 5.356235
R10004 n1_m1_571200_331200 n1_m1_576000_331200 5.356235
R10005 n1_m1_576000_331200 n1_m1_580800_331200 5.356235
R10006 n1_m1_580800_331200 n1_m1_585600_331200 5.356235
R10007 n1_m1_585600_331200 n1_m1_590400_331200 5.356235
R10008 n1_m1_590400_331200 n1_m1_592000_331200 1.785412
R10009 n1_m1_595200_331200 n1_m1_592000_331200 3.570824
R10010 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R10011 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R10012 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R10013 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R10014 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R10015 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R10016 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R10017 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R10018 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R10019 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R10020 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R10021 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R10022 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R10023 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R10024 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R10025 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R10026 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R10027 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R10028 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R10029 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R10030 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R10031 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R10032 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R10033 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R10034 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R10035 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R10036 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R10037 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R10038 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R10039 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R10040 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R10041 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R10042 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R10043 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R10044 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R10045 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R10046 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R10047 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R10048 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R10049 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R10050 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R10051 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R10052 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R10053 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R10054 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R10055 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R10056 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R10057 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R10058 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R10059 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R10060 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R10061 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R10062 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R10063 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R10064 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R10065 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R10066 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R10067 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R10068 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R10069 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R10070 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R10071 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R10072 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R10073 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R10074 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R10075 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R10076 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R10077 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R10078 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R10079 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R10080 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R10081 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R10082 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R10083 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R10084 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R10085 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R10086 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R10087 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R10088 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R10089 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R10090 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R10091 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R10092 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R10093 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R10094 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R10095 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R10096 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R10097 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R10098 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R10099 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R10100 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R10101 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R10102 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R10103 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R10104 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R10105 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R10106 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R10107 n1_m1_403200_336000 n1_m1_408000_336000 5.356235
R10108 n1_m1_408000_336000 n1_m1_412800_336000 5.356235
R10109 n1_m1_412800_336000 n1_m1_417600_336000 5.356235
R10110 n1_m1_417600_336000 n1_m1_422400_336000 5.356235
R10111 n1_m1_422400_336000 n1_m1_424000_336000 1.785412
R10112 n1_m1_427200_336000 n1_m1_424000_336000 3.570824
R10113 n1_m1_427200_336000 n1_m1_432000_336000 5.356235
R10114 n1_m1_432000_336000 n1_m1_436800_336000 5.356235
R10115 n1_m1_436800_336000 n1_m1_441600_336000 5.356235
R10116 n1_m1_441600_336000 n1_m1_446400_336000 5.356235
R10117 n1_m1_446400_336000 n1_m1_451200_336000 5.356235
R10118 n1_m1_451200_336000 n1_m1_452000_336000 0.892706
R10119 n1_m1_456000_336000 n1_m1_452000_336000 4.463529
R10120 n1_m1_456000_336000 n1_m1_460800_336000 5.356235
R10121 n1_m1_460800_336000 n1_m1_465600_336000 5.356235
R10122 n1_m1_465600_336000 n1_m1_470400_336000 5.356235
R10123 n1_m1_470400_336000 n1_m1_475200_336000 5.356235
R10124 n1_m1_475200_336000 n1_m1_480000_336000 5.356235
R10125 n1_m1_480000_336000 n1_m1_484800_336000 5.356235
R10126 n1_m1_484800_336000 n1_m1_489600_336000 5.356235
R10127 n1_m1_489600_336000 n1_m1_494400_336000 5.356235
R10128 n1_m1_494400_336000 n1_m1_499200_336000 5.356235
R10129 n1_m1_499200_336000 n1_m1_504000_336000 5.356235
R10130 n1_m1_504000_336000 n1_m1_508000_336000 4.463529
R10131 n1_m1_508800_336000 n1_m1_508000_336000 0.892706
R10132 n1_m1_508800_336000 n1_m1_513600_336000 5.356235
R10133 n1_m1_513600_336000 n1_m1_518400_336000 5.356235
R10134 n1_m1_518400_336000 n1_m1_523200_336000 5.356235
R10135 n1_m1_523200_336000 n1_m1_528000_336000 5.356235
R10136 n1_m1_528000_336000 n1_m1_532800_336000 5.356235
R10137 n1_m1_532800_336000 n1_m1_536000_336000 3.570824
R10138 n1_m1_537600_336000 n1_m1_536000_336000 1.785412
R10139 n1_m1_537600_336000 n1_m1_542400_336000 5.356235
R10140 n1_m1_542400_336000 n1_m1_547200_336000 5.356235
R10141 n1_m1_547200_336000 n1_m1_552000_336000 5.356235
R10142 n1_m1_552000_336000 n1_m1_556800_336000 5.356235
R10143 n1_m1_556800_336000 n1_m1_561600_336000 5.356235
R10144 n1_m1_561600_336000 n1_m1_564000_336000 2.678118
R10145 n1_m1_566400_336000 n1_m1_564000_336000 2.678118
R10146 n1_m1_566400_336000 n1_m1_571200_336000 5.356235
R10147 n1_m1_571200_336000 n1_m1_576000_336000 5.356235
R10148 n1_m1_576000_336000 n1_m1_580800_336000 5.356235
R10149 n1_m1_580800_336000 n1_m1_585600_336000 5.356235
R10150 n1_m1_585600_336000 n1_m1_590400_336000 5.356235
R10151 n1_m1_590400_336000 n1_m1_592000_336000 1.785412
R10152 n1_m1_595200_336000 n1_m1_592000_336000 3.570824
R10153 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R10154 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R10155 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R10156 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R10157 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R10158 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R10159 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R10160 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R10161 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R10162 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R10163 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R10164 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R10165 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R10166 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R10167 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R10168 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R10169 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R10170 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R10171 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R10172 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R10173 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R10174 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R10175 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R10176 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R10177 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R10178 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R10179 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R10180 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R10181 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R10182 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R10183 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R10184 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R10185 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R10186 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R10187 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R10188 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R10189 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R10190 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R10191 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R10192 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R10193 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R10194 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R10195 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R10196 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R10197 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R10198 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R10199 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R10200 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R10201 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R10202 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R10203 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R10204 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R10205 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R10206 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R10207 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R10208 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R10209 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R10210 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R10211 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R10212 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R10213 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R10214 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R10215 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R10216 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R10217 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R10218 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R10219 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R10220 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R10221 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R10222 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R10223 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R10224 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R10225 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R10226 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R10227 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R10228 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R10229 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R10230 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R10231 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R10232 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R10233 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R10234 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R10235 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R10236 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R10237 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R10238 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R10239 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R10240 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R10241 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R10242 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R10243 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R10244 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R10245 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R10246 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R10247 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R10248 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R10249 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R10250 n1_m1_403200_340800 n1_m1_408000_340800 5.356235
R10251 n1_m1_408000_340800 n1_m1_412800_340800 5.356235
R10252 n1_m1_412800_340800 n1_m1_417600_340800 5.356235
R10253 n1_m1_417600_340800 n1_m1_422400_340800 5.356235
R10254 n1_m1_422400_340800 n1_m1_424000_340800 1.785412
R10255 n1_m1_427200_340800 n1_m1_424000_340800 3.570824
R10256 n1_m1_427200_340800 n1_m1_432000_340800 5.356235
R10257 n1_m1_432000_340800 n1_m1_436800_340800 5.356235
R10258 n1_m1_436800_340800 n1_m1_441600_340800 5.356235
R10259 n1_m1_441600_340800 n1_m1_446400_340800 5.356235
R10260 n1_m1_446400_340800 n1_m1_451200_340800 5.356235
R10261 n1_m1_451200_340800 n1_m1_452000_340800 0.892706
R10262 n1_m1_456000_340800 n1_m1_452000_340800 4.463529
R10263 n1_m1_456000_340800 n1_m1_460800_340800 5.356235
R10264 n1_m1_460800_340800 n1_m1_465600_340800 5.356235
R10265 n1_m1_465600_340800 n1_m1_470400_340800 5.356235
R10266 n1_m1_470400_340800 n1_m1_475200_340800 5.356235
R10267 n1_m1_475200_340800 n1_m1_480000_340800 5.356235
R10268 n1_m1_480000_340800 n1_m1_484800_340800 5.356235
R10269 n1_m1_484800_340800 n1_m1_489600_340800 5.356235
R10270 n1_m1_489600_340800 n1_m1_494400_340800 5.356235
R10271 n1_m1_494400_340800 n1_m1_499200_340800 5.356235
R10272 n1_m1_499200_340800 n1_m1_504000_340800 5.356235
R10273 n1_m1_504000_340800 n1_m1_508000_340800 4.463529
R10274 n1_m1_508800_340800 n1_m1_508000_340800 0.892706
R10275 n1_m1_508800_340800 n1_m1_513600_340800 5.356235
R10276 n1_m1_513600_340800 n1_m1_518400_340800 5.356235
R10277 n1_m1_518400_340800 n1_m1_523200_340800 5.356235
R10278 n1_m1_523200_340800 n1_m1_528000_340800 5.356235
R10279 n1_m1_528000_340800 n1_m1_532800_340800 5.356235
R10280 n1_m1_532800_340800 n1_m1_536000_340800 3.570824
R10281 n1_m1_537600_340800 n1_m1_536000_340800 1.785412
R10282 n1_m1_537600_340800 n1_m1_542400_340800 5.356235
R10283 n1_m1_542400_340800 n1_m1_547200_340800 5.356235
R10284 n1_m1_547200_340800 n1_m1_552000_340800 5.356235
R10285 n1_m1_552000_340800 n1_m1_556800_340800 5.356235
R10286 n1_m1_556800_340800 n1_m1_561600_340800 5.356235
R10287 n1_m1_561600_340800 n1_m1_564000_340800 2.678118
R10288 n1_m1_566400_340800 n1_m1_564000_340800 2.678118
R10289 n1_m1_566400_340800 n1_m1_571200_340800 5.356235
R10290 n1_m1_571200_340800 n1_m1_576000_340800 5.356235
R10291 n1_m1_576000_340800 n1_m1_580800_340800 5.356235
R10292 n1_m1_580800_340800 n1_m1_585600_340800 5.356235
R10293 n1_m1_585600_340800 n1_m1_590400_340800 5.356235
R10294 n1_m1_590400_340800 n1_m1_592000_340800 1.785412
R10295 n1_m1_595200_340800 n1_m1_592000_340800 3.570824
R10296 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R10297 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R10298 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R10299 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R10300 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R10301 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R10302 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R10303 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R10304 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R10305 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R10306 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R10307 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R10308 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R10309 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R10310 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R10311 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R10312 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R10313 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R10314 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R10315 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R10316 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R10317 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R10318 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R10319 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R10320 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R10321 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R10322 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R10323 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R10324 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R10325 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R10326 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R10327 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R10328 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R10329 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R10330 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R10331 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R10332 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R10333 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R10334 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R10335 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R10336 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R10337 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R10338 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R10339 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R10340 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R10341 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R10342 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R10343 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R10344 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R10345 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R10346 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R10347 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R10348 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R10349 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R10350 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R10351 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R10352 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R10353 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R10354 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R10355 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R10356 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R10357 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R10358 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R10359 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R10360 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R10361 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R10362 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R10363 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R10364 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R10365 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R10366 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R10367 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R10368 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R10369 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R10370 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R10371 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R10372 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R10373 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R10374 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R10375 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R10376 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R10377 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R10378 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R10379 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R10380 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R10381 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R10382 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R10383 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R10384 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R10385 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R10386 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R10387 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R10388 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R10389 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R10390 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R10391 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R10392 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R10393 n1_m1_403200_345600 n1_m1_408000_345600 5.356235
R10394 n1_m1_408000_345600 n1_m1_412800_345600 5.356235
R10395 n1_m1_412800_345600 n1_m1_417600_345600 5.356235
R10396 n1_m1_417600_345600 n1_m1_422400_345600 5.356235
R10397 n1_m1_422400_345600 n1_m1_424000_345600 1.785412
R10398 n1_m1_427200_345600 n1_m1_424000_345600 3.570824
R10399 n1_m1_427200_345600 n1_m1_432000_345600 5.356235
R10400 n1_m1_432000_345600 n1_m1_436800_345600 5.356235
R10401 n1_m1_436800_345600 n1_m1_441600_345600 5.356235
R10402 n1_m1_441600_345600 n1_m1_446400_345600 5.356235
R10403 n1_m1_446400_345600 n1_m1_451200_345600 5.356235
R10404 n1_m1_451200_345600 n1_m1_452000_345600 0.892706
R10405 n1_m1_456000_345600 n1_m1_452000_345600 4.463529
R10406 n1_m1_456000_345600 n1_m1_460800_345600 5.356235
R10407 n1_m1_460800_345600 n1_m1_465600_345600 5.356235
R10408 n1_m1_465600_345600 n1_m1_470400_345600 5.356235
R10409 n1_m1_470400_345600 n1_m1_475200_345600 5.356235
R10410 n1_m1_475200_345600 n1_m1_480000_345600 5.356235
R10411 n1_m1_480000_345600 n1_m1_484800_345600 5.356235
R10412 n1_m1_484800_345600 n1_m1_489600_345600 5.356235
R10413 n1_m1_489600_345600 n1_m1_494400_345600 5.356235
R10414 n1_m1_494400_345600 n1_m1_499200_345600 5.356235
R10415 n1_m1_499200_345600 n1_m1_504000_345600 5.356235
R10416 n1_m1_504000_345600 n1_m1_508000_345600 4.463529
R10417 n1_m1_508800_345600 n1_m1_508000_345600 0.892706
R10418 n1_m1_508800_345600 n1_m1_513600_345600 5.356235
R10419 n1_m1_513600_345600 n1_m1_518400_345600 5.356235
R10420 n1_m1_518400_345600 n1_m1_523200_345600 5.356235
R10421 n1_m1_523200_345600 n1_m1_528000_345600 5.356235
R10422 n1_m1_528000_345600 n1_m1_532800_345600 5.356235
R10423 n1_m1_532800_345600 n1_m1_536000_345600 3.570824
R10424 n1_m1_537600_345600 n1_m1_536000_345600 1.785412
R10425 n1_m1_537600_345600 n1_m1_542400_345600 5.356235
R10426 n1_m1_542400_345600 n1_m1_547200_345600 5.356235
R10427 n1_m1_547200_345600 n1_m1_552000_345600 5.356235
R10428 n1_m1_552000_345600 n1_m1_556800_345600 5.356235
R10429 n1_m1_556800_345600 n1_m1_561600_345600 5.356235
R10430 n1_m1_561600_345600 n1_m1_564000_345600 2.678118
R10431 n1_m1_566400_345600 n1_m1_564000_345600 2.678118
R10432 n1_m1_566400_345600 n1_m1_571200_345600 5.356235
R10433 n1_m1_571200_345600 n1_m1_576000_345600 5.356235
R10434 n1_m1_576000_345600 n1_m1_580800_345600 5.356235
R10435 n1_m1_580800_345600 n1_m1_585600_345600 5.356235
R10436 n1_m1_585600_345600 n1_m1_590400_345600 5.356235
R10437 n1_m1_590400_345600 n1_m1_592000_345600 1.785412
R10438 n1_m1_595200_345600 n1_m1_592000_345600 3.570824
R10439 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R10440 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R10441 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R10442 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R10443 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R10444 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R10445 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R10446 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R10447 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R10448 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R10449 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R10450 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R10451 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R10452 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R10453 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R10454 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R10455 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R10456 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R10457 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R10458 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R10459 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R10460 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R10461 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R10462 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R10463 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R10464 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R10465 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R10466 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R10467 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R10468 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R10469 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R10470 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R10471 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R10472 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R10473 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R10474 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R10475 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R10476 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R10477 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R10478 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R10479 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R10480 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R10481 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R10482 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R10483 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R10484 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R10485 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R10486 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R10487 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R10488 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R10489 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R10490 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R10491 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R10492 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R10493 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R10494 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R10495 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R10496 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R10497 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R10498 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R10499 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R10500 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R10501 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R10502 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R10503 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R10504 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R10505 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R10506 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R10507 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R10508 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R10509 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R10510 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R10511 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R10512 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R10513 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R10514 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R10515 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R10516 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R10517 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R10518 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R10519 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R10520 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R10521 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R10522 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R10523 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R10524 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R10525 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R10526 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R10527 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R10528 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R10529 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R10530 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R10531 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R10532 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R10533 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R10534 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R10535 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R10536 n1_m1_403200_350400 n1_m1_408000_350400 5.356235
R10537 n1_m1_408000_350400 n1_m1_412800_350400 5.356235
R10538 n1_m1_412800_350400 n1_m1_417600_350400 5.356235
R10539 n1_m1_417600_350400 n1_m1_422400_350400 5.356235
R10540 n1_m1_422400_350400 n1_m1_424000_350400 1.785412
R10541 n1_m1_427200_350400 n1_m1_424000_350400 3.570824
R10542 n1_m1_427200_350400 n1_m1_432000_350400 5.356235
R10543 n1_m1_432000_350400 n1_m1_436800_350400 5.356235
R10544 n1_m1_436800_350400 n1_m1_441600_350400 5.356235
R10545 n1_m1_441600_350400 n1_m1_446400_350400 5.356235
R10546 n1_m1_446400_350400 n1_m1_451200_350400 5.356235
R10547 n1_m1_451200_350400 n1_m1_452000_350400 0.892706
R10548 n1_m1_456000_350400 n1_m1_452000_350400 4.463529
R10549 n1_m1_456000_350400 n1_m1_460800_350400 5.356235
R10550 n1_m1_460800_350400 n1_m1_465600_350400 5.356235
R10551 n1_m1_465600_350400 n1_m1_470400_350400 5.356235
R10552 n1_m1_470400_350400 n1_m1_475200_350400 5.356235
R10553 n1_m1_475200_350400 n1_m1_480000_350400 5.356235
R10554 n1_m1_480000_350400 n1_m1_484800_350400 5.356235
R10555 n1_m1_484800_350400 n1_m1_489600_350400 5.356235
R10556 n1_m1_489600_350400 n1_m1_494400_350400 5.356235
R10557 n1_m1_494400_350400 n1_m1_499200_350400 5.356235
R10558 n1_m1_499200_350400 n1_m1_504000_350400 5.356235
R10559 n1_m1_504000_350400 n1_m1_508000_350400 4.463529
R10560 n1_m1_508800_350400 n1_m1_508000_350400 0.892706
R10561 n1_m1_508800_350400 n1_m1_513600_350400 5.356235
R10562 n1_m1_513600_350400 n1_m1_518400_350400 5.356235
R10563 n1_m1_518400_350400 n1_m1_523200_350400 5.356235
R10564 n1_m1_523200_350400 n1_m1_528000_350400 5.356235
R10565 n1_m1_528000_350400 n1_m1_532800_350400 5.356235
R10566 n1_m1_532800_350400 n1_m1_536000_350400 3.570824
R10567 n1_m1_537600_350400 n1_m1_536000_350400 1.785412
R10568 n1_m1_537600_350400 n1_m1_542400_350400 5.356235
R10569 n1_m1_542400_350400 n1_m1_547200_350400 5.356235
R10570 n1_m1_547200_350400 n1_m1_552000_350400 5.356235
R10571 n1_m1_552000_350400 n1_m1_556800_350400 5.356235
R10572 n1_m1_556800_350400 n1_m1_561600_350400 5.356235
R10573 n1_m1_561600_350400 n1_m1_564000_350400 2.678118
R10574 n1_m1_566400_350400 n1_m1_564000_350400 2.678118
R10575 n1_m1_566400_350400 n1_m1_571200_350400 5.356235
R10576 n1_m1_571200_350400 n1_m1_576000_350400 5.356235
R10577 n1_m1_576000_350400 n1_m1_580800_350400 5.356235
R10578 n1_m1_580800_350400 n1_m1_585600_350400 5.356235
R10579 n1_m1_585600_350400 n1_m1_590400_350400 5.356235
R10580 n1_m1_590400_350400 n1_m1_592000_350400 1.785412
R10581 n1_m1_595200_350400 n1_m1_592000_350400 3.570824
R10582 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R10583 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R10584 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R10585 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R10586 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R10587 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R10588 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R10589 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R10590 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R10591 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R10592 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R10593 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R10594 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R10595 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R10596 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R10597 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R10598 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R10599 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R10600 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R10601 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R10602 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R10603 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R10604 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R10605 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R10606 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R10607 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R10608 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R10609 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R10610 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R10611 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R10612 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R10613 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R10614 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R10615 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R10616 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R10617 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R10618 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R10619 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R10620 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R10621 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R10622 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R10623 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R10624 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R10625 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R10626 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R10627 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R10628 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R10629 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R10630 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R10631 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R10632 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R10633 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R10634 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R10635 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R10636 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R10637 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R10638 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R10639 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R10640 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R10641 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R10642 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R10643 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R10644 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R10645 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R10646 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R10647 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R10648 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R10649 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R10650 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R10651 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R10652 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R10653 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R10654 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R10655 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R10656 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R10657 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R10658 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R10659 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R10660 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R10661 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R10662 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R10663 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R10664 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R10665 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R10666 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R10667 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R10668 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R10669 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R10670 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R10671 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R10672 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R10673 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R10674 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R10675 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R10676 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R10677 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R10678 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R10679 n1_m1_403200_355200 n1_m1_408000_355200 5.356235
R10680 n1_m1_408000_355200 n1_m1_412800_355200 5.356235
R10681 n1_m1_412800_355200 n1_m1_417600_355200 5.356235
R10682 n1_m1_417600_355200 n1_m1_422400_355200 5.356235
R10683 n1_m1_422400_355200 n1_m1_424000_355200 1.785412
R10684 n1_m1_427200_355200 n1_m1_424000_355200 3.570824
R10685 n1_m1_427200_355200 n1_m1_432000_355200 5.356235
R10686 n1_m1_432000_355200 n1_m1_436800_355200 5.356235
R10687 n1_m1_436800_355200 n1_m1_441600_355200 5.356235
R10688 n1_m1_441600_355200 n1_m1_446400_355200 5.356235
R10689 n1_m1_446400_355200 n1_m1_451200_355200 5.356235
R10690 n1_m1_451200_355200 n1_m1_452000_355200 0.892706
R10691 n1_m1_456000_355200 n1_m1_452000_355200 4.463529
R10692 n1_m1_456000_355200 n1_m1_460800_355200 5.356235
R10693 n1_m1_460800_355200 n1_m1_465600_355200 5.356235
R10694 n1_m1_465600_355200 n1_m1_470400_355200 5.356235
R10695 n1_m1_470400_355200 n1_m1_475200_355200 5.356235
R10696 n1_m1_475200_355200 n1_m1_480000_355200 5.356235
R10697 n1_m1_480000_355200 n1_m1_484800_355200 5.356235
R10698 n1_m1_484800_355200 n1_m1_489600_355200 5.356235
R10699 n1_m1_489600_355200 n1_m1_494400_355200 5.356235
R10700 n1_m1_494400_355200 n1_m1_499200_355200 5.356235
R10701 n1_m1_499200_355200 n1_m1_504000_355200 5.356235
R10702 n1_m1_504000_355200 n1_m1_508000_355200 4.463529
R10703 n1_m1_508800_355200 n1_m1_508000_355200 0.892706
R10704 n1_m1_508800_355200 n1_m1_513600_355200 5.356235
R10705 n1_m1_513600_355200 n1_m1_518400_355200 5.356235
R10706 n1_m1_518400_355200 n1_m1_523200_355200 5.356235
R10707 n1_m1_523200_355200 n1_m1_528000_355200 5.356235
R10708 n1_m1_528000_355200 n1_m1_532800_355200 5.356235
R10709 n1_m1_532800_355200 n1_m1_536000_355200 3.570824
R10710 n1_m1_537600_355200 n1_m1_536000_355200 1.785412
R10711 n1_m1_537600_355200 n1_m1_542400_355200 5.356235
R10712 n1_m1_542400_355200 n1_m1_547200_355200 5.356235
R10713 n1_m1_547200_355200 n1_m1_552000_355200 5.356235
R10714 n1_m1_552000_355200 n1_m1_556800_355200 5.356235
R10715 n1_m1_556800_355200 n1_m1_561600_355200 5.356235
R10716 n1_m1_561600_355200 n1_m1_564000_355200 2.678118
R10717 n1_m1_566400_355200 n1_m1_564000_355200 2.678118
R10718 n1_m1_566400_355200 n1_m1_571200_355200 5.356235
R10719 n1_m1_571200_355200 n1_m1_576000_355200 5.356235
R10720 n1_m1_576000_355200 n1_m1_580800_355200 5.356235
R10721 n1_m1_580800_355200 n1_m1_585600_355200 5.356235
R10722 n1_m1_585600_355200 n1_m1_590400_355200 5.356235
R10723 n1_m1_590400_355200 n1_m1_592000_355200 1.785412
R10724 n1_m1_595200_355200 n1_m1_592000_355200 3.570824
R10725 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R10726 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R10727 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R10728 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R10729 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R10730 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R10731 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R10732 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R10733 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R10734 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R10735 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R10736 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R10737 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R10738 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R10739 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R10740 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R10741 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R10742 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R10743 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R10744 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R10745 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R10746 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R10747 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R10748 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R10749 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R10750 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R10751 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R10752 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R10753 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R10754 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R10755 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R10756 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R10757 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R10758 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R10759 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R10760 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R10761 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R10762 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R10763 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R10764 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R10765 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R10766 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R10767 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R10768 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R10769 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R10770 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R10771 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R10772 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R10773 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R10774 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R10775 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R10776 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R10777 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R10778 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R10779 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R10780 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R10781 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R10782 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R10783 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R10784 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R10785 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R10786 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R10787 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R10788 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R10789 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R10790 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R10791 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R10792 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R10793 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R10794 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R10795 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R10796 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R10797 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R10798 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R10799 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R10800 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R10801 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R10802 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R10803 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R10804 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R10805 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R10806 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R10807 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R10808 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R10809 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R10810 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R10811 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R10812 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R10813 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R10814 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R10815 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R10816 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R10817 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R10818 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R10819 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R10820 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R10821 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R10822 n1_m1_403200_360000 n1_m1_408000_360000 5.356235
R10823 n1_m1_408000_360000 n1_m1_412800_360000 5.356235
R10824 n1_m1_412800_360000 n1_m1_417600_360000 5.356235
R10825 n1_m1_417600_360000 n1_m1_422400_360000 5.356235
R10826 n1_m1_422400_360000 n1_m1_424000_360000 1.785412
R10827 n1_m1_427200_360000 n1_m1_424000_360000 3.570824
R10828 n1_m1_427200_360000 n1_m1_432000_360000 5.356235
R10829 n1_m1_432000_360000 n1_m1_436800_360000 5.356235
R10830 n1_m1_436800_360000 n1_m1_441600_360000 5.356235
R10831 n1_m1_441600_360000 n1_m1_446400_360000 5.356235
R10832 n1_m1_446400_360000 n1_m1_451200_360000 5.356235
R10833 n1_m1_451200_360000 n1_m1_452000_360000 0.892706
R10834 n1_m1_456000_360000 n1_m1_452000_360000 4.463529
R10835 n1_m1_456000_360000 n1_m1_460800_360000 5.356235
R10836 n1_m1_460800_360000 n1_m1_465600_360000 5.356235
R10837 n1_m1_465600_360000 n1_m1_470400_360000 5.356235
R10838 n1_m1_470400_360000 n1_m1_475200_360000 5.356235
R10839 n1_m1_475200_360000 n1_m1_480000_360000 5.356235
R10840 n1_m1_480000_360000 n1_m1_484800_360000 5.356235
R10841 n1_m1_484800_360000 n1_m1_489600_360000 5.356235
R10842 n1_m1_489600_360000 n1_m1_494400_360000 5.356235
R10843 n1_m1_494400_360000 n1_m1_499200_360000 5.356235
R10844 n1_m1_499200_360000 n1_m1_504000_360000 5.356235
R10845 n1_m1_504000_360000 n1_m1_508000_360000 4.463529
R10846 n1_m1_508800_360000 n1_m1_508000_360000 0.892706
R10847 n1_m1_508800_360000 n1_m1_513600_360000 5.356235
R10848 n1_m1_513600_360000 n1_m1_518400_360000 5.356235
R10849 n1_m1_518400_360000 n1_m1_523200_360000 5.356235
R10850 n1_m1_523200_360000 n1_m1_528000_360000 5.356235
R10851 n1_m1_528000_360000 n1_m1_532800_360000 5.356235
R10852 n1_m1_532800_360000 n1_m1_536000_360000 3.570824
R10853 n1_m1_537600_360000 n1_m1_536000_360000 1.785412
R10854 n1_m1_537600_360000 n1_m1_542400_360000 5.356235
R10855 n1_m1_542400_360000 n1_m1_547200_360000 5.356235
R10856 n1_m1_547200_360000 n1_m1_552000_360000 5.356235
R10857 n1_m1_552000_360000 n1_m1_556800_360000 5.356235
R10858 n1_m1_556800_360000 n1_m1_561600_360000 5.356235
R10859 n1_m1_561600_360000 n1_m1_564000_360000 2.678118
R10860 n1_m1_566400_360000 n1_m1_564000_360000 2.678118
R10861 n1_m1_566400_360000 n1_m1_571200_360000 5.356235
R10862 n1_m1_571200_360000 n1_m1_576000_360000 5.356235
R10863 n1_m1_576000_360000 n1_m1_580800_360000 5.356235
R10864 n1_m1_580800_360000 n1_m1_585600_360000 5.356235
R10865 n1_m1_585600_360000 n1_m1_590400_360000 5.356235
R10866 n1_m1_590400_360000 n1_m1_592000_360000 1.785412
R10867 n1_m1_595200_360000 n1_m1_592000_360000 3.570824
R10868 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R10869 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R10870 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R10871 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R10872 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R10873 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R10874 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R10875 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R10876 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R10877 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R10878 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R10879 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R10880 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R10881 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R10882 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R10883 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R10884 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R10885 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R10886 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R10887 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R10888 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R10889 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R10890 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R10891 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R10892 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R10893 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R10894 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R10895 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R10896 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R10897 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R10898 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R10899 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R10900 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R10901 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R10902 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R10903 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R10904 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R10905 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R10906 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R10907 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R10908 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R10909 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R10910 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R10911 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R10912 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R10913 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R10914 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R10915 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R10916 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R10917 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R10918 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R10919 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R10920 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R10921 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R10922 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R10923 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R10924 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R10925 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R10926 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R10927 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R10928 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R10929 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R10930 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R10931 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R10932 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R10933 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R10934 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R10935 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R10936 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R10937 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R10938 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R10939 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R10940 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R10941 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R10942 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R10943 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R10944 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R10945 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R10946 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R10947 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R10948 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R10949 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R10950 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R10951 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R10952 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R10953 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R10954 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R10955 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R10956 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R10957 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R10958 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R10959 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R10960 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R10961 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R10962 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R10963 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R10964 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R10965 n1_m1_403200_364800 n1_m1_408000_364800 5.356235
R10966 n1_m1_408000_364800 n1_m1_412800_364800 5.356235
R10967 n1_m1_412800_364800 n1_m1_417600_364800 5.356235
R10968 n1_m1_417600_364800 n1_m1_422400_364800 5.356235
R10969 n1_m1_422400_364800 n1_m1_424000_364800 1.785412
R10970 n1_m1_427200_364800 n1_m1_424000_364800 3.570824
R10971 n1_m1_427200_364800 n1_m1_432000_364800 5.356235
R10972 n1_m1_432000_364800 n1_m1_436800_364800 5.356235
R10973 n1_m1_436800_364800 n1_m1_441600_364800 5.356235
R10974 n1_m1_441600_364800 n1_m1_446400_364800 5.356235
R10975 n1_m1_446400_364800 n1_m1_451200_364800 5.356235
R10976 n1_m1_451200_364800 n1_m1_452000_364800 0.892706
R10977 n1_m1_456000_364800 n1_m1_452000_364800 4.463529
R10978 n1_m1_456000_364800 n1_m1_460800_364800 5.356235
R10979 n1_m1_460800_364800 n1_m1_465600_364800 5.356235
R10980 n1_m1_465600_364800 n1_m1_470400_364800 5.356235
R10981 n1_m1_470400_364800 n1_m1_475200_364800 5.356235
R10982 n1_m1_475200_364800 n1_m1_480000_364800 5.356235
R10983 n1_m1_480000_364800 n1_m1_484800_364800 5.356235
R10984 n1_m1_484800_364800 n1_m1_489600_364800 5.356235
R10985 n1_m1_489600_364800 n1_m1_494400_364800 5.356235
R10986 n1_m1_494400_364800 n1_m1_499200_364800 5.356235
R10987 n1_m1_499200_364800 n1_m1_504000_364800 5.356235
R10988 n1_m1_504000_364800 n1_m1_508000_364800 4.463529
R10989 n1_m1_508800_364800 n1_m1_508000_364800 0.892706
R10990 n1_m1_508800_364800 n1_m1_513600_364800 5.356235
R10991 n1_m1_513600_364800 n1_m1_518400_364800 5.356235
R10992 n1_m1_518400_364800 n1_m1_523200_364800 5.356235
R10993 n1_m1_523200_364800 n1_m1_528000_364800 5.356235
R10994 n1_m1_528000_364800 n1_m1_532800_364800 5.356235
R10995 n1_m1_532800_364800 n1_m1_536000_364800 3.570824
R10996 n1_m1_537600_364800 n1_m1_536000_364800 1.785412
R10997 n1_m1_537600_364800 n1_m1_542400_364800 5.356235
R10998 n1_m1_542400_364800 n1_m1_547200_364800 5.356235
R10999 n1_m1_547200_364800 n1_m1_552000_364800 5.356235
R11000 n1_m1_552000_364800 n1_m1_556800_364800 5.356235
R11001 n1_m1_556800_364800 n1_m1_561600_364800 5.356235
R11002 n1_m1_561600_364800 n1_m1_564000_364800 2.678118
R11003 n1_m1_566400_364800 n1_m1_564000_364800 2.678118
R11004 n1_m1_566400_364800 n1_m1_571200_364800 5.356235
R11005 n1_m1_571200_364800 n1_m1_576000_364800 5.356235
R11006 n1_m1_576000_364800 n1_m1_580800_364800 5.356235
R11007 n1_m1_580800_364800 n1_m1_585600_364800 5.356235
R11008 n1_m1_585600_364800 n1_m1_590400_364800 5.356235
R11009 n1_m1_590400_364800 n1_m1_592000_364800 1.785412
R11010 n1_m1_595200_364800 n1_m1_592000_364800 3.570824
R11011 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R11012 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R11013 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R11014 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R11015 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R11016 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R11017 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R11018 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R11019 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R11020 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R11021 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R11022 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R11023 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R11024 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R11025 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R11026 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R11027 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R11028 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R11029 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R11030 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R11031 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R11032 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R11033 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R11034 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R11035 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R11036 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R11037 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R11038 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R11039 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R11040 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R11041 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R11042 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R11043 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R11044 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R11045 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R11046 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R11047 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R11048 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R11049 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R11050 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R11051 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R11052 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R11053 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R11054 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R11055 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R11056 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R11057 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R11058 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R11059 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R11060 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R11061 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R11062 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R11063 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R11064 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R11065 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R11066 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R11067 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R11068 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R11069 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R11070 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R11071 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R11072 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R11073 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R11074 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R11075 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R11076 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R11077 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R11078 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R11079 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R11080 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R11081 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R11082 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R11083 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R11084 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R11085 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R11086 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R11087 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R11088 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R11089 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R11090 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R11091 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R11092 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R11093 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R11094 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R11095 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R11096 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R11097 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R11098 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R11099 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R11100 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R11101 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R11102 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R11103 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R11104 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R11105 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R11106 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R11107 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R11108 n1_m1_403200_369600 n1_m1_408000_369600 5.356235
R11109 n1_m1_408000_369600 n1_m1_412800_369600 5.356235
R11110 n1_m1_412800_369600 n1_m1_417600_369600 5.356235
R11111 n1_m1_417600_369600 n1_m1_422400_369600 5.356235
R11112 n1_m1_422400_369600 n1_m1_424000_369600 1.785412
R11113 n1_m1_427200_369600 n1_m1_424000_369600 3.570824
R11114 n1_m1_427200_369600 n1_m1_432000_369600 5.356235
R11115 n1_m1_432000_369600 n1_m1_436800_369600 5.356235
R11116 n1_m1_436800_369600 n1_m1_441600_369600 5.356235
R11117 n1_m1_441600_369600 n1_m1_446400_369600 5.356235
R11118 n1_m1_446400_369600 n1_m1_451200_369600 5.356235
R11119 n1_m1_451200_369600 n1_m1_452000_369600 0.892706
R11120 n1_m1_456000_369600 n1_m1_452000_369600 4.463529
R11121 n1_m1_456000_369600 n1_m1_460800_369600 5.356235
R11122 n1_m1_460800_369600 n1_m1_465600_369600 5.356235
R11123 n1_m1_465600_369600 n1_m1_470400_369600 5.356235
R11124 n1_m1_470400_369600 n1_m1_475200_369600 5.356235
R11125 n1_m1_475200_369600 n1_m1_480000_369600 5.356235
R11126 n1_m1_480000_369600 n1_m1_484800_369600 5.356235
R11127 n1_m1_484800_369600 n1_m1_489600_369600 5.356235
R11128 n1_m1_489600_369600 n1_m1_494400_369600 5.356235
R11129 n1_m1_494400_369600 n1_m1_499200_369600 5.356235
R11130 n1_m1_499200_369600 n1_m1_504000_369600 5.356235
R11131 n1_m1_504000_369600 n1_m1_508000_369600 4.463529
R11132 n1_m1_508800_369600 n1_m1_508000_369600 0.892706
R11133 n1_m1_508800_369600 n1_m1_513600_369600 5.356235
R11134 n1_m1_513600_369600 n1_m1_518400_369600 5.356235
R11135 n1_m1_518400_369600 n1_m1_523200_369600 5.356235
R11136 n1_m1_523200_369600 n1_m1_528000_369600 5.356235
R11137 n1_m1_528000_369600 n1_m1_532800_369600 5.356235
R11138 n1_m1_532800_369600 n1_m1_536000_369600 3.570824
R11139 n1_m1_537600_369600 n1_m1_536000_369600 1.785412
R11140 n1_m1_537600_369600 n1_m1_542400_369600 5.356235
R11141 n1_m1_542400_369600 n1_m1_547200_369600 5.356235
R11142 n1_m1_547200_369600 n1_m1_552000_369600 5.356235
R11143 n1_m1_552000_369600 n1_m1_556800_369600 5.356235
R11144 n1_m1_556800_369600 n1_m1_561600_369600 5.356235
R11145 n1_m1_561600_369600 n1_m1_564000_369600 2.678118
R11146 n1_m1_566400_369600 n1_m1_564000_369600 2.678118
R11147 n1_m1_566400_369600 n1_m1_571200_369600 5.356235
R11148 n1_m1_571200_369600 n1_m1_576000_369600 5.356235
R11149 n1_m1_576000_369600 n1_m1_580800_369600 5.356235
R11150 n1_m1_580800_369600 n1_m1_585600_369600 5.356235
R11151 n1_m1_585600_369600 n1_m1_590400_369600 5.356235
R11152 n1_m1_590400_369600 n1_m1_592000_369600 1.785412
R11153 n1_m1_595200_369600 n1_m1_592000_369600 3.570824
R11154 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R11155 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R11156 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R11157 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R11158 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R11159 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R11160 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R11161 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R11162 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R11163 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R11164 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R11165 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R11166 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R11167 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R11168 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R11169 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R11170 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R11171 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R11172 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R11173 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R11174 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R11175 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R11176 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R11177 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R11178 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R11179 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R11180 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R11181 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R11182 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R11183 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R11184 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R11185 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R11186 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R11187 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R11188 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R11189 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R11190 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R11191 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R11192 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R11193 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R11194 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R11195 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R11196 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R11197 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R11198 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R11199 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R11200 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R11201 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R11202 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R11203 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R11204 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R11205 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R11206 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R11207 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R11208 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R11209 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R11210 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R11211 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R11212 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R11213 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R11214 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R11215 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R11216 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R11217 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R11218 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R11219 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R11220 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R11221 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R11222 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R11223 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R11224 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R11225 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R11226 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R11227 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R11228 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R11229 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R11230 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R11231 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R11232 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R11233 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R11234 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R11235 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R11236 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R11237 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R11238 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R11239 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R11240 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R11241 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R11242 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R11243 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R11244 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R11245 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R11246 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R11247 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R11248 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R11249 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R11250 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R11251 n1_m1_403200_374400 n1_m1_408000_374400 5.356235
R11252 n1_m1_408000_374400 n1_m1_412800_374400 5.356235
R11253 n1_m1_412800_374400 n1_m1_417600_374400 5.356235
R11254 n1_m1_417600_374400 n1_m1_422400_374400 5.356235
R11255 n1_m1_422400_374400 n1_m1_424000_374400 1.785412
R11256 n1_m1_427200_374400 n1_m1_424000_374400 3.570824
R11257 n1_m1_427200_374400 n1_m1_432000_374400 5.356235
R11258 n1_m1_432000_374400 n1_m1_436800_374400 5.356235
R11259 n1_m1_436800_374400 n1_m1_441600_374400 5.356235
R11260 n1_m1_441600_374400 n1_m1_446400_374400 5.356235
R11261 n1_m1_446400_374400 n1_m1_451200_374400 5.356235
R11262 n1_m1_451200_374400 n1_m1_452000_374400 0.892706
R11263 n1_m1_456000_374400 n1_m1_452000_374400 4.463529
R11264 n1_m1_456000_374400 n1_m1_460800_374400 5.356235
R11265 n1_m1_460800_374400 n1_m1_465600_374400 5.356235
R11266 n1_m1_465600_374400 n1_m1_470400_374400 5.356235
R11267 n1_m1_470400_374400 n1_m1_475200_374400 5.356235
R11268 n1_m1_475200_374400 n1_m1_480000_374400 5.356235
R11269 n1_m1_480000_374400 n1_m1_484800_374400 5.356235
R11270 n1_m1_484800_374400 n1_m1_489600_374400 5.356235
R11271 n1_m1_489600_374400 n1_m1_494400_374400 5.356235
R11272 n1_m1_494400_374400 n1_m1_499200_374400 5.356235
R11273 n1_m1_499200_374400 n1_m1_504000_374400 5.356235
R11274 n1_m1_504000_374400 n1_m1_508000_374400 4.463529
R11275 n1_m1_508800_374400 n1_m1_508000_374400 0.892706
R11276 n1_m1_508800_374400 n1_m1_513600_374400 5.356235
R11277 n1_m1_513600_374400 n1_m1_518400_374400 5.356235
R11278 n1_m1_518400_374400 n1_m1_523200_374400 5.356235
R11279 n1_m1_523200_374400 n1_m1_528000_374400 5.356235
R11280 n1_m1_528000_374400 n1_m1_532800_374400 5.356235
R11281 n1_m1_532800_374400 n1_m1_536000_374400 3.570824
R11282 n1_m1_537600_374400 n1_m1_536000_374400 1.785412
R11283 n1_m1_537600_374400 n1_m1_542400_374400 5.356235
R11284 n1_m1_542400_374400 n1_m1_547200_374400 5.356235
R11285 n1_m1_547200_374400 n1_m1_552000_374400 5.356235
R11286 n1_m1_552000_374400 n1_m1_556800_374400 5.356235
R11287 n1_m1_556800_374400 n1_m1_561600_374400 5.356235
R11288 n1_m1_561600_374400 n1_m1_564000_374400 2.678118
R11289 n1_m1_566400_374400 n1_m1_564000_374400 2.678118
R11290 n1_m1_566400_374400 n1_m1_571200_374400 5.356235
R11291 n1_m1_571200_374400 n1_m1_576000_374400 5.356235
R11292 n1_m1_576000_374400 n1_m1_580800_374400 5.356235
R11293 n1_m1_580800_374400 n1_m1_585600_374400 5.356235
R11294 n1_m1_585600_374400 n1_m1_590400_374400 5.356235
R11295 n1_m1_590400_374400 n1_m1_592000_374400 1.785412
R11296 n1_m1_595200_374400 n1_m1_592000_374400 3.570824
R11297 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R11298 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R11299 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R11300 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R11301 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R11302 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R11303 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R11304 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R11305 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R11306 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R11307 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R11308 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R11309 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R11310 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R11311 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R11312 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R11313 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R11314 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R11315 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R11316 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R11317 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R11318 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R11319 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R11320 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R11321 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R11322 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R11323 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R11324 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R11325 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R11326 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R11327 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R11328 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R11329 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R11330 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R11331 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R11332 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R11333 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R11334 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R11335 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R11336 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R11337 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R11338 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R11339 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R11340 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R11341 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R11342 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R11343 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R11344 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R11345 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R11346 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R11347 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R11348 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R11349 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R11350 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R11351 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R11352 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R11353 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R11354 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R11355 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R11356 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R11357 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R11358 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R11359 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R11360 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R11361 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R11362 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R11363 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R11364 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R11365 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R11366 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R11367 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R11368 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R11369 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R11370 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R11371 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R11372 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R11373 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R11374 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R11375 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R11376 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R11377 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R11378 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R11379 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R11380 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R11381 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R11382 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R11383 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R11384 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R11385 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R11386 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R11387 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R11388 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R11389 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R11390 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R11391 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R11392 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R11393 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R11394 n1_m1_403200_379200 n1_m1_408000_379200 5.356235
R11395 n1_m1_408000_379200 n1_m1_412800_379200 5.356235
R11396 n1_m1_412800_379200 n1_m1_417600_379200 5.356235
R11397 n1_m1_417600_379200 n1_m1_422400_379200 5.356235
R11398 n1_m1_422400_379200 n1_m1_424000_379200 1.785412
R11399 n1_m1_427200_379200 n1_m1_424000_379200 3.570824
R11400 n1_m1_427200_379200 n1_m1_432000_379200 5.356235
R11401 n1_m1_432000_379200 n1_m1_436800_379200 5.356235
R11402 n1_m1_436800_379200 n1_m1_441600_379200 5.356235
R11403 n1_m1_441600_379200 n1_m1_446400_379200 5.356235
R11404 n1_m1_446400_379200 n1_m1_451200_379200 5.356235
R11405 n1_m1_451200_379200 n1_m1_452000_379200 0.892706
R11406 n1_m1_456000_379200 n1_m1_452000_379200 4.463529
R11407 n1_m1_456000_379200 n1_m1_460800_379200 5.356235
R11408 n1_m1_460800_379200 n1_m1_465600_379200 5.356235
R11409 n1_m1_465600_379200 n1_m1_470400_379200 5.356235
R11410 n1_m1_470400_379200 n1_m1_475200_379200 5.356235
R11411 n1_m1_475200_379200 n1_m1_480000_379200 5.356235
R11412 n1_m1_480000_379200 n1_m1_484800_379200 5.356235
R11413 n1_m1_484800_379200 n1_m1_489600_379200 5.356235
R11414 n1_m1_489600_379200 n1_m1_494400_379200 5.356235
R11415 n1_m1_494400_379200 n1_m1_499200_379200 5.356235
R11416 n1_m1_499200_379200 n1_m1_504000_379200 5.356235
R11417 n1_m1_504000_379200 n1_m1_508000_379200 4.463529
R11418 n1_m1_508800_379200 n1_m1_508000_379200 0.892706
R11419 n1_m1_508800_379200 n1_m1_513600_379200 5.356235
R11420 n1_m1_513600_379200 n1_m1_518400_379200 5.356235
R11421 n1_m1_518400_379200 n1_m1_523200_379200 5.356235
R11422 n1_m1_523200_379200 n1_m1_528000_379200 5.356235
R11423 n1_m1_528000_379200 n1_m1_532800_379200 5.356235
R11424 n1_m1_532800_379200 n1_m1_536000_379200 3.570824
R11425 n1_m1_537600_379200 n1_m1_536000_379200 1.785412
R11426 n1_m1_537600_379200 n1_m1_542400_379200 5.356235
R11427 n1_m1_542400_379200 n1_m1_547200_379200 5.356235
R11428 n1_m1_547200_379200 n1_m1_552000_379200 5.356235
R11429 n1_m1_552000_379200 n1_m1_556800_379200 5.356235
R11430 n1_m1_556800_379200 n1_m1_561600_379200 5.356235
R11431 n1_m1_561600_379200 n1_m1_564000_379200 2.678118
R11432 n1_m1_566400_379200 n1_m1_564000_379200 2.678118
R11433 n1_m1_566400_379200 n1_m1_571200_379200 5.356235
R11434 n1_m1_571200_379200 n1_m1_576000_379200 5.356235
R11435 n1_m1_576000_379200 n1_m1_580800_379200 5.356235
R11436 n1_m1_580800_379200 n1_m1_585600_379200 5.356235
R11437 n1_m1_585600_379200 n1_m1_590400_379200 5.356235
R11438 n1_m1_590400_379200 n1_m1_592000_379200 1.785412
R11439 n1_m1_595200_379200 n1_m1_592000_379200 3.570824
R11440 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R11441 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R11442 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R11443 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R11444 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R11445 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R11446 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R11447 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R11448 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R11449 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R11450 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R11451 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R11452 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R11453 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R11454 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R11455 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R11456 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R11457 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R11458 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R11459 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R11460 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R11461 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R11462 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R11463 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R11464 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R11465 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R11466 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R11467 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R11468 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R11469 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R11470 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R11471 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R11472 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R11473 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R11474 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R11475 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R11476 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R11477 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R11478 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R11479 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R11480 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R11481 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R11482 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R11483 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R11484 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R11485 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R11486 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R11487 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R11488 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R11489 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R11490 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R11491 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R11492 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R11493 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R11494 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R11495 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R11496 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R11497 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R11498 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R11499 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R11500 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R11501 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R11502 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R11503 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R11504 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R11505 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R11506 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R11507 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R11508 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R11509 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R11510 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R11511 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R11512 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R11513 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R11514 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R11515 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R11516 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R11517 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R11518 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R11519 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R11520 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R11521 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R11522 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R11523 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R11524 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R11525 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R11526 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R11527 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R11528 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R11529 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R11530 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R11531 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R11532 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R11533 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R11534 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R11535 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R11536 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R11537 n1_m1_403200_384000 n1_m1_408000_384000 5.356235
R11538 n1_m1_408000_384000 n1_m1_412800_384000 5.356235
R11539 n1_m1_412800_384000 n1_m1_417600_384000 5.356235
R11540 n1_m1_417600_384000 n1_m1_422400_384000 5.356235
R11541 n1_m1_422400_384000 n1_m1_424000_384000 1.785412
R11542 n1_m1_427200_384000 n1_m1_424000_384000 3.570824
R11543 n1_m1_427200_384000 n1_m1_432000_384000 5.356235
R11544 n1_m1_432000_384000 n1_m1_436800_384000 5.356235
R11545 n1_m1_436800_384000 n1_m1_441600_384000 5.356235
R11546 n1_m1_441600_384000 n1_m1_446400_384000 5.356235
R11547 n1_m1_446400_384000 n1_m1_451200_384000 5.356235
R11548 n1_m1_451200_384000 n1_m1_452000_384000 0.892706
R11549 n1_m1_456000_384000 n1_m1_452000_384000 4.463529
R11550 n1_m1_456000_384000 n1_m1_460800_384000 5.356235
R11551 n1_m1_460800_384000 n1_m1_465600_384000 5.356235
R11552 n1_m1_465600_384000 n1_m1_470400_384000 5.356235
R11553 n1_m1_470400_384000 n1_m1_475200_384000 5.356235
R11554 n1_m1_475200_384000 n1_m1_480000_384000 5.356235
R11555 n1_m1_480000_384000 n1_m1_484800_384000 5.356235
R11556 n1_m1_484800_384000 n1_m1_489600_384000 5.356235
R11557 n1_m1_489600_384000 n1_m1_494400_384000 5.356235
R11558 n1_m1_494400_384000 n1_m1_499200_384000 5.356235
R11559 n1_m1_499200_384000 n1_m1_504000_384000 5.356235
R11560 n1_m1_504000_384000 n1_m1_508000_384000 4.463529
R11561 n1_m1_508800_384000 n1_m1_508000_384000 0.892706
R11562 n1_m1_508800_384000 n1_m1_513600_384000 5.356235
R11563 n1_m1_513600_384000 n1_m1_518400_384000 5.356235
R11564 n1_m1_518400_384000 n1_m1_523200_384000 5.356235
R11565 n1_m1_523200_384000 n1_m1_528000_384000 5.356235
R11566 n1_m1_528000_384000 n1_m1_532800_384000 5.356235
R11567 n1_m1_532800_384000 n1_m1_536000_384000 3.570824
R11568 n1_m1_537600_384000 n1_m1_536000_384000 1.785412
R11569 n1_m1_537600_384000 n1_m1_542400_384000 5.356235
R11570 n1_m1_542400_384000 n1_m1_547200_384000 5.356235
R11571 n1_m1_547200_384000 n1_m1_552000_384000 5.356235
R11572 n1_m1_552000_384000 n1_m1_556800_384000 5.356235
R11573 n1_m1_556800_384000 n1_m1_561600_384000 5.356235
R11574 n1_m1_561600_384000 n1_m1_564000_384000 2.678118
R11575 n1_m1_566400_384000 n1_m1_564000_384000 2.678118
R11576 n1_m1_566400_384000 n1_m1_571200_384000 5.356235
R11577 n1_m1_571200_384000 n1_m1_576000_384000 5.356235
R11578 n1_m1_576000_384000 n1_m1_580800_384000 5.356235
R11579 n1_m1_580800_384000 n1_m1_585600_384000 5.356235
R11580 n1_m1_585600_384000 n1_m1_590400_384000 5.356235
R11581 n1_m1_590400_384000 n1_m1_592000_384000 1.785412
R11582 n1_m1_595200_384000 n1_m1_592000_384000 3.570824
R11583 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R11584 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R11585 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R11586 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R11587 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R11588 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R11589 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R11590 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R11591 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R11592 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R11593 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R11594 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R11595 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R11596 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R11597 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R11598 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R11599 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R11600 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R11601 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R11602 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R11603 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R11604 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R11605 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R11606 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R11607 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R11608 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R11609 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R11610 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R11611 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R11612 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R11613 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R11614 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R11615 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R11616 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R11617 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R11618 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R11619 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R11620 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R11621 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R11622 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R11623 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R11624 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R11625 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R11626 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R11627 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R11628 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R11629 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R11630 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R11631 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R11632 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R11633 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R11634 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R11635 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R11636 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R11637 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R11638 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R11639 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R11640 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R11641 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R11642 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R11643 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R11644 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R11645 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R11646 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R11647 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R11648 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R11649 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R11650 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R11651 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R11652 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R11653 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R11654 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R11655 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R11656 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R11657 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R11658 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R11659 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R11660 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R11661 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R11662 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R11663 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R11664 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R11665 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R11666 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R11667 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R11668 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R11669 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R11670 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R11671 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R11672 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R11673 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R11674 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R11675 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R11676 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R11677 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R11678 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R11679 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R11680 n1_m1_403200_388800 n1_m1_408000_388800 5.356235
R11681 n1_m1_408000_388800 n1_m1_412800_388800 5.356235
R11682 n1_m1_412800_388800 n1_m1_417600_388800 5.356235
R11683 n1_m1_417600_388800 n1_m1_422400_388800 5.356235
R11684 n1_m1_422400_388800 n1_m1_424000_388800 1.785412
R11685 n1_m1_427200_388800 n1_m1_424000_388800 3.570824
R11686 n1_m1_427200_388800 n1_m1_432000_388800 5.356235
R11687 n1_m1_432000_388800 n1_m1_436800_388800 5.356235
R11688 n1_m1_436800_388800 n1_m1_441600_388800 5.356235
R11689 n1_m1_441600_388800 n1_m1_446400_388800 5.356235
R11690 n1_m1_446400_388800 n1_m1_451200_388800 5.356235
R11691 n1_m1_451200_388800 n1_m1_452000_388800 0.892706
R11692 n1_m1_456000_388800 n1_m1_452000_388800 4.463529
R11693 n1_m1_456000_388800 n1_m1_460800_388800 5.356235
R11694 n1_m1_460800_388800 n1_m1_465600_388800 5.356235
R11695 n1_m1_465600_388800 n1_m1_470400_388800 5.356235
R11696 n1_m1_470400_388800 n1_m1_475200_388800 5.356235
R11697 n1_m1_475200_388800 n1_m1_480000_388800 5.356235
R11698 n1_m1_480000_388800 n1_m1_484800_388800 5.356235
R11699 n1_m1_484800_388800 n1_m1_489600_388800 5.356235
R11700 n1_m1_489600_388800 n1_m1_494400_388800 5.356235
R11701 n1_m1_494400_388800 n1_m1_499200_388800 5.356235
R11702 n1_m1_499200_388800 n1_m1_504000_388800 5.356235
R11703 n1_m1_504000_388800 n1_m1_508000_388800 4.463529
R11704 n1_m1_508800_388800 n1_m1_508000_388800 0.892706
R11705 n1_m1_508800_388800 n1_m1_513600_388800 5.356235
R11706 n1_m1_513600_388800 n1_m1_518400_388800 5.356235
R11707 n1_m1_518400_388800 n1_m1_523200_388800 5.356235
R11708 n1_m1_523200_388800 n1_m1_528000_388800 5.356235
R11709 n1_m1_528000_388800 n1_m1_532800_388800 5.356235
R11710 n1_m1_532800_388800 n1_m1_536000_388800 3.570824
R11711 n1_m1_537600_388800 n1_m1_536000_388800 1.785412
R11712 n1_m1_537600_388800 n1_m1_542400_388800 5.356235
R11713 n1_m1_542400_388800 n1_m1_547200_388800 5.356235
R11714 n1_m1_547200_388800 n1_m1_552000_388800 5.356235
R11715 n1_m1_552000_388800 n1_m1_556800_388800 5.356235
R11716 n1_m1_556800_388800 n1_m1_561600_388800 5.356235
R11717 n1_m1_561600_388800 n1_m1_564000_388800 2.678118
R11718 n1_m1_566400_388800 n1_m1_564000_388800 2.678118
R11719 n1_m1_566400_388800 n1_m1_571200_388800 5.356235
R11720 n1_m1_571200_388800 n1_m1_576000_388800 5.356235
R11721 n1_m1_576000_388800 n1_m1_580800_388800 5.356235
R11722 n1_m1_580800_388800 n1_m1_585600_388800 5.356235
R11723 n1_m1_585600_388800 n1_m1_590400_388800 5.356235
R11724 n1_m1_590400_388800 n1_m1_592000_388800 1.785412
R11725 n1_m1_595200_388800 n1_m1_592000_388800 3.570824
R11726 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R11727 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R11728 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R11729 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R11730 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R11731 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R11732 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R11733 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R11734 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R11735 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R11736 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R11737 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R11738 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R11739 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R11740 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R11741 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R11742 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R11743 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R11744 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R11745 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R11746 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R11747 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R11748 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R11749 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R11750 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R11751 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R11752 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R11753 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R11754 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R11755 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R11756 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R11757 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R11758 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R11759 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R11760 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R11761 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R11762 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R11763 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R11764 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R11765 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R11766 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R11767 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R11768 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R11769 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R11770 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R11771 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R11772 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R11773 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R11774 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R11775 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R11776 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R11777 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R11778 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R11779 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R11780 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R11781 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R11782 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R11783 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R11784 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R11785 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R11786 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R11787 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R11788 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R11789 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R11790 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R11791 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R11792 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R11793 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R11794 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R11795 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R11796 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R11797 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R11798 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R11799 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R11800 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R11801 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R11802 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R11803 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R11804 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R11805 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R11806 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R11807 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R11808 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R11809 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R11810 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R11811 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R11812 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R11813 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R11814 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R11815 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R11816 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R11817 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R11818 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R11819 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R11820 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R11821 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R11822 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R11823 n1_m1_403200_393600 n1_m1_408000_393600 5.356235
R11824 n1_m1_408000_393600 n1_m1_412800_393600 5.356235
R11825 n1_m1_412800_393600 n1_m1_417600_393600 5.356235
R11826 n1_m1_417600_393600 n1_m1_422400_393600 5.356235
R11827 n1_m1_422400_393600 n1_m1_424000_393600 1.785412
R11828 n1_m1_427200_393600 n1_m1_424000_393600 3.570824
R11829 n1_m1_427200_393600 n1_m1_432000_393600 5.356235
R11830 n1_m1_432000_393600 n1_m1_436800_393600 5.356235
R11831 n1_m1_436800_393600 n1_m1_441600_393600 5.356235
R11832 n1_m1_441600_393600 n1_m1_446400_393600 5.356235
R11833 n1_m1_446400_393600 n1_m1_451200_393600 5.356235
R11834 n1_m1_451200_393600 n1_m1_452000_393600 0.892706
R11835 n1_m1_456000_393600 n1_m1_452000_393600 4.463529
R11836 n1_m1_456000_393600 n1_m1_460800_393600 5.356235
R11837 n1_m1_460800_393600 n1_m1_465600_393600 5.356235
R11838 n1_m1_465600_393600 n1_m1_470400_393600 5.356235
R11839 n1_m1_470400_393600 n1_m1_475200_393600 5.356235
R11840 n1_m1_475200_393600 n1_m1_480000_393600 5.356235
R11841 n1_m1_480000_393600 n1_m1_484800_393600 5.356235
R11842 n1_m1_484800_393600 n1_m1_489600_393600 5.356235
R11843 n1_m1_489600_393600 n1_m1_494400_393600 5.356235
R11844 n1_m1_494400_393600 n1_m1_499200_393600 5.356235
R11845 n1_m1_499200_393600 n1_m1_504000_393600 5.356235
R11846 n1_m1_504000_393600 n1_m1_508000_393600 4.463529
R11847 n1_m1_508800_393600 n1_m1_508000_393600 0.892706
R11848 n1_m1_508800_393600 n1_m1_513600_393600 5.356235
R11849 n1_m1_513600_393600 n1_m1_518400_393600 5.356235
R11850 n1_m1_518400_393600 n1_m1_523200_393600 5.356235
R11851 n1_m1_523200_393600 n1_m1_528000_393600 5.356235
R11852 n1_m1_528000_393600 n1_m1_532800_393600 5.356235
R11853 n1_m1_532800_393600 n1_m1_536000_393600 3.570824
R11854 n1_m1_537600_393600 n1_m1_536000_393600 1.785412
R11855 n1_m1_537600_393600 n1_m1_542400_393600 5.356235
R11856 n1_m1_542400_393600 n1_m1_547200_393600 5.356235
R11857 n1_m1_547200_393600 n1_m1_552000_393600 5.356235
R11858 n1_m1_552000_393600 n1_m1_556800_393600 5.356235
R11859 n1_m1_556800_393600 n1_m1_561600_393600 5.356235
R11860 n1_m1_561600_393600 n1_m1_564000_393600 2.678118
R11861 n1_m1_566400_393600 n1_m1_564000_393600 2.678118
R11862 n1_m1_566400_393600 n1_m1_571200_393600 5.356235
R11863 n1_m1_571200_393600 n1_m1_576000_393600 5.356235
R11864 n1_m1_576000_393600 n1_m1_580800_393600 5.356235
R11865 n1_m1_580800_393600 n1_m1_585600_393600 5.356235
R11866 n1_m1_585600_393600 n1_m1_590400_393600 5.356235
R11867 n1_m1_590400_393600 n1_m1_592000_393600 1.785412
R11868 n1_m1_595200_393600 n1_m1_592000_393600 3.570824
R11869 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R11870 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R11871 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R11872 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R11873 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R11874 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R11875 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R11876 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R11877 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R11878 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R11879 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R11880 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R11881 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R11882 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R11883 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R11884 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R11885 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R11886 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R11887 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R11888 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R11889 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R11890 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R11891 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R11892 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R11893 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R11894 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R11895 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R11896 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R11897 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R11898 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R11899 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R11900 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R11901 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R11902 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R11903 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R11904 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R11905 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R11906 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R11907 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R11908 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R11909 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R11910 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R11911 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R11912 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R11913 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R11914 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R11915 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R11916 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R11917 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R11918 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R11919 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R11920 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R11921 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R11922 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R11923 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R11924 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R11925 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R11926 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R11927 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R11928 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R11929 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R11930 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R11931 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R11932 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R11933 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R11934 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R11935 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R11936 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R11937 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R11938 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R11939 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R11940 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R11941 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R11942 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R11943 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R11944 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R11945 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R11946 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R11947 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R11948 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R11949 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R11950 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R11951 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R11952 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R11953 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R11954 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R11955 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R11956 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R11957 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R11958 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R11959 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R11960 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R11961 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R11962 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R11963 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R11964 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R11965 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R11966 n1_m1_403200_398400 n1_m1_408000_398400 5.356235
R11967 n1_m1_408000_398400 n1_m1_412800_398400 5.356235
R11968 n1_m1_412800_398400 n1_m1_417600_398400 5.356235
R11969 n1_m1_417600_398400 n1_m1_422400_398400 5.356235
R11970 n1_m1_422400_398400 n1_m1_424000_398400 1.785412
R11971 n1_m1_427200_398400 n1_m1_424000_398400 3.570824
R11972 n1_m1_427200_398400 n1_m1_432000_398400 5.356235
R11973 n1_m1_432000_398400 n1_m1_436800_398400 5.356235
R11974 n1_m1_436800_398400 n1_m1_441600_398400 5.356235
R11975 n1_m1_441600_398400 n1_m1_446400_398400 5.356235
R11976 n1_m1_446400_398400 n1_m1_451200_398400 5.356235
R11977 n1_m1_451200_398400 n1_m1_452000_398400 0.892706
R11978 n1_m1_456000_398400 n1_m1_452000_398400 4.463529
R11979 n1_m1_456000_398400 n1_m1_460800_398400 5.356235
R11980 n1_m1_460800_398400 n1_m1_465600_398400 5.356235
R11981 n1_m1_465600_398400 n1_m1_470400_398400 5.356235
R11982 n1_m1_470400_398400 n1_m1_475200_398400 5.356235
R11983 n1_m1_475200_398400 n1_m1_480000_398400 5.356235
R11984 n1_m1_480000_398400 n1_m1_484800_398400 5.356235
R11985 n1_m1_484800_398400 n1_m1_489600_398400 5.356235
R11986 n1_m1_489600_398400 n1_m1_494400_398400 5.356235
R11987 n1_m1_494400_398400 n1_m1_499200_398400 5.356235
R11988 n1_m1_499200_398400 n1_m1_504000_398400 5.356235
R11989 n1_m1_504000_398400 n1_m1_508000_398400 4.463529
R11990 n1_m1_508800_398400 n1_m1_508000_398400 0.892706
R11991 n1_m1_508800_398400 n1_m1_513600_398400 5.356235
R11992 n1_m1_513600_398400 n1_m1_518400_398400 5.356235
R11993 n1_m1_518400_398400 n1_m1_523200_398400 5.356235
R11994 n1_m1_523200_398400 n1_m1_528000_398400 5.356235
R11995 n1_m1_528000_398400 n1_m1_532800_398400 5.356235
R11996 n1_m1_532800_398400 n1_m1_536000_398400 3.570824
R11997 n1_m1_537600_398400 n1_m1_536000_398400 1.785412
R11998 n1_m1_537600_398400 n1_m1_542400_398400 5.356235
R11999 n1_m1_542400_398400 n1_m1_547200_398400 5.356235
R12000 n1_m1_547200_398400 n1_m1_552000_398400 5.356235
R12001 n1_m1_552000_398400 n1_m1_556800_398400 5.356235
R12002 n1_m1_556800_398400 n1_m1_561600_398400 5.356235
R12003 n1_m1_561600_398400 n1_m1_564000_398400 2.678118
R12004 n1_m1_566400_398400 n1_m1_564000_398400 2.678118
R12005 n1_m1_566400_398400 n1_m1_571200_398400 5.356235
R12006 n1_m1_571200_398400 n1_m1_576000_398400 5.356235
R12007 n1_m1_576000_398400 n1_m1_580800_398400 5.356235
R12008 n1_m1_580800_398400 n1_m1_585600_398400 5.356235
R12009 n1_m1_585600_398400 n1_m1_590400_398400 5.356235
R12010 n1_m1_590400_398400 n1_m1_592000_398400 1.785412
R12011 n1_m1_595200_398400 n1_m1_592000_398400 3.570824
R12012 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R12013 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R12014 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R12015 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R12016 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R12017 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R12018 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R12019 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R12020 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R12021 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R12022 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R12023 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R12024 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R12025 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R12026 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R12027 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R12028 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R12029 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R12030 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R12031 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R12032 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R12033 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R12034 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R12035 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R12036 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R12037 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R12038 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R12039 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R12040 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R12041 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R12042 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R12043 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R12044 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R12045 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R12046 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R12047 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R12048 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R12049 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R12050 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R12051 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R12052 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R12053 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R12054 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R12055 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R12056 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R12057 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R12058 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R12059 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R12060 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R12061 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R12062 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R12063 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R12064 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R12065 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R12066 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R12067 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R12068 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R12069 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R12070 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R12071 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R12072 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R12073 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R12074 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R12075 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R12076 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R12077 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R12078 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R12079 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R12080 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R12081 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R12082 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R12083 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R12084 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R12085 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R12086 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R12087 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R12088 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R12089 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R12090 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R12091 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R12092 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R12093 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R12094 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R12095 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R12096 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R12097 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R12098 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R12099 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R12100 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R12101 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R12102 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R12103 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R12104 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R12105 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R12106 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R12107 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R12108 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R12109 n1_m1_403200_403200 n1_m1_408000_403200 5.356235
R12110 n1_m1_408000_403200 n1_m1_412800_403200 5.356235
R12111 n1_m1_412800_403200 n1_m1_417600_403200 5.356235
R12112 n1_m1_417600_403200 n1_m1_422400_403200 5.356235
R12113 n1_m1_422400_403200 n1_m1_424000_403200 1.785412
R12114 n1_m1_427200_403200 n1_m1_424000_403200 3.570824
R12115 n1_m1_427200_403200 n1_m1_432000_403200 5.356235
R12116 n1_m1_432000_403200 n1_m1_436800_403200 5.356235
R12117 n1_m1_436800_403200 n1_m1_441600_403200 5.356235
R12118 n1_m1_441600_403200 n1_m1_446400_403200 5.356235
R12119 n1_m1_446400_403200 n1_m1_451200_403200 5.356235
R12120 n1_m1_451200_403200 n1_m1_452000_403200 0.892706
R12121 n1_m1_456000_403200 n1_m1_452000_403200 4.463529
R12122 n1_m1_456000_403200 n1_m1_460800_403200 5.356235
R12123 n1_m1_460800_403200 n1_m1_465600_403200 5.356235
R12124 n1_m1_465600_403200 n1_m1_470400_403200 5.356235
R12125 n1_m1_470400_403200 n1_m1_475200_403200 5.356235
R12126 n1_m1_475200_403200 n1_m1_480000_403200 5.356235
R12127 n1_m1_480000_403200 n1_m1_484800_403200 5.356235
R12128 n1_m1_484800_403200 n1_m1_489600_403200 5.356235
R12129 n1_m1_489600_403200 n1_m1_494400_403200 5.356235
R12130 n1_m1_494400_403200 n1_m1_499200_403200 5.356235
R12131 n1_m1_499200_403200 n1_m1_504000_403200 5.356235
R12132 n1_m1_504000_403200 n1_m1_508000_403200 4.463529
R12133 n1_m1_508800_403200 n1_m1_508000_403200 0.892706
R12134 n1_m1_508800_403200 n1_m1_513600_403200 5.356235
R12135 n1_m1_513600_403200 n1_m1_518400_403200 5.356235
R12136 n1_m1_518400_403200 n1_m1_523200_403200 5.356235
R12137 n1_m1_523200_403200 n1_m1_528000_403200 5.356235
R12138 n1_m1_528000_403200 n1_m1_532800_403200 5.356235
R12139 n1_m1_532800_403200 n1_m1_536000_403200 3.570824
R12140 n1_m1_537600_403200 n1_m1_536000_403200 1.785412
R12141 n1_m1_537600_403200 n1_m1_542400_403200 5.356235
R12142 n1_m1_542400_403200 n1_m1_547200_403200 5.356235
R12143 n1_m1_547200_403200 n1_m1_552000_403200 5.356235
R12144 n1_m1_552000_403200 n1_m1_556800_403200 5.356235
R12145 n1_m1_556800_403200 n1_m1_561600_403200 5.356235
R12146 n1_m1_561600_403200 n1_m1_564000_403200 2.678118
R12147 n1_m1_566400_403200 n1_m1_564000_403200 2.678118
R12148 n1_m1_566400_403200 n1_m1_571200_403200 5.356235
R12149 n1_m1_571200_403200 n1_m1_576000_403200 5.356235
R12150 n1_m1_576000_403200 n1_m1_580800_403200 5.356235
R12151 n1_m1_580800_403200 n1_m1_585600_403200 5.356235
R12152 n1_m1_585600_403200 n1_m1_590400_403200 5.356235
R12153 n1_m1_590400_403200 n1_m1_592000_403200 1.785412
R12154 n1_m1_595200_403200 n1_m1_592000_403200 3.570824
R12155 n1_m1_0_408000 n1_m1_4000_408000 4.463529
R12156 n1_m1_4800_408000 n1_m1_4000_408000 0.892706
R12157 n1_m1_4800_408000 n1_m1_9600_408000 5.356235
R12158 n1_m1_9600_408000 n1_m1_14400_408000 5.356235
R12159 n1_m1_14400_408000 n1_m1_19200_408000 5.356235
R12160 n1_m1_19200_408000 n1_m1_24000_408000 5.356235
R12161 n1_m1_24000_408000 n1_m1_28800_408000 5.356235
R12162 n1_m1_28800_408000 n1_m1_32000_408000 3.570824
R12163 n1_m1_33600_408000 n1_m1_32000_408000 1.785412
R12164 n1_m1_33600_408000 n1_m1_38400_408000 5.356235
R12165 n1_m1_38400_408000 n1_m1_43200_408000 5.356235
R12166 n1_m1_43200_408000 n1_m1_48000_408000 5.356235
R12167 n1_m1_48000_408000 n1_m1_52800_408000 5.356235
R12168 n1_m1_52800_408000 n1_m1_57600_408000 5.356235
R12169 n1_m1_57600_408000 n1_m1_60000_408000 2.678118
R12170 n1_m1_62400_408000 n1_m1_60000_408000 2.678118
R12171 n1_m1_62400_408000 n1_m1_67200_408000 5.356235
R12172 n1_m1_67200_408000 n1_m1_72000_408000 5.356235
R12173 n1_m1_72000_408000 n1_m1_76800_408000 5.356235
R12174 n1_m1_76800_408000 n1_m1_81600_408000 5.356235
R12175 n1_m1_81600_408000 n1_m1_86400_408000 5.356235
R12176 n1_m1_86400_408000 n1_m1_88000_408000 1.785412
R12177 n1_m1_91200_408000 n1_m1_88000_408000 3.570824
R12178 n1_m1_91200_408000 n1_m1_96000_408000 5.356235
R12179 n1_m1_96000_408000 n1_m1_100800_408000 5.356235
R12180 n1_m1_100800_408000 n1_m1_105600_408000 5.356235
R12181 n1_m1_105600_408000 n1_m1_110400_408000 5.356235
R12182 n1_m1_110400_408000 n1_m1_115200_408000 5.356235
R12183 n1_m1_115200_408000 n1_m1_116000_408000 0.892706
R12184 n1_m1_120000_408000 n1_m1_116000_408000 4.463529
R12185 n1_m1_120000_408000 n1_m1_124800_408000 5.356235
R12186 n1_m1_124800_408000 n1_m1_129600_408000 5.356235
R12187 n1_m1_129600_408000 n1_m1_134400_408000 5.356235
R12188 n1_m1_134400_408000 n1_m1_139200_408000 5.356235
R12189 n1_m1_139200_408000 n1_m1_144000_408000 5.356235
R12190 n1_m1_144000_408000 n1_m1_148800_408000 5.356235
R12191 n1_m1_148800_408000 n1_m1_153600_408000 5.356235
R12192 n1_m1_153600_408000 n1_m1_158400_408000 5.356235
R12193 n1_m1_158400_408000 n1_m1_163200_408000 5.356235
R12194 n1_m1_163200_408000 n1_m1_168000_408000 5.356235
R12195 n1_m1_168000_408000 n1_m1_172000_408000 4.463529
R12196 n1_m1_172800_408000 n1_m1_172000_408000 0.892706
R12197 n1_m1_172800_408000 n1_m1_177600_408000 5.356235
R12198 n1_m1_177600_408000 n1_m1_182400_408000 5.356235
R12199 n1_m1_182400_408000 n1_m1_187200_408000 5.356235
R12200 n1_m1_187200_408000 n1_m1_192000_408000 5.356235
R12201 n1_m1_192000_408000 n1_m1_196800_408000 5.356235
R12202 n1_m1_196800_408000 n1_m1_200000_408000 3.570824
R12203 n1_m1_201600_408000 n1_m1_200000_408000 1.785412
R12204 n1_m1_201600_408000 n1_m1_206400_408000 5.356235
R12205 n1_m1_206400_408000 n1_m1_211200_408000 5.356235
R12206 n1_m1_211200_408000 n1_m1_216000_408000 5.356235
R12207 n1_m1_216000_408000 n1_m1_220800_408000 5.356235
R12208 n1_m1_220800_408000 n1_m1_225600_408000 5.356235
R12209 n1_m1_225600_408000 n1_m1_228000_408000 2.678118
R12210 n1_m1_230400_408000 n1_m1_228000_408000 2.678118
R12211 n1_m1_230400_408000 n1_m1_235200_408000 5.356235
R12212 n1_m1_235200_408000 n1_m1_240000_408000 5.356235
R12213 n1_m1_240000_408000 n1_m1_244800_408000 5.356235
R12214 n1_m1_244800_408000 n1_m1_249600_408000 5.356235
R12215 n1_m1_249600_408000 n1_m1_254400_408000 5.356235
R12216 n1_m1_254400_408000 n1_m1_256000_408000 1.785412
R12217 n1_m1_259200_408000 n1_m1_256000_408000 3.570824
R12218 n1_m1_259200_408000 n1_m1_264000_408000 5.356235
R12219 n1_m1_264000_408000 n1_m1_268800_408000 5.356235
R12220 n1_m1_268800_408000 n1_m1_273600_408000 5.356235
R12221 n1_m1_273600_408000 n1_m1_278400_408000 5.356235
R12222 n1_m1_278400_408000 n1_m1_283200_408000 5.356235
R12223 n1_m1_283200_408000 n1_m1_284000_408000 0.892706
R12224 n1_m1_288000_408000 n1_m1_284000_408000 4.463529
R12225 n1_m1_288000_408000 n1_m1_292800_408000 5.356235
R12226 n1_m1_292800_408000 n1_m1_297600_408000 5.356235
R12227 n1_m1_297600_408000 n1_m1_302400_408000 5.356235
R12228 n1_m1_302400_408000 n1_m1_307200_408000 5.356235
R12229 n1_m1_307200_408000 n1_m1_312000_408000 5.356235
R12230 n1_m1_312000_408000 n1_m1_316800_408000 5.356235
R12231 n1_m1_316800_408000 n1_m1_321600_408000 5.356235
R12232 n1_m1_321600_408000 n1_m1_326400_408000 5.356235
R12233 n1_m1_326400_408000 n1_m1_331200_408000 5.356235
R12234 n1_m1_331200_408000 n1_m1_336000_408000 5.356235
R12235 n1_m1_336000_408000 n1_m1_340000_408000 4.463529
R12236 n1_m1_340800_408000 n1_m1_340000_408000 0.892706
R12237 n1_m1_340800_408000 n1_m1_345600_408000 5.356235
R12238 n1_m1_345600_408000 n1_m1_350400_408000 5.356235
R12239 n1_m1_350400_408000 n1_m1_355200_408000 5.356235
R12240 n1_m1_355200_408000 n1_m1_360000_408000 5.356235
R12241 n1_m1_360000_408000 n1_m1_364800_408000 5.356235
R12242 n1_m1_364800_408000 n1_m1_368000_408000 3.570824
R12243 n1_m1_369600_408000 n1_m1_368000_408000 1.785412
R12244 n1_m1_369600_408000 n1_m1_374400_408000 5.356235
R12245 n1_m1_374400_408000 n1_m1_379200_408000 5.356235
R12246 n1_m1_379200_408000 n1_m1_384000_408000 5.356235
R12247 n1_m1_384000_408000 n1_m1_388800_408000 5.356235
R12248 n1_m1_388800_408000 n1_m1_393600_408000 5.356235
R12249 n1_m1_393600_408000 n1_m1_396000_408000 2.678118
R12250 n1_m1_398400_408000 n1_m1_396000_408000 2.678118
R12251 n1_m1_398400_408000 n1_m1_403200_408000 5.356235
R12252 n1_m1_403200_408000 n1_m1_408000_408000 5.356235
R12253 n1_m1_408000_408000 n1_m1_412800_408000 5.356235
R12254 n1_m1_412800_408000 n1_m1_417600_408000 5.356235
R12255 n1_m1_417600_408000 n1_m1_422400_408000 5.356235
R12256 n1_m1_422400_408000 n1_m1_424000_408000 1.785412
R12257 n1_m1_427200_408000 n1_m1_424000_408000 3.570824
R12258 n1_m1_427200_408000 n1_m1_432000_408000 5.356235
R12259 n1_m1_432000_408000 n1_m1_436800_408000 5.356235
R12260 n1_m1_436800_408000 n1_m1_441600_408000 5.356235
R12261 n1_m1_441600_408000 n1_m1_446400_408000 5.356235
R12262 n1_m1_446400_408000 n1_m1_451200_408000 5.356235
R12263 n1_m1_451200_408000 n1_m1_452000_408000 0.892706
R12264 n1_m1_456000_408000 n1_m1_452000_408000 4.463529
R12265 n1_m1_456000_408000 n1_m1_460800_408000 5.356235
R12266 n1_m1_460800_408000 n1_m1_465600_408000 5.356235
R12267 n1_m1_465600_408000 n1_m1_470400_408000 5.356235
R12268 n1_m1_470400_408000 n1_m1_475200_408000 5.356235
R12269 n1_m1_475200_408000 n1_m1_480000_408000 5.356235
R12270 n1_m1_480000_408000 n1_m1_484800_408000 5.356235
R12271 n1_m1_484800_408000 n1_m1_489600_408000 5.356235
R12272 n1_m1_489600_408000 n1_m1_494400_408000 5.356235
R12273 n1_m1_494400_408000 n1_m1_499200_408000 5.356235
R12274 n1_m1_499200_408000 n1_m1_504000_408000 5.356235
R12275 n1_m1_504000_408000 n1_m1_508000_408000 4.463529
R12276 n1_m1_508800_408000 n1_m1_508000_408000 0.892706
R12277 n1_m1_508800_408000 n1_m1_513600_408000 5.356235
R12278 n1_m1_513600_408000 n1_m1_518400_408000 5.356235
R12279 n1_m1_518400_408000 n1_m1_523200_408000 5.356235
R12280 n1_m1_523200_408000 n1_m1_528000_408000 5.356235
R12281 n1_m1_528000_408000 n1_m1_532800_408000 5.356235
R12282 n1_m1_532800_408000 n1_m1_536000_408000 3.570824
R12283 n1_m1_537600_408000 n1_m1_536000_408000 1.785412
R12284 n1_m1_537600_408000 n1_m1_542400_408000 5.356235
R12285 n1_m1_542400_408000 n1_m1_547200_408000 5.356235
R12286 n1_m1_547200_408000 n1_m1_552000_408000 5.356235
R12287 n1_m1_552000_408000 n1_m1_556800_408000 5.356235
R12288 n1_m1_556800_408000 n1_m1_561600_408000 5.356235
R12289 n1_m1_561600_408000 n1_m1_564000_408000 2.678118
R12290 n1_m1_566400_408000 n1_m1_564000_408000 2.678118
R12291 n1_m1_566400_408000 n1_m1_571200_408000 5.356235
R12292 n1_m1_571200_408000 n1_m1_576000_408000 5.356235
R12293 n1_m1_576000_408000 n1_m1_580800_408000 5.356235
R12294 n1_m1_580800_408000 n1_m1_585600_408000 5.356235
R12295 n1_m1_585600_408000 n1_m1_590400_408000 5.356235
R12296 n1_m1_590400_408000 n1_m1_592000_408000 1.785412
R12297 n1_m1_595200_408000 n1_m1_592000_408000 3.570824
R12298 n1_m1_0_412800 n1_m1_4000_412800 4.463529
R12299 n1_m1_4800_412800 n1_m1_4000_412800 0.892706
R12300 n1_m1_4800_412800 n1_m1_9600_412800 5.356235
R12301 n1_m1_9600_412800 n1_m1_14400_412800 5.356235
R12302 n1_m1_14400_412800 n1_m1_19200_412800 5.356235
R12303 n1_m1_19200_412800 n1_m1_24000_412800 5.356235
R12304 n1_m1_24000_412800 n1_m1_28800_412800 5.356235
R12305 n1_m1_28800_412800 n1_m1_32000_412800 3.570824
R12306 n1_m1_33600_412800 n1_m1_32000_412800 1.785412
R12307 n1_m1_33600_412800 n1_m1_38400_412800 5.356235
R12308 n1_m1_38400_412800 n1_m1_43200_412800 5.356235
R12309 n1_m1_43200_412800 n1_m1_48000_412800 5.356235
R12310 n1_m1_48000_412800 n1_m1_52800_412800 5.356235
R12311 n1_m1_52800_412800 n1_m1_57600_412800 5.356235
R12312 n1_m1_57600_412800 n1_m1_60000_412800 2.678118
R12313 n1_m1_62400_412800 n1_m1_60000_412800 2.678118
R12314 n1_m1_62400_412800 n1_m1_67200_412800 5.356235
R12315 n1_m1_67200_412800 n1_m1_72000_412800 5.356235
R12316 n1_m1_72000_412800 n1_m1_76800_412800 5.356235
R12317 n1_m1_76800_412800 n1_m1_81600_412800 5.356235
R12318 n1_m1_81600_412800 n1_m1_86400_412800 5.356235
R12319 n1_m1_86400_412800 n1_m1_88000_412800 1.785412
R12320 n1_m1_91200_412800 n1_m1_88000_412800 3.570824
R12321 n1_m1_91200_412800 n1_m1_96000_412800 5.356235
R12322 n1_m1_96000_412800 n1_m1_100800_412800 5.356235
R12323 n1_m1_100800_412800 n1_m1_105600_412800 5.356235
R12324 n1_m1_105600_412800 n1_m1_110400_412800 5.356235
R12325 n1_m1_110400_412800 n1_m1_115200_412800 5.356235
R12326 n1_m1_115200_412800 n1_m1_116000_412800 0.892706
R12327 n1_m1_120000_412800 n1_m1_116000_412800 4.463529
R12328 n1_m1_120000_412800 n1_m1_124800_412800 5.356235
R12329 n1_m1_124800_412800 n1_m1_129600_412800 5.356235
R12330 n1_m1_129600_412800 n1_m1_134400_412800 5.356235
R12331 n1_m1_134400_412800 n1_m1_139200_412800 5.356235
R12332 n1_m1_139200_412800 n1_m1_144000_412800 5.356235
R12333 n1_m1_144000_412800 n1_m1_148800_412800 5.356235
R12334 n1_m1_148800_412800 n1_m1_153600_412800 5.356235
R12335 n1_m1_153600_412800 n1_m1_158400_412800 5.356235
R12336 n1_m1_158400_412800 n1_m1_163200_412800 5.356235
R12337 n1_m1_163200_412800 n1_m1_168000_412800 5.356235
R12338 n1_m1_168000_412800 n1_m1_172000_412800 4.463529
R12339 n1_m1_172800_412800 n1_m1_172000_412800 0.892706
R12340 n1_m1_172800_412800 n1_m1_177600_412800 5.356235
R12341 n1_m1_177600_412800 n1_m1_182400_412800 5.356235
R12342 n1_m1_182400_412800 n1_m1_187200_412800 5.356235
R12343 n1_m1_187200_412800 n1_m1_192000_412800 5.356235
R12344 n1_m1_192000_412800 n1_m1_196800_412800 5.356235
R12345 n1_m1_196800_412800 n1_m1_200000_412800 3.570824
R12346 n1_m1_201600_412800 n1_m1_200000_412800 1.785412
R12347 n1_m1_201600_412800 n1_m1_206400_412800 5.356235
R12348 n1_m1_206400_412800 n1_m1_211200_412800 5.356235
R12349 n1_m1_211200_412800 n1_m1_216000_412800 5.356235
R12350 n1_m1_216000_412800 n1_m1_220800_412800 5.356235
R12351 n1_m1_220800_412800 n1_m1_225600_412800 5.356235
R12352 n1_m1_225600_412800 n1_m1_228000_412800 2.678118
R12353 n1_m1_230400_412800 n1_m1_228000_412800 2.678118
R12354 n1_m1_230400_412800 n1_m1_235200_412800 5.356235
R12355 n1_m1_235200_412800 n1_m1_240000_412800 5.356235
R12356 n1_m1_240000_412800 n1_m1_244800_412800 5.356235
R12357 n1_m1_244800_412800 n1_m1_249600_412800 5.356235
R12358 n1_m1_249600_412800 n1_m1_254400_412800 5.356235
R12359 n1_m1_254400_412800 n1_m1_256000_412800 1.785412
R12360 n1_m1_259200_412800 n1_m1_256000_412800 3.570824
R12361 n1_m1_259200_412800 n1_m1_264000_412800 5.356235
R12362 n1_m1_264000_412800 n1_m1_268800_412800 5.356235
R12363 n1_m1_268800_412800 n1_m1_273600_412800 5.356235
R12364 n1_m1_273600_412800 n1_m1_278400_412800 5.356235
R12365 n1_m1_278400_412800 n1_m1_283200_412800 5.356235
R12366 n1_m1_283200_412800 n1_m1_284000_412800 0.892706
R12367 n1_m1_288000_412800 n1_m1_284000_412800 4.463529
R12368 n1_m1_288000_412800 n1_m1_292800_412800 5.356235
R12369 n1_m1_292800_412800 n1_m1_297600_412800 5.356235
R12370 n1_m1_297600_412800 n1_m1_302400_412800 5.356235
R12371 n1_m1_302400_412800 n1_m1_307200_412800 5.356235
R12372 n1_m1_307200_412800 n1_m1_312000_412800 5.356235
R12373 n1_m1_312000_412800 n1_m1_316800_412800 5.356235
R12374 n1_m1_316800_412800 n1_m1_321600_412800 5.356235
R12375 n1_m1_321600_412800 n1_m1_326400_412800 5.356235
R12376 n1_m1_326400_412800 n1_m1_331200_412800 5.356235
R12377 n1_m1_331200_412800 n1_m1_336000_412800 5.356235
R12378 n1_m1_336000_412800 n1_m1_340000_412800 4.463529
R12379 n1_m1_340800_412800 n1_m1_340000_412800 0.892706
R12380 n1_m1_340800_412800 n1_m1_345600_412800 5.356235
R12381 n1_m1_345600_412800 n1_m1_350400_412800 5.356235
R12382 n1_m1_350400_412800 n1_m1_355200_412800 5.356235
R12383 n1_m1_355200_412800 n1_m1_360000_412800 5.356235
R12384 n1_m1_360000_412800 n1_m1_364800_412800 5.356235
R12385 n1_m1_364800_412800 n1_m1_368000_412800 3.570824
R12386 n1_m1_369600_412800 n1_m1_368000_412800 1.785412
R12387 n1_m1_369600_412800 n1_m1_374400_412800 5.356235
R12388 n1_m1_374400_412800 n1_m1_379200_412800 5.356235
R12389 n1_m1_379200_412800 n1_m1_384000_412800 5.356235
R12390 n1_m1_384000_412800 n1_m1_388800_412800 5.356235
R12391 n1_m1_388800_412800 n1_m1_393600_412800 5.356235
R12392 n1_m1_393600_412800 n1_m1_396000_412800 2.678118
R12393 n1_m1_398400_412800 n1_m1_396000_412800 2.678118
R12394 n1_m1_398400_412800 n1_m1_403200_412800 5.356235
R12395 n1_m1_403200_412800 n1_m1_408000_412800 5.356235
R12396 n1_m1_408000_412800 n1_m1_412800_412800 5.356235
R12397 n1_m1_412800_412800 n1_m1_417600_412800 5.356235
R12398 n1_m1_417600_412800 n1_m1_422400_412800 5.356235
R12399 n1_m1_422400_412800 n1_m1_424000_412800 1.785412
R12400 n1_m1_427200_412800 n1_m1_424000_412800 3.570824
R12401 n1_m1_427200_412800 n1_m1_432000_412800 5.356235
R12402 n1_m1_432000_412800 n1_m1_436800_412800 5.356235
R12403 n1_m1_436800_412800 n1_m1_441600_412800 5.356235
R12404 n1_m1_441600_412800 n1_m1_446400_412800 5.356235
R12405 n1_m1_446400_412800 n1_m1_451200_412800 5.356235
R12406 n1_m1_451200_412800 n1_m1_452000_412800 0.892706
R12407 n1_m1_456000_412800 n1_m1_452000_412800 4.463529
R12408 n1_m1_456000_412800 n1_m1_460800_412800 5.356235
R12409 n1_m1_460800_412800 n1_m1_465600_412800 5.356235
R12410 n1_m1_465600_412800 n1_m1_470400_412800 5.356235
R12411 n1_m1_470400_412800 n1_m1_475200_412800 5.356235
R12412 n1_m1_475200_412800 n1_m1_480000_412800 5.356235
R12413 n1_m1_480000_412800 n1_m1_484800_412800 5.356235
R12414 n1_m1_484800_412800 n1_m1_489600_412800 5.356235
R12415 n1_m1_489600_412800 n1_m1_494400_412800 5.356235
R12416 n1_m1_494400_412800 n1_m1_499200_412800 5.356235
R12417 n1_m1_499200_412800 n1_m1_504000_412800 5.356235
R12418 n1_m1_504000_412800 n1_m1_508000_412800 4.463529
R12419 n1_m1_508800_412800 n1_m1_508000_412800 0.892706
R12420 n1_m1_508800_412800 n1_m1_513600_412800 5.356235
R12421 n1_m1_513600_412800 n1_m1_518400_412800 5.356235
R12422 n1_m1_518400_412800 n1_m1_523200_412800 5.356235
R12423 n1_m1_523200_412800 n1_m1_528000_412800 5.356235
R12424 n1_m1_528000_412800 n1_m1_532800_412800 5.356235
R12425 n1_m1_532800_412800 n1_m1_536000_412800 3.570824
R12426 n1_m1_537600_412800 n1_m1_536000_412800 1.785412
R12427 n1_m1_537600_412800 n1_m1_542400_412800 5.356235
R12428 n1_m1_542400_412800 n1_m1_547200_412800 5.356235
R12429 n1_m1_547200_412800 n1_m1_552000_412800 5.356235
R12430 n1_m1_552000_412800 n1_m1_556800_412800 5.356235
R12431 n1_m1_556800_412800 n1_m1_561600_412800 5.356235
R12432 n1_m1_561600_412800 n1_m1_564000_412800 2.678118
R12433 n1_m1_566400_412800 n1_m1_564000_412800 2.678118
R12434 n1_m1_566400_412800 n1_m1_571200_412800 5.356235
R12435 n1_m1_571200_412800 n1_m1_576000_412800 5.356235
R12436 n1_m1_576000_412800 n1_m1_580800_412800 5.356235
R12437 n1_m1_580800_412800 n1_m1_585600_412800 5.356235
R12438 n1_m1_585600_412800 n1_m1_590400_412800 5.356235
R12439 n1_m1_590400_412800 n1_m1_592000_412800 1.785412
R12440 n1_m1_595200_412800 n1_m1_592000_412800 3.570824
R12441 n1_m1_0_417600 n1_m1_4000_417600 4.463529
R12442 n1_m1_4800_417600 n1_m1_4000_417600 0.892706
R12443 n1_m1_4800_417600 n1_m1_9600_417600 5.356235
R12444 n1_m1_9600_417600 n1_m1_14400_417600 5.356235
R12445 n1_m1_14400_417600 n1_m1_19200_417600 5.356235
R12446 n1_m1_19200_417600 n1_m1_24000_417600 5.356235
R12447 n1_m1_24000_417600 n1_m1_28800_417600 5.356235
R12448 n1_m1_28800_417600 n1_m1_32000_417600 3.570824
R12449 n1_m1_33600_417600 n1_m1_32000_417600 1.785412
R12450 n1_m1_33600_417600 n1_m1_38400_417600 5.356235
R12451 n1_m1_38400_417600 n1_m1_43200_417600 5.356235
R12452 n1_m1_43200_417600 n1_m1_48000_417600 5.356235
R12453 n1_m1_48000_417600 n1_m1_52800_417600 5.356235
R12454 n1_m1_52800_417600 n1_m1_57600_417600 5.356235
R12455 n1_m1_57600_417600 n1_m1_60000_417600 2.678118
R12456 n1_m1_62400_417600 n1_m1_60000_417600 2.678118
R12457 n1_m1_62400_417600 n1_m1_67200_417600 5.356235
R12458 n1_m1_67200_417600 n1_m1_72000_417600 5.356235
R12459 n1_m1_72000_417600 n1_m1_76800_417600 5.356235
R12460 n1_m1_76800_417600 n1_m1_81600_417600 5.356235
R12461 n1_m1_81600_417600 n1_m1_86400_417600 5.356235
R12462 n1_m1_86400_417600 n1_m1_88000_417600 1.785412
R12463 n1_m1_91200_417600 n1_m1_88000_417600 3.570824
R12464 n1_m1_91200_417600 n1_m1_96000_417600 5.356235
R12465 n1_m1_96000_417600 n1_m1_100800_417600 5.356235
R12466 n1_m1_100800_417600 n1_m1_105600_417600 5.356235
R12467 n1_m1_105600_417600 n1_m1_110400_417600 5.356235
R12468 n1_m1_110400_417600 n1_m1_115200_417600 5.356235
R12469 n1_m1_115200_417600 n1_m1_116000_417600 0.892706
R12470 n1_m1_120000_417600 n1_m1_116000_417600 4.463529
R12471 n1_m1_120000_417600 n1_m1_124800_417600 5.356235
R12472 n1_m1_124800_417600 n1_m1_129600_417600 5.356235
R12473 n1_m1_129600_417600 n1_m1_134400_417600 5.356235
R12474 n1_m1_134400_417600 n1_m1_139200_417600 5.356235
R12475 n1_m1_139200_417600 n1_m1_144000_417600 5.356235
R12476 n1_m1_144000_417600 n1_m1_148800_417600 5.356235
R12477 n1_m1_148800_417600 n1_m1_153600_417600 5.356235
R12478 n1_m1_153600_417600 n1_m1_158400_417600 5.356235
R12479 n1_m1_158400_417600 n1_m1_163200_417600 5.356235
R12480 n1_m1_163200_417600 n1_m1_168000_417600 5.356235
R12481 n1_m1_168000_417600 n1_m1_172000_417600 4.463529
R12482 n1_m1_172800_417600 n1_m1_172000_417600 0.892706
R12483 n1_m1_172800_417600 n1_m1_177600_417600 5.356235
R12484 n1_m1_177600_417600 n1_m1_182400_417600 5.356235
R12485 n1_m1_182400_417600 n1_m1_187200_417600 5.356235
R12486 n1_m1_187200_417600 n1_m1_192000_417600 5.356235
R12487 n1_m1_192000_417600 n1_m1_196800_417600 5.356235
R12488 n1_m1_196800_417600 n1_m1_200000_417600 3.570824
R12489 n1_m1_201600_417600 n1_m1_200000_417600 1.785412
R12490 n1_m1_201600_417600 n1_m1_206400_417600 5.356235
R12491 n1_m1_206400_417600 n1_m1_211200_417600 5.356235
R12492 n1_m1_211200_417600 n1_m1_216000_417600 5.356235
R12493 n1_m1_216000_417600 n1_m1_220800_417600 5.356235
R12494 n1_m1_220800_417600 n1_m1_225600_417600 5.356235
R12495 n1_m1_225600_417600 n1_m1_228000_417600 2.678118
R12496 n1_m1_230400_417600 n1_m1_228000_417600 2.678118
R12497 n1_m1_230400_417600 n1_m1_235200_417600 5.356235
R12498 n1_m1_235200_417600 n1_m1_240000_417600 5.356235
R12499 n1_m1_240000_417600 n1_m1_244800_417600 5.356235
R12500 n1_m1_244800_417600 n1_m1_249600_417600 5.356235
R12501 n1_m1_249600_417600 n1_m1_254400_417600 5.356235
R12502 n1_m1_254400_417600 n1_m1_256000_417600 1.785412
R12503 n1_m1_259200_417600 n1_m1_256000_417600 3.570824
R12504 n1_m1_259200_417600 n1_m1_264000_417600 5.356235
R12505 n1_m1_264000_417600 n1_m1_268800_417600 5.356235
R12506 n1_m1_268800_417600 n1_m1_273600_417600 5.356235
R12507 n1_m1_273600_417600 n1_m1_278400_417600 5.356235
R12508 n1_m1_278400_417600 n1_m1_283200_417600 5.356235
R12509 n1_m1_283200_417600 n1_m1_284000_417600 0.892706
R12510 n1_m1_288000_417600 n1_m1_284000_417600 4.463529
R12511 n1_m1_288000_417600 n1_m1_292800_417600 5.356235
R12512 n1_m1_292800_417600 n1_m1_297600_417600 5.356235
R12513 n1_m1_297600_417600 n1_m1_302400_417600 5.356235
R12514 n1_m1_302400_417600 n1_m1_307200_417600 5.356235
R12515 n1_m1_307200_417600 n1_m1_312000_417600 5.356235
R12516 n1_m1_312000_417600 n1_m1_316800_417600 5.356235
R12517 n1_m1_316800_417600 n1_m1_321600_417600 5.356235
R12518 n1_m1_321600_417600 n1_m1_326400_417600 5.356235
R12519 n1_m1_326400_417600 n1_m1_331200_417600 5.356235
R12520 n1_m1_331200_417600 n1_m1_336000_417600 5.356235
R12521 n1_m1_336000_417600 n1_m1_340000_417600 4.463529
R12522 n1_m1_340800_417600 n1_m1_340000_417600 0.892706
R12523 n1_m1_340800_417600 n1_m1_345600_417600 5.356235
R12524 n1_m1_345600_417600 n1_m1_350400_417600 5.356235
R12525 n1_m1_350400_417600 n1_m1_355200_417600 5.356235
R12526 n1_m1_355200_417600 n1_m1_360000_417600 5.356235
R12527 n1_m1_360000_417600 n1_m1_364800_417600 5.356235
R12528 n1_m1_364800_417600 n1_m1_368000_417600 3.570824
R12529 n1_m1_369600_417600 n1_m1_368000_417600 1.785412
R12530 n1_m1_369600_417600 n1_m1_374400_417600 5.356235
R12531 n1_m1_374400_417600 n1_m1_379200_417600 5.356235
R12532 n1_m1_379200_417600 n1_m1_384000_417600 5.356235
R12533 n1_m1_384000_417600 n1_m1_388800_417600 5.356235
R12534 n1_m1_388800_417600 n1_m1_393600_417600 5.356235
R12535 n1_m1_393600_417600 n1_m1_396000_417600 2.678118
R12536 n1_m1_398400_417600 n1_m1_396000_417600 2.678118
R12537 n1_m1_398400_417600 n1_m1_403200_417600 5.356235
R12538 n1_m1_403200_417600 n1_m1_408000_417600 5.356235
R12539 n1_m1_408000_417600 n1_m1_412800_417600 5.356235
R12540 n1_m1_412800_417600 n1_m1_417600_417600 5.356235
R12541 n1_m1_417600_417600 n1_m1_422400_417600 5.356235
R12542 n1_m1_422400_417600 n1_m1_424000_417600 1.785412
R12543 n1_m1_427200_417600 n1_m1_424000_417600 3.570824
R12544 n1_m1_427200_417600 n1_m1_432000_417600 5.356235
R12545 n1_m1_432000_417600 n1_m1_436800_417600 5.356235
R12546 n1_m1_436800_417600 n1_m1_441600_417600 5.356235
R12547 n1_m1_441600_417600 n1_m1_446400_417600 5.356235
R12548 n1_m1_446400_417600 n1_m1_451200_417600 5.356235
R12549 n1_m1_451200_417600 n1_m1_452000_417600 0.892706
R12550 n1_m1_456000_417600 n1_m1_452000_417600 4.463529
R12551 n1_m1_456000_417600 n1_m1_460800_417600 5.356235
R12552 n1_m1_460800_417600 n1_m1_465600_417600 5.356235
R12553 n1_m1_465600_417600 n1_m1_470400_417600 5.356235
R12554 n1_m1_470400_417600 n1_m1_475200_417600 5.356235
R12555 n1_m1_475200_417600 n1_m1_480000_417600 5.356235
R12556 n1_m1_480000_417600 n1_m1_484800_417600 5.356235
R12557 n1_m1_484800_417600 n1_m1_489600_417600 5.356235
R12558 n1_m1_489600_417600 n1_m1_494400_417600 5.356235
R12559 n1_m1_494400_417600 n1_m1_499200_417600 5.356235
R12560 n1_m1_499200_417600 n1_m1_504000_417600 5.356235
R12561 n1_m1_504000_417600 n1_m1_508000_417600 4.463529
R12562 n1_m1_508800_417600 n1_m1_508000_417600 0.892706
R12563 n1_m1_508800_417600 n1_m1_513600_417600 5.356235
R12564 n1_m1_513600_417600 n1_m1_518400_417600 5.356235
R12565 n1_m1_518400_417600 n1_m1_523200_417600 5.356235
R12566 n1_m1_523200_417600 n1_m1_528000_417600 5.356235
R12567 n1_m1_528000_417600 n1_m1_532800_417600 5.356235
R12568 n1_m1_532800_417600 n1_m1_536000_417600 3.570824
R12569 n1_m1_537600_417600 n1_m1_536000_417600 1.785412
R12570 n1_m1_537600_417600 n1_m1_542400_417600 5.356235
R12571 n1_m1_542400_417600 n1_m1_547200_417600 5.356235
R12572 n1_m1_547200_417600 n1_m1_552000_417600 5.356235
R12573 n1_m1_552000_417600 n1_m1_556800_417600 5.356235
R12574 n1_m1_556800_417600 n1_m1_561600_417600 5.356235
R12575 n1_m1_561600_417600 n1_m1_564000_417600 2.678118
R12576 n1_m1_566400_417600 n1_m1_564000_417600 2.678118
R12577 n1_m1_566400_417600 n1_m1_571200_417600 5.356235
R12578 n1_m1_571200_417600 n1_m1_576000_417600 5.356235
R12579 n1_m1_576000_417600 n1_m1_580800_417600 5.356235
R12580 n1_m1_580800_417600 n1_m1_585600_417600 5.356235
R12581 n1_m1_585600_417600 n1_m1_590400_417600 5.356235
R12582 n1_m1_590400_417600 n1_m1_592000_417600 1.785412
R12583 n1_m1_595200_417600 n1_m1_592000_417600 3.570824
R12584 n1_m1_0_422400 n1_m1_4000_422400 4.463529
R12585 n1_m1_4800_422400 n1_m1_4000_422400 0.892706
R12586 n1_m1_4800_422400 n1_m1_9600_422400 5.356235
R12587 n1_m1_9600_422400 n1_m1_14400_422400 5.356235
R12588 n1_m1_14400_422400 n1_m1_19200_422400 5.356235
R12589 n1_m1_19200_422400 n1_m1_24000_422400 5.356235
R12590 n1_m1_24000_422400 n1_m1_28800_422400 5.356235
R12591 n1_m1_28800_422400 n1_m1_32000_422400 3.570824
R12592 n1_m1_33600_422400 n1_m1_32000_422400 1.785412
R12593 n1_m1_33600_422400 n1_m1_38400_422400 5.356235
R12594 n1_m1_38400_422400 n1_m1_43200_422400 5.356235
R12595 n1_m1_43200_422400 n1_m1_48000_422400 5.356235
R12596 n1_m1_48000_422400 n1_m1_52800_422400 5.356235
R12597 n1_m1_52800_422400 n1_m1_57600_422400 5.356235
R12598 n1_m1_57600_422400 n1_m1_60000_422400 2.678118
R12599 n1_m1_62400_422400 n1_m1_60000_422400 2.678118
R12600 n1_m1_62400_422400 n1_m1_67200_422400 5.356235
R12601 n1_m1_67200_422400 n1_m1_72000_422400 5.356235
R12602 n1_m1_72000_422400 n1_m1_76800_422400 5.356235
R12603 n1_m1_76800_422400 n1_m1_81600_422400 5.356235
R12604 n1_m1_81600_422400 n1_m1_86400_422400 5.356235
R12605 n1_m1_86400_422400 n1_m1_88000_422400 1.785412
R12606 n1_m1_91200_422400 n1_m1_88000_422400 3.570824
R12607 n1_m1_91200_422400 n1_m1_96000_422400 5.356235
R12608 n1_m1_96000_422400 n1_m1_100800_422400 5.356235
R12609 n1_m1_100800_422400 n1_m1_105600_422400 5.356235
R12610 n1_m1_105600_422400 n1_m1_110400_422400 5.356235
R12611 n1_m1_110400_422400 n1_m1_115200_422400 5.356235
R12612 n1_m1_115200_422400 n1_m1_116000_422400 0.892706
R12613 n1_m1_120000_422400 n1_m1_116000_422400 4.463529
R12614 n1_m1_120000_422400 n1_m1_124800_422400 5.356235
R12615 n1_m1_124800_422400 n1_m1_129600_422400 5.356235
R12616 n1_m1_129600_422400 n1_m1_134400_422400 5.356235
R12617 n1_m1_134400_422400 n1_m1_139200_422400 5.356235
R12618 n1_m1_139200_422400 n1_m1_144000_422400 5.356235
R12619 n1_m1_144000_422400 n1_m1_148800_422400 5.356235
R12620 n1_m1_148800_422400 n1_m1_153600_422400 5.356235
R12621 n1_m1_153600_422400 n1_m1_158400_422400 5.356235
R12622 n1_m1_158400_422400 n1_m1_163200_422400 5.356235
R12623 n1_m1_163200_422400 n1_m1_168000_422400 5.356235
R12624 n1_m1_168000_422400 n1_m1_172000_422400 4.463529
R12625 n1_m1_172800_422400 n1_m1_172000_422400 0.892706
R12626 n1_m1_172800_422400 n1_m1_177600_422400 5.356235
R12627 n1_m1_177600_422400 n1_m1_182400_422400 5.356235
R12628 n1_m1_182400_422400 n1_m1_187200_422400 5.356235
R12629 n1_m1_187200_422400 n1_m1_192000_422400 5.356235
R12630 n1_m1_192000_422400 n1_m1_196800_422400 5.356235
R12631 n1_m1_196800_422400 n1_m1_200000_422400 3.570824
R12632 n1_m1_201600_422400 n1_m1_200000_422400 1.785412
R12633 n1_m1_201600_422400 n1_m1_206400_422400 5.356235
R12634 n1_m1_206400_422400 n1_m1_211200_422400 5.356235
R12635 n1_m1_211200_422400 n1_m1_216000_422400 5.356235
R12636 n1_m1_216000_422400 n1_m1_220800_422400 5.356235
R12637 n1_m1_220800_422400 n1_m1_225600_422400 5.356235
R12638 n1_m1_225600_422400 n1_m1_228000_422400 2.678118
R12639 n1_m1_230400_422400 n1_m1_228000_422400 2.678118
R12640 n1_m1_230400_422400 n1_m1_235200_422400 5.356235
R12641 n1_m1_235200_422400 n1_m1_240000_422400 5.356235
R12642 n1_m1_240000_422400 n1_m1_244800_422400 5.356235
R12643 n1_m1_244800_422400 n1_m1_249600_422400 5.356235
R12644 n1_m1_249600_422400 n1_m1_254400_422400 5.356235
R12645 n1_m1_254400_422400 n1_m1_256000_422400 1.785412
R12646 n1_m1_259200_422400 n1_m1_256000_422400 3.570824
R12647 n1_m1_259200_422400 n1_m1_264000_422400 5.356235
R12648 n1_m1_264000_422400 n1_m1_268800_422400 5.356235
R12649 n1_m1_268800_422400 n1_m1_273600_422400 5.356235
R12650 n1_m1_273600_422400 n1_m1_278400_422400 5.356235
R12651 n1_m1_278400_422400 n1_m1_283200_422400 5.356235
R12652 n1_m1_283200_422400 n1_m1_284000_422400 0.892706
R12653 n1_m1_288000_422400 n1_m1_284000_422400 4.463529
R12654 n1_m1_288000_422400 n1_m1_292800_422400 5.356235
R12655 n1_m1_292800_422400 n1_m1_297600_422400 5.356235
R12656 n1_m1_297600_422400 n1_m1_302400_422400 5.356235
R12657 n1_m1_302400_422400 n1_m1_307200_422400 5.356235
R12658 n1_m1_307200_422400 n1_m1_312000_422400 5.356235
R12659 n1_m1_312000_422400 n1_m1_316800_422400 5.356235
R12660 n1_m1_316800_422400 n1_m1_321600_422400 5.356235
R12661 n1_m1_321600_422400 n1_m1_326400_422400 5.356235
R12662 n1_m1_326400_422400 n1_m1_331200_422400 5.356235
R12663 n1_m1_331200_422400 n1_m1_336000_422400 5.356235
R12664 n1_m1_336000_422400 n1_m1_340000_422400 4.463529
R12665 n1_m1_340800_422400 n1_m1_340000_422400 0.892706
R12666 n1_m1_340800_422400 n1_m1_345600_422400 5.356235
R12667 n1_m1_345600_422400 n1_m1_350400_422400 5.356235
R12668 n1_m1_350400_422400 n1_m1_355200_422400 5.356235
R12669 n1_m1_355200_422400 n1_m1_360000_422400 5.356235
R12670 n1_m1_360000_422400 n1_m1_364800_422400 5.356235
R12671 n1_m1_364800_422400 n1_m1_368000_422400 3.570824
R12672 n1_m1_369600_422400 n1_m1_368000_422400 1.785412
R12673 n1_m1_369600_422400 n1_m1_374400_422400 5.356235
R12674 n1_m1_374400_422400 n1_m1_379200_422400 5.356235
R12675 n1_m1_379200_422400 n1_m1_384000_422400 5.356235
R12676 n1_m1_384000_422400 n1_m1_388800_422400 5.356235
R12677 n1_m1_388800_422400 n1_m1_393600_422400 5.356235
R12678 n1_m1_393600_422400 n1_m1_396000_422400 2.678118
R12679 n1_m1_398400_422400 n1_m1_396000_422400 2.678118
R12680 n1_m1_398400_422400 n1_m1_403200_422400 5.356235
R12681 n1_m1_403200_422400 n1_m1_408000_422400 5.356235
R12682 n1_m1_408000_422400 n1_m1_412800_422400 5.356235
R12683 n1_m1_412800_422400 n1_m1_417600_422400 5.356235
R12684 n1_m1_417600_422400 n1_m1_422400_422400 5.356235
R12685 n1_m1_422400_422400 n1_m1_424000_422400 1.785412
R12686 n1_m1_427200_422400 n1_m1_424000_422400 3.570824
R12687 n1_m1_427200_422400 n1_m1_432000_422400 5.356235
R12688 n1_m1_432000_422400 n1_m1_436800_422400 5.356235
R12689 n1_m1_436800_422400 n1_m1_441600_422400 5.356235
R12690 n1_m1_441600_422400 n1_m1_446400_422400 5.356235
R12691 n1_m1_446400_422400 n1_m1_451200_422400 5.356235
R12692 n1_m1_451200_422400 n1_m1_452000_422400 0.892706
R12693 n1_m1_456000_422400 n1_m1_452000_422400 4.463529
R12694 n1_m1_456000_422400 n1_m1_460800_422400 5.356235
R12695 n1_m1_460800_422400 n1_m1_465600_422400 5.356235
R12696 n1_m1_465600_422400 n1_m1_470400_422400 5.356235
R12697 n1_m1_470400_422400 n1_m1_475200_422400 5.356235
R12698 n1_m1_475200_422400 n1_m1_480000_422400 5.356235
R12699 n1_m1_480000_422400 n1_m1_484800_422400 5.356235
R12700 n1_m1_484800_422400 n1_m1_489600_422400 5.356235
R12701 n1_m1_489600_422400 n1_m1_494400_422400 5.356235
R12702 n1_m1_494400_422400 n1_m1_499200_422400 5.356235
R12703 n1_m1_499200_422400 n1_m1_504000_422400 5.356235
R12704 n1_m1_504000_422400 n1_m1_508000_422400 4.463529
R12705 n1_m1_508800_422400 n1_m1_508000_422400 0.892706
R12706 n1_m1_508800_422400 n1_m1_513600_422400 5.356235
R12707 n1_m1_513600_422400 n1_m1_518400_422400 5.356235
R12708 n1_m1_518400_422400 n1_m1_523200_422400 5.356235
R12709 n1_m1_523200_422400 n1_m1_528000_422400 5.356235
R12710 n1_m1_528000_422400 n1_m1_532800_422400 5.356235
R12711 n1_m1_532800_422400 n1_m1_536000_422400 3.570824
R12712 n1_m1_537600_422400 n1_m1_536000_422400 1.785412
R12713 n1_m1_537600_422400 n1_m1_542400_422400 5.356235
R12714 n1_m1_542400_422400 n1_m1_547200_422400 5.356235
R12715 n1_m1_547200_422400 n1_m1_552000_422400 5.356235
R12716 n1_m1_552000_422400 n1_m1_556800_422400 5.356235
R12717 n1_m1_556800_422400 n1_m1_561600_422400 5.356235
R12718 n1_m1_561600_422400 n1_m1_564000_422400 2.678118
R12719 n1_m1_566400_422400 n1_m1_564000_422400 2.678118
R12720 n1_m1_566400_422400 n1_m1_571200_422400 5.356235
R12721 n1_m1_571200_422400 n1_m1_576000_422400 5.356235
R12722 n1_m1_576000_422400 n1_m1_580800_422400 5.356235
R12723 n1_m1_580800_422400 n1_m1_585600_422400 5.356235
R12724 n1_m1_585600_422400 n1_m1_590400_422400 5.356235
R12725 n1_m1_590400_422400 n1_m1_592000_422400 1.785412
R12726 n1_m1_595200_422400 n1_m1_592000_422400 3.570824
R12727 n1_m1_0_427200 n1_m1_4000_427200 4.463529
R12728 n1_m1_4800_427200 n1_m1_4000_427200 0.892706
R12729 n1_m1_4800_427200 n1_m1_9600_427200 5.356235
R12730 n1_m1_9600_427200 n1_m1_14400_427200 5.356235
R12731 n1_m1_14400_427200 n1_m1_19200_427200 5.356235
R12732 n1_m1_19200_427200 n1_m1_24000_427200 5.356235
R12733 n1_m1_24000_427200 n1_m1_28800_427200 5.356235
R12734 n1_m1_28800_427200 n1_m1_32000_427200 3.570824
R12735 n1_m1_33600_427200 n1_m1_32000_427200 1.785412
R12736 n1_m1_33600_427200 n1_m1_38400_427200 5.356235
R12737 n1_m1_38400_427200 n1_m1_43200_427200 5.356235
R12738 n1_m1_43200_427200 n1_m1_48000_427200 5.356235
R12739 n1_m1_48000_427200 n1_m1_52800_427200 5.356235
R12740 n1_m1_52800_427200 n1_m1_57600_427200 5.356235
R12741 n1_m1_57600_427200 n1_m1_60000_427200 2.678118
R12742 n1_m1_62400_427200 n1_m1_60000_427200 2.678118
R12743 n1_m1_62400_427200 n1_m1_67200_427200 5.356235
R12744 n1_m1_67200_427200 n1_m1_72000_427200 5.356235
R12745 n1_m1_72000_427200 n1_m1_76800_427200 5.356235
R12746 n1_m1_76800_427200 n1_m1_81600_427200 5.356235
R12747 n1_m1_81600_427200 n1_m1_86400_427200 5.356235
R12748 n1_m1_86400_427200 n1_m1_88000_427200 1.785412
R12749 n1_m1_91200_427200 n1_m1_88000_427200 3.570824
R12750 n1_m1_91200_427200 n1_m1_96000_427200 5.356235
R12751 n1_m1_96000_427200 n1_m1_100800_427200 5.356235
R12752 n1_m1_100800_427200 n1_m1_105600_427200 5.356235
R12753 n1_m1_105600_427200 n1_m1_110400_427200 5.356235
R12754 n1_m1_110400_427200 n1_m1_115200_427200 5.356235
R12755 n1_m1_115200_427200 n1_m1_116000_427200 0.892706
R12756 n1_m1_120000_427200 n1_m1_116000_427200 4.463529
R12757 n1_m1_120000_427200 n1_m1_124800_427200 5.356235
R12758 n1_m1_124800_427200 n1_m1_129600_427200 5.356235
R12759 n1_m1_129600_427200 n1_m1_134400_427200 5.356235
R12760 n1_m1_134400_427200 n1_m1_139200_427200 5.356235
R12761 n1_m1_139200_427200 n1_m1_144000_427200 5.356235
R12762 n1_m1_144000_427200 n1_m1_148800_427200 5.356235
R12763 n1_m1_148800_427200 n1_m1_153600_427200 5.356235
R12764 n1_m1_153600_427200 n1_m1_158400_427200 5.356235
R12765 n1_m1_158400_427200 n1_m1_163200_427200 5.356235
R12766 n1_m1_163200_427200 n1_m1_168000_427200 5.356235
R12767 n1_m1_168000_427200 n1_m1_172000_427200 4.463529
R12768 n1_m1_172800_427200 n1_m1_172000_427200 0.892706
R12769 n1_m1_172800_427200 n1_m1_177600_427200 5.356235
R12770 n1_m1_177600_427200 n1_m1_182400_427200 5.356235
R12771 n1_m1_182400_427200 n1_m1_187200_427200 5.356235
R12772 n1_m1_187200_427200 n1_m1_192000_427200 5.356235
R12773 n1_m1_192000_427200 n1_m1_196800_427200 5.356235
R12774 n1_m1_196800_427200 n1_m1_200000_427200 3.570824
R12775 n1_m1_201600_427200 n1_m1_200000_427200 1.785412
R12776 n1_m1_201600_427200 n1_m1_206400_427200 5.356235
R12777 n1_m1_206400_427200 n1_m1_211200_427200 5.356235
R12778 n1_m1_211200_427200 n1_m1_216000_427200 5.356235
R12779 n1_m1_216000_427200 n1_m1_220800_427200 5.356235
R12780 n1_m1_220800_427200 n1_m1_225600_427200 5.356235
R12781 n1_m1_225600_427200 n1_m1_228000_427200 2.678118
R12782 n1_m1_230400_427200 n1_m1_228000_427200 2.678118
R12783 n1_m1_230400_427200 n1_m1_235200_427200 5.356235
R12784 n1_m1_235200_427200 n1_m1_240000_427200 5.356235
R12785 n1_m1_240000_427200 n1_m1_244800_427200 5.356235
R12786 n1_m1_244800_427200 n1_m1_249600_427200 5.356235
R12787 n1_m1_249600_427200 n1_m1_254400_427200 5.356235
R12788 n1_m1_254400_427200 n1_m1_256000_427200 1.785412
R12789 n1_m1_259200_427200 n1_m1_256000_427200 3.570824
R12790 n1_m1_259200_427200 n1_m1_264000_427200 5.356235
R12791 n1_m1_264000_427200 n1_m1_268800_427200 5.356235
R12792 n1_m1_268800_427200 n1_m1_273600_427200 5.356235
R12793 n1_m1_273600_427200 n1_m1_278400_427200 5.356235
R12794 n1_m1_278400_427200 n1_m1_283200_427200 5.356235
R12795 n1_m1_283200_427200 n1_m1_284000_427200 0.892706
R12796 n1_m1_288000_427200 n1_m1_284000_427200 4.463529
R12797 n1_m1_288000_427200 n1_m1_292800_427200 5.356235
R12798 n1_m1_292800_427200 n1_m1_297600_427200 5.356235
R12799 n1_m1_297600_427200 n1_m1_302400_427200 5.356235
R12800 n1_m1_302400_427200 n1_m1_307200_427200 5.356235
R12801 n1_m1_307200_427200 n1_m1_312000_427200 5.356235
R12802 n1_m1_312000_427200 n1_m1_316800_427200 5.356235
R12803 n1_m1_316800_427200 n1_m1_321600_427200 5.356235
R12804 n1_m1_321600_427200 n1_m1_326400_427200 5.356235
R12805 n1_m1_326400_427200 n1_m1_331200_427200 5.356235
R12806 n1_m1_331200_427200 n1_m1_336000_427200 5.356235
R12807 n1_m1_336000_427200 n1_m1_340000_427200 4.463529
R12808 n1_m1_340800_427200 n1_m1_340000_427200 0.892706
R12809 n1_m1_340800_427200 n1_m1_345600_427200 5.356235
R12810 n1_m1_345600_427200 n1_m1_350400_427200 5.356235
R12811 n1_m1_350400_427200 n1_m1_355200_427200 5.356235
R12812 n1_m1_355200_427200 n1_m1_360000_427200 5.356235
R12813 n1_m1_360000_427200 n1_m1_364800_427200 5.356235
R12814 n1_m1_364800_427200 n1_m1_368000_427200 3.570824
R12815 n1_m1_369600_427200 n1_m1_368000_427200 1.785412
R12816 n1_m1_369600_427200 n1_m1_374400_427200 5.356235
R12817 n1_m1_374400_427200 n1_m1_379200_427200 5.356235
R12818 n1_m1_379200_427200 n1_m1_384000_427200 5.356235
R12819 n1_m1_384000_427200 n1_m1_388800_427200 5.356235
R12820 n1_m1_388800_427200 n1_m1_393600_427200 5.356235
R12821 n1_m1_393600_427200 n1_m1_396000_427200 2.678118
R12822 n1_m1_398400_427200 n1_m1_396000_427200 2.678118
R12823 n1_m1_398400_427200 n1_m1_403200_427200 5.356235
R12824 n1_m1_403200_427200 n1_m1_408000_427200 5.356235
R12825 n1_m1_408000_427200 n1_m1_412800_427200 5.356235
R12826 n1_m1_412800_427200 n1_m1_417600_427200 5.356235
R12827 n1_m1_417600_427200 n1_m1_422400_427200 5.356235
R12828 n1_m1_422400_427200 n1_m1_424000_427200 1.785412
R12829 n1_m1_427200_427200 n1_m1_424000_427200 3.570824
R12830 n1_m1_427200_427200 n1_m1_432000_427200 5.356235
R12831 n1_m1_432000_427200 n1_m1_436800_427200 5.356235
R12832 n1_m1_436800_427200 n1_m1_441600_427200 5.356235
R12833 n1_m1_441600_427200 n1_m1_446400_427200 5.356235
R12834 n1_m1_446400_427200 n1_m1_451200_427200 5.356235
R12835 n1_m1_451200_427200 n1_m1_452000_427200 0.892706
R12836 n1_m1_456000_427200 n1_m1_452000_427200 4.463529
R12837 n1_m1_456000_427200 n1_m1_460800_427200 5.356235
R12838 n1_m1_460800_427200 n1_m1_465600_427200 5.356235
R12839 n1_m1_465600_427200 n1_m1_470400_427200 5.356235
R12840 n1_m1_470400_427200 n1_m1_475200_427200 5.356235
R12841 n1_m1_475200_427200 n1_m1_480000_427200 5.356235
R12842 n1_m1_480000_427200 n1_m1_484800_427200 5.356235
R12843 n1_m1_484800_427200 n1_m1_489600_427200 5.356235
R12844 n1_m1_489600_427200 n1_m1_494400_427200 5.356235
R12845 n1_m1_494400_427200 n1_m1_499200_427200 5.356235
R12846 n1_m1_499200_427200 n1_m1_504000_427200 5.356235
R12847 n1_m1_504000_427200 n1_m1_508000_427200 4.463529
R12848 n1_m1_508800_427200 n1_m1_508000_427200 0.892706
R12849 n1_m1_508800_427200 n1_m1_513600_427200 5.356235
R12850 n1_m1_513600_427200 n1_m1_518400_427200 5.356235
R12851 n1_m1_518400_427200 n1_m1_523200_427200 5.356235
R12852 n1_m1_523200_427200 n1_m1_528000_427200 5.356235
R12853 n1_m1_528000_427200 n1_m1_532800_427200 5.356235
R12854 n1_m1_532800_427200 n1_m1_536000_427200 3.570824
R12855 n1_m1_537600_427200 n1_m1_536000_427200 1.785412
R12856 n1_m1_537600_427200 n1_m1_542400_427200 5.356235
R12857 n1_m1_542400_427200 n1_m1_547200_427200 5.356235
R12858 n1_m1_547200_427200 n1_m1_552000_427200 5.356235
R12859 n1_m1_552000_427200 n1_m1_556800_427200 5.356235
R12860 n1_m1_556800_427200 n1_m1_561600_427200 5.356235
R12861 n1_m1_561600_427200 n1_m1_564000_427200 2.678118
R12862 n1_m1_566400_427200 n1_m1_564000_427200 2.678118
R12863 n1_m1_566400_427200 n1_m1_571200_427200 5.356235
R12864 n1_m1_571200_427200 n1_m1_576000_427200 5.356235
R12865 n1_m1_576000_427200 n1_m1_580800_427200 5.356235
R12866 n1_m1_580800_427200 n1_m1_585600_427200 5.356235
R12867 n1_m1_585600_427200 n1_m1_590400_427200 5.356235
R12868 n1_m1_590400_427200 n1_m1_592000_427200 1.785412
R12869 n1_m1_595200_427200 n1_m1_592000_427200 3.570824
R12870 n1_m1_0_432000 n1_m1_4000_432000 4.463529
R12871 n1_m1_4800_432000 n1_m1_4000_432000 0.892706
R12872 n1_m1_4800_432000 n1_m1_9600_432000 5.356235
R12873 n1_m1_9600_432000 n1_m1_14400_432000 5.356235
R12874 n1_m1_14400_432000 n1_m1_19200_432000 5.356235
R12875 n1_m1_19200_432000 n1_m1_24000_432000 5.356235
R12876 n1_m1_24000_432000 n1_m1_28800_432000 5.356235
R12877 n1_m1_28800_432000 n1_m1_32000_432000 3.570824
R12878 n1_m1_33600_432000 n1_m1_32000_432000 1.785412
R12879 n1_m1_33600_432000 n1_m1_38400_432000 5.356235
R12880 n1_m1_38400_432000 n1_m1_43200_432000 5.356235
R12881 n1_m1_43200_432000 n1_m1_48000_432000 5.356235
R12882 n1_m1_48000_432000 n1_m1_52800_432000 5.356235
R12883 n1_m1_52800_432000 n1_m1_57600_432000 5.356235
R12884 n1_m1_57600_432000 n1_m1_60000_432000 2.678118
R12885 n1_m1_62400_432000 n1_m1_60000_432000 2.678118
R12886 n1_m1_62400_432000 n1_m1_67200_432000 5.356235
R12887 n1_m1_67200_432000 n1_m1_72000_432000 5.356235
R12888 n1_m1_72000_432000 n1_m1_76800_432000 5.356235
R12889 n1_m1_76800_432000 n1_m1_81600_432000 5.356235
R12890 n1_m1_81600_432000 n1_m1_86400_432000 5.356235
R12891 n1_m1_86400_432000 n1_m1_88000_432000 1.785412
R12892 n1_m1_91200_432000 n1_m1_88000_432000 3.570824
R12893 n1_m1_91200_432000 n1_m1_96000_432000 5.356235
R12894 n1_m1_96000_432000 n1_m1_100800_432000 5.356235
R12895 n1_m1_100800_432000 n1_m1_105600_432000 5.356235
R12896 n1_m1_105600_432000 n1_m1_110400_432000 5.356235
R12897 n1_m1_110400_432000 n1_m1_115200_432000 5.356235
R12898 n1_m1_115200_432000 n1_m1_116000_432000 0.892706
R12899 n1_m1_120000_432000 n1_m1_116000_432000 4.463529
R12900 n1_m1_120000_432000 n1_m1_124800_432000 5.356235
R12901 n1_m1_124800_432000 n1_m1_129600_432000 5.356235
R12902 n1_m1_129600_432000 n1_m1_134400_432000 5.356235
R12903 n1_m1_134400_432000 n1_m1_139200_432000 5.356235
R12904 n1_m1_139200_432000 n1_m1_144000_432000 5.356235
R12905 n1_m1_144000_432000 n1_m1_148800_432000 5.356235
R12906 n1_m1_148800_432000 n1_m1_153600_432000 5.356235
R12907 n1_m1_153600_432000 n1_m1_158400_432000 5.356235
R12908 n1_m1_158400_432000 n1_m1_163200_432000 5.356235
R12909 n1_m1_163200_432000 n1_m1_168000_432000 5.356235
R12910 n1_m1_168000_432000 n1_m1_172000_432000 4.463529
R12911 n1_m1_172800_432000 n1_m1_172000_432000 0.892706
R12912 n1_m1_172800_432000 n1_m1_177600_432000 5.356235
R12913 n1_m1_177600_432000 n1_m1_182400_432000 5.356235
R12914 n1_m1_182400_432000 n1_m1_187200_432000 5.356235
R12915 n1_m1_187200_432000 n1_m1_192000_432000 5.356235
R12916 n1_m1_192000_432000 n1_m1_196800_432000 5.356235
R12917 n1_m1_196800_432000 n1_m1_200000_432000 3.570824
R12918 n1_m1_201600_432000 n1_m1_200000_432000 1.785412
R12919 n1_m1_201600_432000 n1_m1_206400_432000 5.356235
R12920 n1_m1_206400_432000 n1_m1_211200_432000 5.356235
R12921 n1_m1_211200_432000 n1_m1_216000_432000 5.356235
R12922 n1_m1_216000_432000 n1_m1_220800_432000 5.356235
R12923 n1_m1_220800_432000 n1_m1_225600_432000 5.356235
R12924 n1_m1_225600_432000 n1_m1_228000_432000 2.678118
R12925 n1_m1_230400_432000 n1_m1_228000_432000 2.678118
R12926 n1_m1_230400_432000 n1_m1_235200_432000 5.356235
R12927 n1_m1_235200_432000 n1_m1_240000_432000 5.356235
R12928 n1_m1_240000_432000 n1_m1_244800_432000 5.356235
R12929 n1_m1_244800_432000 n1_m1_249600_432000 5.356235
R12930 n1_m1_249600_432000 n1_m1_254400_432000 5.356235
R12931 n1_m1_254400_432000 n1_m1_256000_432000 1.785412
R12932 n1_m1_259200_432000 n1_m1_256000_432000 3.570824
R12933 n1_m1_259200_432000 n1_m1_264000_432000 5.356235
R12934 n1_m1_264000_432000 n1_m1_268800_432000 5.356235
R12935 n1_m1_268800_432000 n1_m1_273600_432000 5.356235
R12936 n1_m1_273600_432000 n1_m1_278400_432000 5.356235
R12937 n1_m1_278400_432000 n1_m1_283200_432000 5.356235
R12938 n1_m1_283200_432000 n1_m1_284000_432000 0.892706
R12939 n1_m1_288000_432000 n1_m1_284000_432000 4.463529
R12940 n1_m1_288000_432000 n1_m1_292800_432000 5.356235
R12941 n1_m1_292800_432000 n1_m1_297600_432000 5.356235
R12942 n1_m1_297600_432000 n1_m1_302400_432000 5.356235
R12943 n1_m1_302400_432000 n1_m1_307200_432000 5.356235
R12944 n1_m1_307200_432000 n1_m1_312000_432000 5.356235
R12945 n1_m1_312000_432000 n1_m1_316800_432000 5.356235
R12946 n1_m1_316800_432000 n1_m1_321600_432000 5.356235
R12947 n1_m1_321600_432000 n1_m1_326400_432000 5.356235
R12948 n1_m1_326400_432000 n1_m1_331200_432000 5.356235
R12949 n1_m1_331200_432000 n1_m1_336000_432000 5.356235
R12950 n1_m1_336000_432000 n1_m1_340000_432000 4.463529
R12951 n1_m1_340800_432000 n1_m1_340000_432000 0.892706
R12952 n1_m1_340800_432000 n1_m1_345600_432000 5.356235
R12953 n1_m1_345600_432000 n1_m1_350400_432000 5.356235
R12954 n1_m1_350400_432000 n1_m1_355200_432000 5.356235
R12955 n1_m1_355200_432000 n1_m1_360000_432000 5.356235
R12956 n1_m1_360000_432000 n1_m1_364800_432000 5.356235
R12957 n1_m1_364800_432000 n1_m1_368000_432000 3.570824
R12958 n1_m1_369600_432000 n1_m1_368000_432000 1.785412
R12959 n1_m1_369600_432000 n1_m1_374400_432000 5.356235
R12960 n1_m1_374400_432000 n1_m1_379200_432000 5.356235
R12961 n1_m1_379200_432000 n1_m1_384000_432000 5.356235
R12962 n1_m1_384000_432000 n1_m1_388800_432000 5.356235
R12963 n1_m1_388800_432000 n1_m1_393600_432000 5.356235
R12964 n1_m1_393600_432000 n1_m1_396000_432000 2.678118
R12965 n1_m1_398400_432000 n1_m1_396000_432000 2.678118
R12966 n1_m1_398400_432000 n1_m1_403200_432000 5.356235
R12967 n1_m1_403200_432000 n1_m1_408000_432000 5.356235
R12968 n1_m1_408000_432000 n1_m1_412800_432000 5.356235
R12969 n1_m1_412800_432000 n1_m1_417600_432000 5.356235
R12970 n1_m1_417600_432000 n1_m1_422400_432000 5.356235
R12971 n1_m1_422400_432000 n1_m1_424000_432000 1.785412
R12972 n1_m1_427200_432000 n1_m1_424000_432000 3.570824
R12973 n1_m1_427200_432000 n1_m1_432000_432000 5.356235
R12974 n1_m1_432000_432000 n1_m1_436800_432000 5.356235
R12975 n1_m1_436800_432000 n1_m1_441600_432000 5.356235
R12976 n1_m1_441600_432000 n1_m1_446400_432000 5.356235
R12977 n1_m1_446400_432000 n1_m1_451200_432000 5.356235
R12978 n1_m1_451200_432000 n1_m1_452000_432000 0.892706
R12979 n1_m1_456000_432000 n1_m1_452000_432000 4.463529
R12980 n1_m1_456000_432000 n1_m1_460800_432000 5.356235
R12981 n1_m1_460800_432000 n1_m1_465600_432000 5.356235
R12982 n1_m1_465600_432000 n1_m1_470400_432000 5.356235
R12983 n1_m1_470400_432000 n1_m1_475200_432000 5.356235
R12984 n1_m1_475200_432000 n1_m1_480000_432000 5.356235
R12985 n1_m1_480000_432000 n1_m1_484800_432000 5.356235
R12986 n1_m1_484800_432000 n1_m1_489600_432000 5.356235
R12987 n1_m1_489600_432000 n1_m1_494400_432000 5.356235
R12988 n1_m1_494400_432000 n1_m1_499200_432000 5.356235
R12989 n1_m1_499200_432000 n1_m1_504000_432000 5.356235
R12990 n1_m1_504000_432000 n1_m1_508000_432000 4.463529
R12991 n1_m1_508800_432000 n1_m1_508000_432000 0.892706
R12992 n1_m1_508800_432000 n1_m1_513600_432000 5.356235
R12993 n1_m1_513600_432000 n1_m1_518400_432000 5.356235
R12994 n1_m1_518400_432000 n1_m1_523200_432000 5.356235
R12995 n1_m1_523200_432000 n1_m1_528000_432000 5.356235
R12996 n1_m1_528000_432000 n1_m1_532800_432000 5.356235
R12997 n1_m1_532800_432000 n1_m1_536000_432000 3.570824
R12998 n1_m1_537600_432000 n1_m1_536000_432000 1.785412
R12999 n1_m1_537600_432000 n1_m1_542400_432000 5.356235
R13000 n1_m1_542400_432000 n1_m1_547200_432000 5.356235
R13001 n1_m1_547200_432000 n1_m1_552000_432000 5.356235
R13002 n1_m1_552000_432000 n1_m1_556800_432000 5.356235
R13003 n1_m1_556800_432000 n1_m1_561600_432000 5.356235
R13004 n1_m1_561600_432000 n1_m1_564000_432000 2.678118
R13005 n1_m1_566400_432000 n1_m1_564000_432000 2.678118
R13006 n1_m1_566400_432000 n1_m1_571200_432000 5.356235
R13007 n1_m1_571200_432000 n1_m1_576000_432000 5.356235
R13008 n1_m1_576000_432000 n1_m1_580800_432000 5.356235
R13009 n1_m1_580800_432000 n1_m1_585600_432000 5.356235
R13010 n1_m1_585600_432000 n1_m1_590400_432000 5.356235
R13011 n1_m1_590400_432000 n1_m1_592000_432000 1.785412
R13012 n1_m1_595200_432000 n1_m1_592000_432000 3.570824
R13013 n1_m1_0_436800 n1_m1_4000_436800 4.463529
R13014 n1_m1_4800_436800 n1_m1_4000_436800 0.892706
R13015 n1_m1_4800_436800 n1_m1_9600_436800 5.356235
R13016 n1_m1_9600_436800 n1_m1_14400_436800 5.356235
R13017 n1_m1_14400_436800 n1_m1_19200_436800 5.356235
R13018 n1_m1_19200_436800 n1_m1_24000_436800 5.356235
R13019 n1_m1_24000_436800 n1_m1_28800_436800 5.356235
R13020 n1_m1_28800_436800 n1_m1_32000_436800 3.570824
R13021 n1_m1_33600_436800 n1_m1_32000_436800 1.785412
R13022 n1_m1_33600_436800 n1_m1_38400_436800 5.356235
R13023 n1_m1_38400_436800 n1_m1_43200_436800 5.356235
R13024 n1_m1_43200_436800 n1_m1_48000_436800 5.356235
R13025 n1_m1_48000_436800 n1_m1_52800_436800 5.356235
R13026 n1_m1_52800_436800 n1_m1_57600_436800 5.356235
R13027 n1_m1_57600_436800 n1_m1_60000_436800 2.678118
R13028 n1_m1_62400_436800 n1_m1_60000_436800 2.678118
R13029 n1_m1_62400_436800 n1_m1_67200_436800 5.356235
R13030 n1_m1_67200_436800 n1_m1_72000_436800 5.356235
R13031 n1_m1_72000_436800 n1_m1_76800_436800 5.356235
R13032 n1_m1_76800_436800 n1_m1_81600_436800 5.356235
R13033 n1_m1_81600_436800 n1_m1_86400_436800 5.356235
R13034 n1_m1_86400_436800 n1_m1_88000_436800 1.785412
R13035 n1_m1_91200_436800 n1_m1_88000_436800 3.570824
R13036 n1_m1_91200_436800 n1_m1_96000_436800 5.356235
R13037 n1_m1_96000_436800 n1_m1_100800_436800 5.356235
R13038 n1_m1_100800_436800 n1_m1_105600_436800 5.356235
R13039 n1_m1_105600_436800 n1_m1_110400_436800 5.356235
R13040 n1_m1_110400_436800 n1_m1_115200_436800 5.356235
R13041 n1_m1_115200_436800 n1_m1_116000_436800 0.892706
R13042 n1_m1_120000_436800 n1_m1_116000_436800 4.463529
R13043 n1_m1_120000_436800 n1_m1_124800_436800 5.356235
R13044 n1_m1_124800_436800 n1_m1_129600_436800 5.356235
R13045 n1_m1_129600_436800 n1_m1_134400_436800 5.356235
R13046 n1_m1_134400_436800 n1_m1_139200_436800 5.356235
R13047 n1_m1_139200_436800 n1_m1_144000_436800 5.356235
R13048 n1_m1_144000_436800 n1_m1_148800_436800 5.356235
R13049 n1_m1_148800_436800 n1_m1_153600_436800 5.356235
R13050 n1_m1_153600_436800 n1_m1_158400_436800 5.356235
R13051 n1_m1_158400_436800 n1_m1_163200_436800 5.356235
R13052 n1_m1_163200_436800 n1_m1_168000_436800 5.356235
R13053 n1_m1_168000_436800 n1_m1_172000_436800 4.463529
R13054 n1_m1_172800_436800 n1_m1_172000_436800 0.892706
R13055 n1_m1_172800_436800 n1_m1_177600_436800 5.356235
R13056 n1_m1_177600_436800 n1_m1_182400_436800 5.356235
R13057 n1_m1_182400_436800 n1_m1_187200_436800 5.356235
R13058 n1_m1_187200_436800 n1_m1_192000_436800 5.356235
R13059 n1_m1_192000_436800 n1_m1_196800_436800 5.356235
R13060 n1_m1_196800_436800 n1_m1_200000_436800 3.570824
R13061 n1_m1_201600_436800 n1_m1_200000_436800 1.785412
R13062 n1_m1_201600_436800 n1_m1_206400_436800 5.356235
R13063 n1_m1_206400_436800 n1_m1_211200_436800 5.356235
R13064 n1_m1_211200_436800 n1_m1_216000_436800 5.356235
R13065 n1_m1_216000_436800 n1_m1_220800_436800 5.356235
R13066 n1_m1_220800_436800 n1_m1_225600_436800 5.356235
R13067 n1_m1_225600_436800 n1_m1_228000_436800 2.678118
R13068 n1_m1_230400_436800 n1_m1_228000_436800 2.678118
R13069 n1_m1_230400_436800 n1_m1_235200_436800 5.356235
R13070 n1_m1_235200_436800 n1_m1_240000_436800 5.356235
R13071 n1_m1_240000_436800 n1_m1_244800_436800 5.356235
R13072 n1_m1_244800_436800 n1_m1_249600_436800 5.356235
R13073 n1_m1_249600_436800 n1_m1_254400_436800 5.356235
R13074 n1_m1_254400_436800 n1_m1_256000_436800 1.785412
R13075 n1_m1_259200_436800 n1_m1_256000_436800 3.570824
R13076 n1_m1_259200_436800 n1_m1_264000_436800 5.356235
R13077 n1_m1_264000_436800 n1_m1_268800_436800 5.356235
R13078 n1_m1_268800_436800 n1_m1_273600_436800 5.356235
R13079 n1_m1_273600_436800 n1_m1_278400_436800 5.356235
R13080 n1_m1_278400_436800 n1_m1_283200_436800 5.356235
R13081 n1_m1_283200_436800 n1_m1_284000_436800 0.892706
R13082 n1_m1_288000_436800 n1_m1_284000_436800 4.463529
R13083 n1_m1_288000_436800 n1_m1_292800_436800 5.356235
R13084 n1_m1_292800_436800 n1_m1_297600_436800 5.356235
R13085 n1_m1_297600_436800 n1_m1_302400_436800 5.356235
R13086 n1_m1_302400_436800 n1_m1_307200_436800 5.356235
R13087 n1_m1_307200_436800 n1_m1_312000_436800 5.356235
R13088 n1_m1_312000_436800 n1_m1_316800_436800 5.356235
R13089 n1_m1_316800_436800 n1_m1_321600_436800 5.356235
R13090 n1_m1_321600_436800 n1_m1_326400_436800 5.356235
R13091 n1_m1_326400_436800 n1_m1_331200_436800 5.356235
R13092 n1_m1_331200_436800 n1_m1_336000_436800 5.356235
R13093 n1_m1_336000_436800 n1_m1_340000_436800 4.463529
R13094 n1_m1_340800_436800 n1_m1_340000_436800 0.892706
R13095 n1_m1_340800_436800 n1_m1_345600_436800 5.356235
R13096 n1_m1_345600_436800 n1_m1_350400_436800 5.356235
R13097 n1_m1_350400_436800 n1_m1_355200_436800 5.356235
R13098 n1_m1_355200_436800 n1_m1_360000_436800 5.356235
R13099 n1_m1_360000_436800 n1_m1_364800_436800 5.356235
R13100 n1_m1_364800_436800 n1_m1_368000_436800 3.570824
R13101 n1_m1_369600_436800 n1_m1_368000_436800 1.785412
R13102 n1_m1_369600_436800 n1_m1_374400_436800 5.356235
R13103 n1_m1_374400_436800 n1_m1_379200_436800 5.356235
R13104 n1_m1_379200_436800 n1_m1_384000_436800 5.356235
R13105 n1_m1_384000_436800 n1_m1_388800_436800 5.356235
R13106 n1_m1_388800_436800 n1_m1_393600_436800 5.356235
R13107 n1_m1_393600_436800 n1_m1_396000_436800 2.678118
R13108 n1_m1_398400_436800 n1_m1_396000_436800 2.678118
R13109 n1_m1_398400_436800 n1_m1_403200_436800 5.356235
R13110 n1_m1_403200_436800 n1_m1_408000_436800 5.356235
R13111 n1_m1_408000_436800 n1_m1_412800_436800 5.356235
R13112 n1_m1_412800_436800 n1_m1_417600_436800 5.356235
R13113 n1_m1_417600_436800 n1_m1_422400_436800 5.356235
R13114 n1_m1_422400_436800 n1_m1_424000_436800 1.785412
R13115 n1_m1_427200_436800 n1_m1_424000_436800 3.570824
R13116 n1_m1_427200_436800 n1_m1_432000_436800 5.356235
R13117 n1_m1_432000_436800 n1_m1_436800_436800 5.356235
R13118 n1_m1_436800_436800 n1_m1_441600_436800 5.356235
R13119 n1_m1_441600_436800 n1_m1_446400_436800 5.356235
R13120 n1_m1_446400_436800 n1_m1_451200_436800 5.356235
R13121 n1_m1_451200_436800 n1_m1_452000_436800 0.892706
R13122 n1_m1_456000_436800 n1_m1_452000_436800 4.463529
R13123 n1_m1_456000_436800 n1_m1_460800_436800 5.356235
R13124 n1_m1_460800_436800 n1_m1_465600_436800 5.356235
R13125 n1_m1_465600_436800 n1_m1_470400_436800 5.356235
R13126 n1_m1_470400_436800 n1_m1_475200_436800 5.356235
R13127 n1_m1_475200_436800 n1_m1_480000_436800 5.356235
R13128 n1_m1_480000_436800 n1_m1_484800_436800 5.356235
R13129 n1_m1_484800_436800 n1_m1_489600_436800 5.356235
R13130 n1_m1_489600_436800 n1_m1_494400_436800 5.356235
R13131 n1_m1_494400_436800 n1_m1_499200_436800 5.356235
R13132 n1_m1_499200_436800 n1_m1_504000_436800 5.356235
R13133 n1_m1_504000_436800 n1_m1_508000_436800 4.463529
R13134 n1_m1_508800_436800 n1_m1_508000_436800 0.892706
R13135 n1_m1_508800_436800 n1_m1_513600_436800 5.356235
R13136 n1_m1_513600_436800 n1_m1_518400_436800 5.356235
R13137 n1_m1_518400_436800 n1_m1_523200_436800 5.356235
R13138 n1_m1_523200_436800 n1_m1_528000_436800 5.356235
R13139 n1_m1_528000_436800 n1_m1_532800_436800 5.356235
R13140 n1_m1_532800_436800 n1_m1_536000_436800 3.570824
R13141 n1_m1_537600_436800 n1_m1_536000_436800 1.785412
R13142 n1_m1_537600_436800 n1_m1_542400_436800 5.356235
R13143 n1_m1_542400_436800 n1_m1_547200_436800 5.356235
R13144 n1_m1_547200_436800 n1_m1_552000_436800 5.356235
R13145 n1_m1_552000_436800 n1_m1_556800_436800 5.356235
R13146 n1_m1_556800_436800 n1_m1_561600_436800 5.356235
R13147 n1_m1_561600_436800 n1_m1_564000_436800 2.678118
R13148 n1_m1_566400_436800 n1_m1_564000_436800 2.678118
R13149 n1_m1_566400_436800 n1_m1_571200_436800 5.356235
R13150 n1_m1_571200_436800 n1_m1_576000_436800 5.356235
R13151 n1_m1_576000_436800 n1_m1_580800_436800 5.356235
R13152 n1_m1_580800_436800 n1_m1_585600_436800 5.356235
R13153 n1_m1_585600_436800 n1_m1_590400_436800 5.356235
R13154 n1_m1_590400_436800 n1_m1_592000_436800 1.785412
R13155 n1_m1_595200_436800 n1_m1_592000_436800 3.570824
R13156 n1_m1_0_441600 n1_m1_4000_441600 4.463529
R13157 n1_m1_4800_441600 n1_m1_4000_441600 0.892706
R13158 n1_m1_4800_441600 n1_m1_9600_441600 5.356235
R13159 n1_m1_9600_441600 n1_m1_14400_441600 5.356235
R13160 n1_m1_14400_441600 n1_m1_19200_441600 5.356235
R13161 n1_m1_19200_441600 n1_m1_24000_441600 5.356235
R13162 n1_m1_24000_441600 n1_m1_28800_441600 5.356235
R13163 n1_m1_28800_441600 n1_m1_32000_441600 3.570824
R13164 n1_m1_33600_441600 n1_m1_32000_441600 1.785412
R13165 n1_m1_33600_441600 n1_m1_38400_441600 5.356235
R13166 n1_m1_38400_441600 n1_m1_43200_441600 5.356235
R13167 n1_m1_43200_441600 n1_m1_48000_441600 5.356235
R13168 n1_m1_48000_441600 n1_m1_52800_441600 5.356235
R13169 n1_m1_52800_441600 n1_m1_57600_441600 5.356235
R13170 n1_m1_57600_441600 n1_m1_60000_441600 2.678118
R13171 n1_m1_62400_441600 n1_m1_60000_441600 2.678118
R13172 n1_m1_62400_441600 n1_m1_67200_441600 5.356235
R13173 n1_m1_67200_441600 n1_m1_72000_441600 5.356235
R13174 n1_m1_72000_441600 n1_m1_76800_441600 5.356235
R13175 n1_m1_76800_441600 n1_m1_81600_441600 5.356235
R13176 n1_m1_81600_441600 n1_m1_86400_441600 5.356235
R13177 n1_m1_86400_441600 n1_m1_88000_441600 1.785412
R13178 n1_m1_91200_441600 n1_m1_88000_441600 3.570824
R13179 n1_m1_91200_441600 n1_m1_96000_441600 5.356235
R13180 n1_m1_96000_441600 n1_m1_100800_441600 5.356235
R13181 n1_m1_100800_441600 n1_m1_105600_441600 5.356235
R13182 n1_m1_105600_441600 n1_m1_110400_441600 5.356235
R13183 n1_m1_110400_441600 n1_m1_115200_441600 5.356235
R13184 n1_m1_115200_441600 n1_m1_116000_441600 0.892706
R13185 n1_m1_120000_441600 n1_m1_116000_441600 4.463529
R13186 n1_m1_120000_441600 n1_m1_124800_441600 5.356235
R13187 n1_m1_124800_441600 n1_m1_129600_441600 5.356235
R13188 n1_m1_129600_441600 n1_m1_134400_441600 5.356235
R13189 n1_m1_134400_441600 n1_m1_139200_441600 5.356235
R13190 n1_m1_139200_441600 n1_m1_144000_441600 5.356235
R13191 n1_m1_144000_441600 n1_m1_148800_441600 5.356235
R13192 n1_m1_148800_441600 n1_m1_153600_441600 5.356235
R13193 n1_m1_153600_441600 n1_m1_158400_441600 5.356235
R13194 n1_m1_158400_441600 n1_m1_163200_441600 5.356235
R13195 n1_m1_163200_441600 n1_m1_168000_441600 5.356235
R13196 n1_m1_168000_441600 n1_m1_172000_441600 4.463529
R13197 n1_m1_172800_441600 n1_m1_172000_441600 0.892706
R13198 n1_m1_172800_441600 n1_m1_177600_441600 5.356235
R13199 n1_m1_177600_441600 n1_m1_182400_441600 5.356235
R13200 n1_m1_182400_441600 n1_m1_187200_441600 5.356235
R13201 n1_m1_187200_441600 n1_m1_192000_441600 5.356235
R13202 n1_m1_192000_441600 n1_m1_196800_441600 5.356235
R13203 n1_m1_196800_441600 n1_m1_200000_441600 3.570824
R13204 n1_m1_201600_441600 n1_m1_200000_441600 1.785412
R13205 n1_m1_201600_441600 n1_m1_206400_441600 5.356235
R13206 n1_m1_206400_441600 n1_m1_211200_441600 5.356235
R13207 n1_m1_211200_441600 n1_m1_216000_441600 5.356235
R13208 n1_m1_216000_441600 n1_m1_220800_441600 5.356235
R13209 n1_m1_220800_441600 n1_m1_225600_441600 5.356235
R13210 n1_m1_225600_441600 n1_m1_228000_441600 2.678118
R13211 n1_m1_230400_441600 n1_m1_228000_441600 2.678118
R13212 n1_m1_230400_441600 n1_m1_235200_441600 5.356235
R13213 n1_m1_235200_441600 n1_m1_240000_441600 5.356235
R13214 n1_m1_240000_441600 n1_m1_244800_441600 5.356235
R13215 n1_m1_244800_441600 n1_m1_249600_441600 5.356235
R13216 n1_m1_249600_441600 n1_m1_254400_441600 5.356235
R13217 n1_m1_254400_441600 n1_m1_256000_441600 1.785412
R13218 n1_m1_259200_441600 n1_m1_256000_441600 3.570824
R13219 n1_m1_259200_441600 n1_m1_264000_441600 5.356235
R13220 n1_m1_264000_441600 n1_m1_268800_441600 5.356235
R13221 n1_m1_268800_441600 n1_m1_273600_441600 5.356235
R13222 n1_m1_273600_441600 n1_m1_278400_441600 5.356235
R13223 n1_m1_278400_441600 n1_m1_283200_441600 5.356235
R13224 n1_m1_283200_441600 n1_m1_284000_441600 0.892706
R13225 n1_m1_288000_441600 n1_m1_284000_441600 4.463529
R13226 n1_m1_288000_441600 n1_m1_292800_441600 5.356235
R13227 n1_m1_292800_441600 n1_m1_297600_441600 5.356235
R13228 n1_m1_297600_441600 n1_m1_302400_441600 5.356235
R13229 n1_m1_302400_441600 n1_m1_307200_441600 5.356235
R13230 n1_m1_307200_441600 n1_m1_312000_441600 5.356235
R13231 n1_m1_312000_441600 n1_m1_316800_441600 5.356235
R13232 n1_m1_316800_441600 n1_m1_321600_441600 5.356235
R13233 n1_m1_321600_441600 n1_m1_326400_441600 5.356235
R13234 n1_m1_326400_441600 n1_m1_331200_441600 5.356235
R13235 n1_m1_331200_441600 n1_m1_336000_441600 5.356235
R13236 n1_m1_336000_441600 n1_m1_340000_441600 4.463529
R13237 n1_m1_340800_441600 n1_m1_340000_441600 0.892706
R13238 n1_m1_340800_441600 n1_m1_345600_441600 5.356235
R13239 n1_m1_345600_441600 n1_m1_350400_441600 5.356235
R13240 n1_m1_350400_441600 n1_m1_355200_441600 5.356235
R13241 n1_m1_355200_441600 n1_m1_360000_441600 5.356235
R13242 n1_m1_360000_441600 n1_m1_364800_441600 5.356235
R13243 n1_m1_364800_441600 n1_m1_368000_441600 3.570824
R13244 n1_m1_369600_441600 n1_m1_368000_441600 1.785412
R13245 n1_m1_369600_441600 n1_m1_374400_441600 5.356235
R13246 n1_m1_374400_441600 n1_m1_379200_441600 5.356235
R13247 n1_m1_379200_441600 n1_m1_384000_441600 5.356235
R13248 n1_m1_384000_441600 n1_m1_388800_441600 5.356235
R13249 n1_m1_388800_441600 n1_m1_393600_441600 5.356235
R13250 n1_m1_393600_441600 n1_m1_396000_441600 2.678118
R13251 n1_m1_398400_441600 n1_m1_396000_441600 2.678118
R13252 n1_m1_398400_441600 n1_m1_403200_441600 5.356235
R13253 n1_m1_403200_441600 n1_m1_408000_441600 5.356235
R13254 n1_m1_408000_441600 n1_m1_412800_441600 5.356235
R13255 n1_m1_412800_441600 n1_m1_417600_441600 5.356235
R13256 n1_m1_417600_441600 n1_m1_422400_441600 5.356235
R13257 n1_m1_422400_441600 n1_m1_424000_441600 1.785412
R13258 n1_m1_427200_441600 n1_m1_424000_441600 3.570824
R13259 n1_m1_427200_441600 n1_m1_432000_441600 5.356235
R13260 n1_m1_432000_441600 n1_m1_436800_441600 5.356235
R13261 n1_m1_436800_441600 n1_m1_441600_441600 5.356235
R13262 n1_m1_441600_441600 n1_m1_446400_441600 5.356235
R13263 n1_m1_446400_441600 n1_m1_451200_441600 5.356235
R13264 n1_m1_451200_441600 n1_m1_452000_441600 0.892706
R13265 n1_m1_456000_441600 n1_m1_452000_441600 4.463529
R13266 n1_m1_456000_441600 n1_m1_460800_441600 5.356235
R13267 n1_m1_460800_441600 n1_m1_465600_441600 5.356235
R13268 n1_m1_465600_441600 n1_m1_470400_441600 5.356235
R13269 n1_m1_470400_441600 n1_m1_475200_441600 5.356235
R13270 n1_m1_475200_441600 n1_m1_480000_441600 5.356235
R13271 n1_m1_480000_441600 n1_m1_484800_441600 5.356235
R13272 n1_m1_484800_441600 n1_m1_489600_441600 5.356235
R13273 n1_m1_489600_441600 n1_m1_494400_441600 5.356235
R13274 n1_m1_494400_441600 n1_m1_499200_441600 5.356235
R13275 n1_m1_499200_441600 n1_m1_504000_441600 5.356235
R13276 n1_m1_504000_441600 n1_m1_508000_441600 4.463529
R13277 n1_m1_508800_441600 n1_m1_508000_441600 0.892706
R13278 n1_m1_508800_441600 n1_m1_513600_441600 5.356235
R13279 n1_m1_513600_441600 n1_m1_518400_441600 5.356235
R13280 n1_m1_518400_441600 n1_m1_523200_441600 5.356235
R13281 n1_m1_523200_441600 n1_m1_528000_441600 5.356235
R13282 n1_m1_528000_441600 n1_m1_532800_441600 5.356235
R13283 n1_m1_532800_441600 n1_m1_536000_441600 3.570824
R13284 n1_m1_537600_441600 n1_m1_536000_441600 1.785412
R13285 n1_m1_537600_441600 n1_m1_542400_441600 5.356235
R13286 n1_m1_542400_441600 n1_m1_547200_441600 5.356235
R13287 n1_m1_547200_441600 n1_m1_552000_441600 5.356235
R13288 n1_m1_552000_441600 n1_m1_556800_441600 5.356235
R13289 n1_m1_556800_441600 n1_m1_561600_441600 5.356235
R13290 n1_m1_561600_441600 n1_m1_564000_441600 2.678118
R13291 n1_m1_566400_441600 n1_m1_564000_441600 2.678118
R13292 n1_m1_566400_441600 n1_m1_571200_441600 5.356235
R13293 n1_m1_571200_441600 n1_m1_576000_441600 5.356235
R13294 n1_m1_576000_441600 n1_m1_580800_441600 5.356235
R13295 n1_m1_580800_441600 n1_m1_585600_441600 5.356235
R13296 n1_m1_585600_441600 n1_m1_590400_441600 5.356235
R13297 n1_m1_590400_441600 n1_m1_592000_441600 1.785412
R13298 n1_m1_595200_441600 n1_m1_592000_441600 3.570824
R13299 n1_m1_0_446400 n1_m1_4000_446400 4.463529
R13300 n1_m1_4800_446400 n1_m1_4000_446400 0.892706
R13301 n1_m1_4800_446400 n1_m1_9600_446400 5.356235
R13302 n1_m1_9600_446400 n1_m1_14400_446400 5.356235
R13303 n1_m1_14400_446400 n1_m1_19200_446400 5.356235
R13304 n1_m1_19200_446400 n1_m1_24000_446400 5.356235
R13305 n1_m1_24000_446400 n1_m1_28800_446400 5.356235
R13306 n1_m1_28800_446400 n1_m1_32000_446400 3.570824
R13307 n1_m1_33600_446400 n1_m1_32000_446400 1.785412
R13308 n1_m1_33600_446400 n1_m1_38400_446400 5.356235
R13309 n1_m1_38400_446400 n1_m1_43200_446400 5.356235
R13310 n1_m1_43200_446400 n1_m1_48000_446400 5.356235
R13311 n1_m1_48000_446400 n1_m1_52800_446400 5.356235
R13312 n1_m1_52800_446400 n1_m1_57600_446400 5.356235
R13313 n1_m1_57600_446400 n1_m1_60000_446400 2.678118
R13314 n1_m1_62400_446400 n1_m1_60000_446400 2.678118
R13315 n1_m1_62400_446400 n1_m1_67200_446400 5.356235
R13316 n1_m1_67200_446400 n1_m1_72000_446400 5.356235
R13317 n1_m1_72000_446400 n1_m1_76800_446400 5.356235
R13318 n1_m1_76800_446400 n1_m1_81600_446400 5.356235
R13319 n1_m1_81600_446400 n1_m1_86400_446400 5.356235
R13320 n1_m1_86400_446400 n1_m1_88000_446400 1.785412
R13321 n1_m1_91200_446400 n1_m1_88000_446400 3.570824
R13322 n1_m1_91200_446400 n1_m1_96000_446400 5.356235
R13323 n1_m1_96000_446400 n1_m1_100800_446400 5.356235
R13324 n1_m1_100800_446400 n1_m1_105600_446400 5.356235
R13325 n1_m1_105600_446400 n1_m1_110400_446400 5.356235
R13326 n1_m1_110400_446400 n1_m1_115200_446400 5.356235
R13327 n1_m1_115200_446400 n1_m1_116000_446400 0.892706
R13328 n1_m1_120000_446400 n1_m1_116000_446400 4.463529
R13329 n1_m1_120000_446400 n1_m1_124800_446400 5.356235
R13330 n1_m1_124800_446400 n1_m1_129600_446400 5.356235
R13331 n1_m1_129600_446400 n1_m1_134400_446400 5.356235
R13332 n1_m1_134400_446400 n1_m1_139200_446400 5.356235
R13333 n1_m1_139200_446400 n1_m1_144000_446400 5.356235
R13334 n1_m1_144000_446400 n1_m1_148800_446400 5.356235
R13335 n1_m1_148800_446400 n1_m1_153600_446400 5.356235
R13336 n1_m1_153600_446400 n1_m1_158400_446400 5.356235
R13337 n1_m1_158400_446400 n1_m1_163200_446400 5.356235
R13338 n1_m1_163200_446400 n1_m1_168000_446400 5.356235
R13339 n1_m1_168000_446400 n1_m1_172000_446400 4.463529
R13340 n1_m1_172800_446400 n1_m1_172000_446400 0.892706
R13341 n1_m1_172800_446400 n1_m1_177600_446400 5.356235
R13342 n1_m1_177600_446400 n1_m1_182400_446400 5.356235
R13343 n1_m1_182400_446400 n1_m1_187200_446400 5.356235
R13344 n1_m1_187200_446400 n1_m1_192000_446400 5.356235
R13345 n1_m1_192000_446400 n1_m1_196800_446400 5.356235
R13346 n1_m1_196800_446400 n1_m1_200000_446400 3.570824
R13347 n1_m1_201600_446400 n1_m1_200000_446400 1.785412
R13348 n1_m1_201600_446400 n1_m1_206400_446400 5.356235
R13349 n1_m1_206400_446400 n1_m1_211200_446400 5.356235
R13350 n1_m1_211200_446400 n1_m1_216000_446400 5.356235
R13351 n1_m1_216000_446400 n1_m1_220800_446400 5.356235
R13352 n1_m1_220800_446400 n1_m1_225600_446400 5.356235
R13353 n1_m1_225600_446400 n1_m1_228000_446400 2.678118
R13354 n1_m1_230400_446400 n1_m1_228000_446400 2.678118
R13355 n1_m1_230400_446400 n1_m1_235200_446400 5.356235
R13356 n1_m1_235200_446400 n1_m1_240000_446400 5.356235
R13357 n1_m1_240000_446400 n1_m1_244800_446400 5.356235
R13358 n1_m1_244800_446400 n1_m1_249600_446400 5.356235
R13359 n1_m1_249600_446400 n1_m1_254400_446400 5.356235
R13360 n1_m1_254400_446400 n1_m1_256000_446400 1.785412
R13361 n1_m1_259200_446400 n1_m1_256000_446400 3.570824
R13362 n1_m1_259200_446400 n1_m1_264000_446400 5.356235
R13363 n1_m1_264000_446400 n1_m1_268800_446400 5.356235
R13364 n1_m1_268800_446400 n1_m1_273600_446400 5.356235
R13365 n1_m1_273600_446400 n1_m1_278400_446400 5.356235
R13366 n1_m1_278400_446400 n1_m1_283200_446400 5.356235
R13367 n1_m1_283200_446400 n1_m1_284000_446400 0.892706
R13368 n1_m1_288000_446400 n1_m1_284000_446400 4.463529
R13369 n1_m1_288000_446400 n1_m1_292800_446400 5.356235
R13370 n1_m1_292800_446400 n1_m1_297600_446400 5.356235
R13371 n1_m1_297600_446400 n1_m1_302400_446400 5.356235
R13372 n1_m1_302400_446400 n1_m1_307200_446400 5.356235
R13373 n1_m1_307200_446400 n1_m1_312000_446400 5.356235
R13374 n1_m1_312000_446400 n1_m1_316800_446400 5.356235
R13375 n1_m1_316800_446400 n1_m1_321600_446400 5.356235
R13376 n1_m1_321600_446400 n1_m1_326400_446400 5.356235
R13377 n1_m1_326400_446400 n1_m1_331200_446400 5.356235
R13378 n1_m1_331200_446400 n1_m1_336000_446400 5.356235
R13379 n1_m1_336000_446400 n1_m1_340000_446400 4.463529
R13380 n1_m1_340800_446400 n1_m1_340000_446400 0.892706
R13381 n1_m1_340800_446400 n1_m1_345600_446400 5.356235
R13382 n1_m1_345600_446400 n1_m1_350400_446400 5.356235
R13383 n1_m1_350400_446400 n1_m1_355200_446400 5.356235
R13384 n1_m1_355200_446400 n1_m1_360000_446400 5.356235
R13385 n1_m1_360000_446400 n1_m1_364800_446400 5.356235
R13386 n1_m1_364800_446400 n1_m1_368000_446400 3.570824
R13387 n1_m1_369600_446400 n1_m1_368000_446400 1.785412
R13388 n1_m1_369600_446400 n1_m1_374400_446400 5.356235
R13389 n1_m1_374400_446400 n1_m1_379200_446400 5.356235
R13390 n1_m1_379200_446400 n1_m1_384000_446400 5.356235
R13391 n1_m1_384000_446400 n1_m1_388800_446400 5.356235
R13392 n1_m1_388800_446400 n1_m1_393600_446400 5.356235
R13393 n1_m1_393600_446400 n1_m1_396000_446400 2.678118
R13394 n1_m1_398400_446400 n1_m1_396000_446400 2.678118
R13395 n1_m1_398400_446400 n1_m1_403200_446400 5.356235
R13396 n1_m1_403200_446400 n1_m1_408000_446400 5.356235
R13397 n1_m1_408000_446400 n1_m1_412800_446400 5.356235
R13398 n1_m1_412800_446400 n1_m1_417600_446400 5.356235
R13399 n1_m1_417600_446400 n1_m1_422400_446400 5.356235
R13400 n1_m1_422400_446400 n1_m1_424000_446400 1.785412
R13401 n1_m1_427200_446400 n1_m1_424000_446400 3.570824
R13402 n1_m1_427200_446400 n1_m1_432000_446400 5.356235
R13403 n1_m1_432000_446400 n1_m1_436800_446400 5.356235
R13404 n1_m1_436800_446400 n1_m1_441600_446400 5.356235
R13405 n1_m1_441600_446400 n1_m1_446400_446400 5.356235
R13406 n1_m1_446400_446400 n1_m1_451200_446400 5.356235
R13407 n1_m1_451200_446400 n1_m1_452000_446400 0.892706
R13408 n1_m1_456000_446400 n1_m1_452000_446400 4.463529
R13409 n1_m1_456000_446400 n1_m1_460800_446400 5.356235
R13410 n1_m1_460800_446400 n1_m1_465600_446400 5.356235
R13411 n1_m1_465600_446400 n1_m1_470400_446400 5.356235
R13412 n1_m1_470400_446400 n1_m1_475200_446400 5.356235
R13413 n1_m1_475200_446400 n1_m1_480000_446400 5.356235
R13414 n1_m1_480000_446400 n1_m1_484800_446400 5.356235
R13415 n1_m1_484800_446400 n1_m1_489600_446400 5.356235
R13416 n1_m1_489600_446400 n1_m1_494400_446400 5.356235
R13417 n1_m1_494400_446400 n1_m1_499200_446400 5.356235
R13418 n1_m1_499200_446400 n1_m1_504000_446400 5.356235
R13419 n1_m1_504000_446400 n1_m1_508000_446400 4.463529
R13420 n1_m1_508800_446400 n1_m1_508000_446400 0.892706
R13421 n1_m1_508800_446400 n1_m1_513600_446400 5.356235
R13422 n1_m1_513600_446400 n1_m1_518400_446400 5.356235
R13423 n1_m1_518400_446400 n1_m1_523200_446400 5.356235
R13424 n1_m1_523200_446400 n1_m1_528000_446400 5.356235
R13425 n1_m1_528000_446400 n1_m1_532800_446400 5.356235
R13426 n1_m1_532800_446400 n1_m1_536000_446400 3.570824
R13427 n1_m1_537600_446400 n1_m1_536000_446400 1.785412
R13428 n1_m1_537600_446400 n1_m1_542400_446400 5.356235
R13429 n1_m1_542400_446400 n1_m1_547200_446400 5.356235
R13430 n1_m1_547200_446400 n1_m1_552000_446400 5.356235
R13431 n1_m1_552000_446400 n1_m1_556800_446400 5.356235
R13432 n1_m1_556800_446400 n1_m1_561600_446400 5.356235
R13433 n1_m1_561600_446400 n1_m1_564000_446400 2.678118
R13434 n1_m1_566400_446400 n1_m1_564000_446400 2.678118
R13435 n1_m1_566400_446400 n1_m1_571200_446400 5.356235
R13436 n1_m1_571200_446400 n1_m1_576000_446400 5.356235
R13437 n1_m1_576000_446400 n1_m1_580800_446400 5.356235
R13438 n1_m1_580800_446400 n1_m1_585600_446400 5.356235
R13439 n1_m1_585600_446400 n1_m1_590400_446400 5.356235
R13440 n1_m1_590400_446400 n1_m1_592000_446400 1.785412
R13441 n1_m1_595200_446400 n1_m1_592000_446400 3.570824
R13442 n1_m1_0_451200 n1_m1_4000_451200 4.463529
R13443 n1_m1_4800_451200 n1_m1_4000_451200 0.892706
R13444 n1_m1_4800_451200 n1_m1_9600_451200 5.356235
R13445 n1_m1_9600_451200 n1_m1_14400_451200 5.356235
R13446 n1_m1_14400_451200 n1_m1_19200_451200 5.356235
R13447 n1_m1_19200_451200 n1_m1_24000_451200 5.356235
R13448 n1_m1_24000_451200 n1_m1_28800_451200 5.356235
R13449 n1_m1_28800_451200 n1_m1_32000_451200 3.570824
R13450 n1_m1_33600_451200 n1_m1_32000_451200 1.785412
R13451 n1_m1_33600_451200 n1_m1_38400_451200 5.356235
R13452 n1_m1_38400_451200 n1_m1_43200_451200 5.356235
R13453 n1_m1_43200_451200 n1_m1_48000_451200 5.356235
R13454 n1_m1_48000_451200 n1_m1_52800_451200 5.356235
R13455 n1_m1_52800_451200 n1_m1_57600_451200 5.356235
R13456 n1_m1_57600_451200 n1_m1_60000_451200 2.678118
R13457 n1_m1_62400_451200 n1_m1_60000_451200 2.678118
R13458 n1_m1_62400_451200 n1_m1_67200_451200 5.356235
R13459 n1_m1_67200_451200 n1_m1_72000_451200 5.356235
R13460 n1_m1_72000_451200 n1_m1_76800_451200 5.356235
R13461 n1_m1_76800_451200 n1_m1_81600_451200 5.356235
R13462 n1_m1_81600_451200 n1_m1_86400_451200 5.356235
R13463 n1_m1_86400_451200 n1_m1_88000_451200 1.785412
R13464 n1_m1_91200_451200 n1_m1_88000_451200 3.570824
R13465 n1_m1_91200_451200 n1_m1_96000_451200 5.356235
R13466 n1_m1_96000_451200 n1_m1_100800_451200 5.356235
R13467 n1_m1_100800_451200 n1_m1_105600_451200 5.356235
R13468 n1_m1_105600_451200 n1_m1_110400_451200 5.356235
R13469 n1_m1_110400_451200 n1_m1_115200_451200 5.356235
R13470 n1_m1_115200_451200 n1_m1_116000_451200 0.892706
R13471 n1_m1_120000_451200 n1_m1_116000_451200 4.463529
R13472 n1_m1_120000_451200 n1_m1_124800_451200 5.356235
R13473 n1_m1_124800_451200 n1_m1_129600_451200 5.356235
R13474 n1_m1_129600_451200 n1_m1_134400_451200 5.356235
R13475 n1_m1_134400_451200 n1_m1_139200_451200 5.356235
R13476 n1_m1_139200_451200 n1_m1_144000_451200 5.356235
R13477 n1_m1_144000_451200 n1_m1_148800_451200 5.356235
R13478 n1_m1_148800_451200 n1_m1_153600_451200 5.356235
R13479 n1_m1_153600_451200 n1_m1_158400_451200 5.356235
R13480 n1_m1_158400_451200 n1_m1_163200_451200 5.356235
R13481 n1_m1_163200_451200 n1_m1_168000_451200 5.356235
R13482 n1_m1_168000_451200 n1_m1_172000_451200 4.463529
R13483 n1_m1_172800_451200 n1_m1_172000_451200 0.892706
R13484 n1_m1_172800_451200 n1_m1_177600_451200 5.356235
R13485 n1_m1_177600_451200 n1_m1_182400_451200 5.356235
R13486 n1_m1_182400_451200 n1_m1_187200_451200 5.356235
R13487 n1_m1_187200_451200 n1_m1_192000_451200 5.356235
R13488 n1_m1_192000_451200 n1_m1_196800_451200 5.356235
R13489 n1_m1_196800_451200 n1_m1_200000_451200 3.570824
R13490 n1_m1_201600_451200 n1_m1_200000_451200 1.785412
R13491 n1_m1_201600_451200 n1_m1_206400_451200 5.356235
R13492 n1_m1_206400_451200 n1_m1_211200_451200 5.356235
R13493 n1_m1_211200_451200 n1_m1_216000_451200 5.356235
R13494 n1_m1_216000_451200 n1_m1_220800_451200 5.356235
R13495 n1_m1_220800_451200 n1_m1_225600_451200 5.356235
R13496 n1_m1_225600_451200 n1_m1_228000_451200 2.678118
R13497 n1_m1_230400_451200 n1_m1_228000_451200 2.678118
R13498 n1_m1_230400_451200 n1_m1_235200_451200 5.356235
R13499 n1_m1_235200_451200 n1_m1_240000_451200 5.356235
R13500 n1_m1_240000_451200 n1_m1_244800_451200 5.356235
R13501 n1_m1_244800_451200 n1_m1_249600_451200 5.356235
R13502 n1_m1_249600_451200 n1_m1_254400_451200 5.356235
R13503 n1_m1_254400_451200 n1_m1_256000_451200 1.785412
R13504 n1_m1_259200_451200 n1_m1_256000_451200 3.570824
R13505 n1_m1_259200_451200 n1_m1_264000_451200 5.356235
R13506 n1_m1_264000_451200 n1_m1_268800_451200 5.356235
R13507 n1_m1_268800_451200 n1_m1_273600_451200 5.356235
R13508 n1_m1_273600_451200 n1_m1_278400_451200 5.356235
R13509 n1_m1_278400_451200 n1_m1_283200_451200 5.356235
R13510 n1_m1_283200_451200 n1_m1_284000_451200 0.892706
R13511 n1_m1_288000_451200 n1_m1_284000_451200 4.463529
R13512 n1_m1_288000_451200 n1_m1_292800_451200 5.356235
R13513 n1_m1_292800_451200 n1_m1_297600_451200 5.356235
R13514 n1_m1_297600_451200 n1_m1_302400_451200 5.356235
R13515 n1_m1_302400_451200 n1_m1_307200_451200 5.356235
R13516 n1_m1_307200_451200 n1_m1_312000_451200 5.356235
R13517 n1_m1_312000_451200 n1_m1_316800_451200 5.356235
R13518 n1_m1_316800_451200 n1_m1_321600_451200 5.356235
R13519 n1_m1_321600_451200 n1_m1_326400_451200 5.356235
R13520 n1_m1_326400_451200 n1_m1_331200_451200 5.356235
R13521 n1_m1_331200_451200 n1_m1_336000_451200 5.356235
R13522 n1_m1_336000_451200 n1_m1_340000_451200 4.463529
R13523 n1_m1_340800_451200 n1_m1_340000_451200 0.892706
R13524 n1_m1_340800_451200 n1_m1_345600_451200 5.356235
R13525 n1_m1_345600_451200 n1_m1_350400_451200 5.356235
R13526 n1_m1_350400_451200 n1_m1_355200_451200 5.356235
R13527 n1_m1_355200_451200 n1_m1_360000_451200 5.356235
R13528 n1_m1_360000_451200 n1_m1_364800_451200 5.356235
R13529 n1_m1_364800_451200 n1_m1_368000_451200 3.570824
R13530 n1_m1_369600_451200 n1_m1_368000_451200 1.785412
R13531 n1_m1_369600_451200 n1_m1_374400_451200 5.356235
R13532 n1_m1_374400_451200 n1_m1_379200_451200 5.356235
R13533 n1_m1_379200_451200 n1_m1_384000_451200 5.356235
R13534 n1_m1_384000_451200 n1_m1_388800_451200 5.356235
R13535 n1_m1_388800_451200 n1_m1_393600_451200 5.356235
R13536 n1_m1_393600_451200 n1_m1_396000_451200 2.678118
R13537 n1_m1_398400_451200 n1_m1_396000_451200 2.678118
R13538 n1_m1_398400_451200 n1_m1_403200_451200 5.356235
R13539 n1_m1_403200_451200 n1_m1_408000_451200 5.356235
R13540 n1_m1_408000_451200 n1_m1_412800_451200 5.356235
R13541 n1_m1_412800_451200 n1_m1_417600_451200 5.356235
R13542 n1_m1_417600_451200 n1_m1_422400_451200 5.356235
R13543 n1_m1_422400_451200 n1_m1_424000_451200 1.785412
R13544 n1_m1_427200_451200 n1_m1_424000_451200 3.570824
R13545 n1_m1_427200_451200 n1_m1_432000_451200 5.356235
R13546 n1_m1_432000_451200 n1_m1_436800_451200 5.356235
R13547 n1_m1_436800_451200 n1_m1_441600_451200 5.356235
R13548 n1_m1_441600_451200 n1_m1_446400_451200 5.356235
R13549 n1_m1_446400_451200 n1_m1_451200_451200 5.356235
R13550 n1_m1_451200_451200 n1_m1_452000_451200 0.892706
R13551 n1_m1_456000_451200 n1_m1_452000_451200 4.463529
R13552 n1_m1_456000_451200 n1_m1_460800_451200 5.356235
R13553 n1_m1_460800_451200 n1_m1_465600_451200 5.356235
R13554 n1_m1_465600_451200 n1_m1_470400_451200 5.356235
R13555 n1_m1_470400_451200 n1_m1_475200_451200 5.356235
R13556 n1_m1_475200_451200 n1_m1_480000_451200 5.356235
R13557 n1_m1_480000_451200 n1_m1_484800_451200 5.356235
R13558 n1_m1_484800_451200 n1_m1_489600_451200 5.356235
R13559 n1_m1_489600_451200 n1_m1_494400_451200 5.356235
R13560 n1_m1_494400_451200 n1_m1_499200_451200 5.356235
R13561 n1_m1_499200_451200 n1_m1_504000_451200 5.356235
R13562 n1_m1_504000_451200 n1_m1_508000_451200 4.463529
R13563 n1_m1_508800_451200 n1_m1_508000_451200 0.892706
R13564 n1_m1_508800_451200 n1_m1_513600_451200 5.356235
R13565 n1_m1_513600_451200 n1_m1_518400_451200 5.356235
R13566 n1_m1_518400_451200 n1_m1_523200_451200 5.356235
R13567 n1_m1_523200_451200 n1_m1_528000_451200 5.356235
R13568 n1_m1_528000_451200 n1_m1_532800_451200 5.356235
R13569 n1_m1_532800_451200 n1_m1_536000_451200 3.570824
R13570 n1_m1_537600_451200 n1_m1_536000_451200 1.785412
R13571 n1_m1_537600_451200 n1_m1_542400_451200 5.356235
R13572 n1_m1_542400_451200 n1_m1_547200_451200 5.356235
R13573 n1_m1_547200_451200 n1_m1_552000_451200 5.356235
R13574 n1_m1_552000_451200 n1_m1_556800_451200 5.356235
R13575 n1_m1_556800_451200 n1_m1_561600_451200 5.356235
R13576 n1_m1_561600_451200 n1_m1_564000_451200 2.678118
R13577 n1_m1_566400_451200 n1_m1_564000_451200 2.678118
R13578 n1_m1_566400_451200 n1_m1_571200_451200 5.356235
R13579 n1_m1_571200_451200 n1_m1_576000_451200 5.356235
R13580 n1_m1_576000_451200 n1_m1_580800_451200 5.356235
R13581 n1_m1_580800_451200 n1_m1_585600_451200 5.356235
R13582 n1_m1_585600_451200 n1_m1_590400_451200 5.356235
R13583 n1_m1_590400_451200 n1_m1_592000_451200 1.785412
R13584 n1_m1_595200_451200 n1_m1_592000_451200 3.570824
R13585 n1_m1_0_456000 n1_m1_4000_456000 4.463529
R13586 n1_m1_4800_456000 n1_m1_4000_456000 0.892706
R13587 n1_m1_4800_456000 n1_m1_9600_456000 5.356235
R13588 n1_m1_9600_456000 n1_m1_14400_456000 5.356235
R13589 n1_m1_14400_456000 n1_m1_19200_456000 5.356235
R13590 n1_m1_19200_456000 n1_m1_24000_456000 5.356235
R13591 n1_m1_24000_456000 n1_m1_28800_456000 5.356235
R13592 n1_m1_28800_456000 n1_m1_32000_456000 3.570824
R13593 n1_m1_33600_456000 n1_m1_32000_456000 1.785412
R13594 n1_m1_33600_456000 n1_m1_38400_456000 5.356235
R13595 n1_m1_38400_456000 n1_m1_43200_456000 5.356235
R13596 n1_m1_43200_456000 n1_m1_48000_456000 5.356235
R13597 n1_m1_48000_456000 n1_m1_52800_456000 5.356235
R13598 n1_m1_52800_456000 n1_m1_57600_456000 5.356235
R13599 n1_m1_57600_456000 n1_m1_60000_456000 2.678118
R13600 n1_m1_62400_456000 n1_m1_60000_456000 2.678118
R13601 n1_m1_62400_456000 n1_m1_67200_456000 5.356235
R13602 n1_m1_67200_456000 n1_m1_72000_456000 5.356235
R13603 n1_m1_72000_456000 n1_m1_76800_456000 5.356235
R13604 n1_m1_76800_456000 n1_m1_81600_456000 5.356235
R13605 n1_m1_81600_456000 n1_m1_86400_456000 5.356235
R13606 n1_m1_86400_456000 n1_m1_88000_456000 1.785412
R13607 n1_m1_91200_456000 n1_m1_88000_456000 3.570824
R13608 n1_m1_91200_456000 n1_m1_96000_456000 5.356235
R13609 n1_m1_96000_456000 n1_m1_100800_456000 5.356235
R13610 n1_m1_100800_456000 n1_m1_105600_456000 5.356235
R13611 n1_m1_105600_456000 n1_m1_110400_456000 5.356235
R13612 n1_m1_110400_456000 n1_m1_115200_456000 5.356235
R13613 n1_m1_115200_456000 n1_m1_116000_456000 0.892706
R13614 n1_m1_120000_456000 n1_m1_116000_456000 4.463529
R13615 n1_m1_120000_456000 n1_m1_124800_456000 5.356235
R13616 n1_m1_124800_456000 n1_m1_129600_456000 5.356235
R13617 n1_m1_129600_456000 n1_m1_134400_456000 5.356235
R13618 n1_m1_134400_456000 n1_m1_139200_456000 5.356235
R13619 n1_m1_139200_456000 n1_m1_144000_456000 5.356235
R13620 n1_m1_144000_456000 n1_m1_148800_456000 5.356235
R13621 n1_m1_148800_456000 n1_m1_153600_456000 5.356235
R13622 n1_m1_153600_456000 n1_m1_158400_456000 5.356235
R13623 n1_m1_158400_456000 n1_m1_163200_456000 5.356235
R13624 n1_m1_163200_456000 n1_m1_168000_456000 5.356235
R13625 n1_m1_168000_456000 n1_m1_172000_456000 4.463529
R13626 n1_m1_172800_456000 n1_m1_172000_456000 0.892706
R13627 n1_m1_172800_456000 n1_m1_177600_456000 5.356235
R13628 n1_m1_177600_456000 n1_m1_182400_456000 5.356235
R13629 n1_m1_182400_456000 n1_m1_187200_456000 5.356235
R13630 n1_m1_187200_456000 n1_m1_192000_456000 5.356235
R13631 n1_m1_192000_456000 n1_m1_196800_456000 5.356235
R13632 n1_m1_196800_456000 n1_m1_200000_456000 3.570824
R13633 n1_m1_201600_456000 n1_m1_200000_456000 1.785412
R13634 n1_m1_201600_456000 n1_m1_206400_456000 5.356235
R13635 n1_m1_206400_456000 n1_m1_211200_456000 5.356235
R13636 n1_m1_211200_456000 n1_m1_216000_456000 5.356235
R13637 n1_m1_216000_456000 n1_m1_220800_456000 5.356235
R13638 n1_m1_220800_456000 n1_m1_225600_456000 5.356235
R13639 n1_m1_225600_456000 n1_m1_228000_456000 2.678118
R13640 n1_m1_230400_456000 n1_m1_228000_456000 2.678118
R13641 n1_m1_230400_456000 n1_m1_235200_456000 5.356235
R13642 n1_m1_235200_456000 n1_m1_240000_456000 5.356235
R13643 n1_m1_240000_456000 n1_m1_244800_456000 5.356235
R13644 n1_m1_244800_456000 n1_m1_249600_456000 5.356235
R13645 n1_m1_249600_456000 n1_m1_254400_456000 5.356235
R13646 n1_m1_254400_456000 n1_m1_256000_456000 1.785412
R13647 n1_m1_259200_456000 n1_m1_256000_456000 3.570824
R13648 n1_m1_259200_456000 n1_m1_264000_456000 5.356235
R13649 n1_m1_264000_456000 n1_m1_268800_456000 5.356235
R13650 n1_m1_268800_456000 n1_m1_273600_456000 5.356235
R13651 n1_m1_273600_456000 n1_m1_278400_456000 5.356235
R13652 n1_m1_278400_456000 n1_m1_283200_456000 5.356235
R13653 n1_m1_283200_456000 n1_m1_284000_456000 0.892706
R13654 n1_m1_288000_456000 n1_m1_284000_456000 4.463529
R13655 n1_m1_288000_456000 n1_m1_292800_456000 5.356235
R13656 n1_m1_292800_456000 n1_m1_297600_456000 5.356235
R13657 n1_m1_297600_456000 n1_m1_302400_456000 5.356235
R13658 n1_m1_302400_456000 n1_m1_307200_456000 5.356235
R13659 n1_m1_307200_456000 n1_m1_312000_456000 5.356235
R13660 n1_m1_312000_456000 n1_m1_316800_456000 5.356235
R13661 n1_m1_316800_456000 n1_m1_321600_456000 5.356235
R13662 n1_m1_321600_456000 n1_m1_326400_456000 5.356235
R13663 n1_m1_326400_456000 n1_m1_331200_456000 5.356235
R13664 n1_m1_331200_456000 n1_m1_336000_456000 5.356235
R13665 n1_m1_336000_456000 n1_m1_340000_456000 4.463529
R13666 n1_m1_340800_456000 n1_m1_340000_456000 0.892706
R13667 n1_m1_340800_456000 n1_m1_345600_456000 5.356235
R13668 n1_m1_345600_456000 n1_m1_350400_456000 5.356235
R13669 n1_m1_350400_456000 n1_m1_355200_456000 5.356235
R13670 n1_m1_355200_456000 n1_m1_360000_456000 5.356235
R13671 n1_m1_360000_456000 n1_m1_364800_456000 5.356235
R13672 n1_m1_364800_456000 n1_m1_368000_456000 3.570824
R13673 n1_m1_369600_456000 n1_m1_368000_456000 1.785412
R13674 n1_m1_369600_456000 n1_m1_374400_456000 5.356235
R13675 n1_m1_374400_456000 n1_m1_379200_456000 5.356235
R13676 n1_m1_379200_456000 n1_m1_384000_456000 5.356235
R13677 n1_m1_384000_456000 n1_m1_388800_456000 5.356235
R13678 n1_m1_388800_456000 n1_m1_393600_456000 5.356235
R13679 n1_m1_393600_456000 n1_m1_396000_456000 2.678118
R13680 n1_m1_398400_456000 n1_m1_396000_456000 2.678118
R13681 n1_m1_398400_456000 n1_m1_403200_456000 5.356235
R13682 n1_m1_403200_456000 n1_m1_408000_456000 5.356235
R13683 n1_m1_408000_456000 n1_m1_412800_456000 5.356235
R13684 n1_m1_412800_456000 n1_m1_417600_456000 5.356235
R13685 n1_m1_417600_456000 n1_m1_422400_456000 5.356235
R13686 n1_m1_422400_456000 n1_m1_424000_456000 1.785412
R13687 n1_m1_427200_456000 n1_m1_424000_456000 3.570824
R13688 n1_m1_427200_456000 n1_m1_432000_456000 5.356235
R13689 n1_m1_432000_456000 n1_m1_436800_456000 5.356235
R13690 n1_m1_436800_456000 n1_m1_441600_456000 5.356235
R13691 n1_m1_441600_456000 n1_m1_446400_456000 5.356235
R13692 n1_m1_446400_456000 n1_m1_451200_456000 5.356235
R13693 n1_m1_451200_456000 n1_m1_452000_456000 0.892706
R13694 n1_m1_456000_456000 n1_m1_452000_456000 4.463529
R13695 n1_m1_456000_456000 n1_m1_460800_456000 5.356235
R13696 n1_m1_460800_456000 n1_m1_465600_456000 5.356235
R13697 n1_m1_465600_456000 n1_m1_470400_456000 5.356235
R13698 n1_m1_470400_456000 n1_m1_475200_456000 5.356235
R13699 n1_m1_475200_456000 n1_m1_480000_456000 5.356235
R13700 n1_m1_480000_456000 n1_m1_484800_456000 5.356235
R13701 n1_m1_484800_456000 n1_m1_489600_456000 5.356235
R13702 n1_m1_489600_456000 n1_m1_494400_456000 5.356235
R13703 n1_m1_494400_456000 n1_m1_499200_456000 5.356235
R13704 n1_m1_499200_456000 n1_m1_504000_456000 5.356235
R13705 n1_m1_504000_456000 n1_m1_508000_456000 4.463529
R13706 n1_m1_508800_456000 n1_m1_508000_456000 0.892706
R13707 n1_m1_508800_456000 n1_m1_513600_456000 5.356235
R13708 n1_m1_513600_456000 n1_m1_518400_456000 5.356235
R13709 n1_m1_518400_456000 n1_m1_523200_456000 5.356235
R13710 n1_m1_523200_456000 n1_m1_528000_456000 5.356235
R13711 n1_m1_528000_456000 n1_m1_532800_456000 5.356235
R13712 n1_m1_532800_456000 n1_m1_536000_456000 3.570824
R13713 n1_m1_537600_456000 n1_m1_536000_456000 1.785412
R13714 n1_m1_537600_456000 n1_m1_542400_456000 5.356235
R13715 n1_m1_542400_456000 n1_m1_547200_456000 5.356235
R13716 n1_m1_547200_456000 n1_m1_552000_456000 5.356235
R13717 n1_m1_552000_456000 n1_m1_556800_456000 5.356235
R13718 n1_m1_556800_456000 n1_m1_561600_456000 5.356235
R13719 n1_m1_561600_456000 n1_m1_564000_456000 2.678118
R13720 n1_m1_566400_456000 n1_m1_564000_456000 2.678118
R13721 n1_m1_566400_456000 n1_m1_571200_456000 5.356235
R13722 n1_m1_571200_456000 n1_m1_576000_456000 5.356235
R13723 n1_m1_576000_456000 n1_m1_580800_456000 5.356235
R13724 n1_m1_580800_456000 n1_m1_585600_456000 5.356235
R13725 n1_m1_585600_456000 n1_m1_590400_456000 5.356235
R13726 n1_m1_590400_456000 n1_m1_592000_456000 1.785412
R13727 n1_m1_595200_456000 n1_m1_592000_456000 3.570824
R13728 n1_m1_0_460800 n1_m1_4000_460800 4.463529
R13729 n1_m1_4800_460800 n1_m1_4000_460800 0.892706
R13730 n1_m1_4800_460800 n1_m1_9600_460800 5.356235
R13731 n1_m1_9600_460800 n1_m1_14400_460800 5.356235
R13732 n1_m1_14400_460800 n1_m1_19200_460800 5.356235
R13733 n1_m1_19200_460800 n1_m1_24000_460800 5.356235
R13734 n1_m1_24000_460800 n1_m1_28800_460800 5.356235
R13735 n1_m1_28800_460800 n1_m1_32000_460800 3.570824
R13736 n1_m1_33600_460800 n1_m1_32000_460800 1.785412
R13737 n1_m1_33600_460800 n1_m1_38400_460800 5.356235
R13738 n1_m1_38400_460800 n1_m1_43200_460800 5.356235
R13739 n1_m1_43200_460800 n1_m1_48000_460800 5.356235
R13740 n1_m1_48000_460800 n1_m1_52800_460800 5.356235
R13741 n1_m1_52800_460800 n1_m1_57600_460800 5.356235
R13742 n1_m1_57600_460800 n1_m1_60000_460800 2.678118
R13743 n1_m1_62400_460800 n1_m1_60000_460800 2.678118
R13744 n1_m1_62400_460800 n1_m1_67200_460800 5.356235
R13745 n1_m1_67200_460800 n1_m1_72000_460800 5.356235
R13746 n1_m1_72000_460800 n1_m1_76800_460800 5.356235
R13747 n1_m1_76800_460800 n1_m1_81600_460800 5.356235
R13748 n1_m1_81600_460800 n1_m1_86400_460800 5.356235
R13749 n1_m1_86400_460800 n1_m1_88000_460800 1.785412
R13750 n1_m1_91200_460800 n1_m1_88000_460800 3.570824
R13751 n1_m1_91200_460800 n1_m1_96000_460800 5.356235
R13752 n1_m1_96000_460800 n1_m1_100800_460800 5.356235
R13753 n1_m1_100800_460800 n1_m1_105600_460800 5.356235
R13754 n1_m1_105600_460800 n1_m1_110400_460800 5.356235
R13755 n1_m1_110400_460800 n1_m1_115200_460800 5.356235
R13756 n1_m1_115200_460800 n1_m1_116000_460800 0.892706
R13757 n1_m1_120000_460800 n1_m1_116000_460800 4.463529
R13758 n1_m1_120000_460800 n1_m1_124800_460800 5.356235
R13759 n1_m1_124800_460800 n1_m1_129600_460800 5.356235
R13760 n1_m1_129600_460800 n1_m1_134400_460800 5.356235
R13761 n1_m1_134400_460800 n1_m1_139200_460800 5.356235
R13762 n1_m1_139200_460800 n1_m1_144000_460800 5.356235
R13763 n1_m1_144000_460800 n1_m1_148800_460800 5.356235
R13764 n1_m1_148800_460800 n1_m1_153600_460800 5.356235
R13765 n1_m1_153600_460800 n1_m1_158400_460800 5.356235
R13766 n1_m1_158400_460800 n1_m1_163200_460800 5.356235
R13767 n1_m1_163200_460800 n1_m1_168000_460800 5.356235
R13768 n1_m1_168000_460800 n1_m1_172000_460800 4.463529
R13769 n1_m1_172800_460800 n1_m1_172000_460800 0.892706
R13770 n1_m1_172800_460800 n1_m1_177600_460800 5.356235
R13771 n1_m1_177600_460800 n1_m1_182400_460800 5.356235
R13772 n1_m1_182400_460800 n1_m1_187200_460800 5.356235
R13773 n1_m1_187200_460800 n1_m1_192000_460800 5.356235
R13774 n1_m1_192000_460800 n1_m1_196800_460800 5.356235
R13775 n1_m1_196800_460800 n1_m1_200000_460800 3.570824
R13776 n1_m1_201600_460800 n1_m1_200000_460800 1.785412
R13777 n1_m1_201600_460800 n1_m1_206400_460800 5.356235
R13778 n1_m1_206400_460800 n1_m1_211200_460800 5.356235
R13779 n1_m1_211200_460800 n1_m1_216000_460800 5.356235
R13780 n1_m1_216000_460800 n1_m1_220800_460800 5.356235
R13781 n1_m1_220800_460800 n1_m1_225600_460800 5.356235
R13782 n1_m1_225600_460800 n1_m1_228000_460800 2.678118
R13783 n1_m1_230400_460800 n1_m1_228000_460800 2.678118
R13784 n1_m1_230400_460800 n1_m1_235200_460800 5.356235
R13785 n1_m1_235200_460800 n1_m1_240000_460800 5.356235
R13786 n1_m1_240000_460800 n1_m1_244800_460800 5.356235
R13787 n1_m1_244800_460800 n1_m1_249600_460800 5.356235
R13788 n1_m1_249600_460800 n1_m1_254400_460800 5.356235
R13789 n1_m1_254400_460800 n1_m1_256000_460800 1.785412
R13790 n1_m1_259200_460800 n1_m1_256000_460800 3.570824
R13791 n1_m1_259200_460800 n1_m1_264000_460800 5.356235
R13792 n1_m1_264000_460800 n1_m1_268800_460800 5.356235
R13793 n1_m1_268800_460800 n1_m1_273600_460800 5.356235
R13794 n1_m1_273600_460800 n1_m1_278400_460800 5.356235
R13795 n1_m1_278400_460800 n1_m1_283200_460800 5.356235
R13796 n1_m1_283200_460800 n1_m1_284000_460800 0.892706
R13797 n1_m1_288000_460800 n1_m1_284000_460800 4.463529
R13798 n1_m1_288000_460800 n1_m1_292800_460800 5.356235
R13799 n1_m1_292800_460800 n1_m1_297600_460800 5.356235
R13800 n1_m1_297600_460800 n1_m1_302400_460800 5.356235
R13801 n1_m1_302400_460800 n1_m1_307200_460800 5.356235
R13802 n1_m1_307200_460800 n1_m1_312000_460800 5.356235
R13803 n1_m1_312000_460800 n1_m1_316800_460800 5.356235
R13804 n1_m1_316800_460800 n1_m1_321600_460800 5.356235
R13805 n1_m1_321600_460800 n1_m1_326400_460800 5.356235
R13806 n1_m1_326400_460800 n1_m1_331200_460800 5.356235
R13807 n1_m1_331200_460800 n1_m1_336000_460800 5.356235
R13808 n1_m1_336000_460800 n1_m1_340000_460800 4.463529
R13809 n1_m1_340800_460800 n1_m1_340000_460800 0.892706
R13810 n1_m1_340800_460800 n1_m1_345600_460800 5.356235
R13811 n1_m1_345600_460800 n1_m1_350400_460800 5.356235
R13812 n1_m1_350400_460800 n1_m1_355200_460800 5.356235
R13813 n1_m1_355200_460800 n1_m1_360000_460800 5.356235
R13814 n1_m1_360000_460800 n1_m1_364800_460800 5.356235
R13815 n1_m1_364800_460800 n1_m1_368000_460800 3.570824
R13816 n1_m1_369600_460800 n1_m1_368000_460800 1.785412
R13817 n1_m1_369600_460800 n1_m1_374400_460800 5.356235
R13818 n1_m1_374400_460800 n1_m1_379200_460800 5.356235
R13819 n1_m1_379200_460800 n1_m1_384000_460800 5.356235
R13820 n1_m1_384000_460800 n1_m1_388800_460800 5.356235
R13821 n1_m1_388800_460800 n1_m1_393600_460800 5.356235
R13822 n1_m1_393600_460800 n1_m1_396000_460800 2.678118
R13823 n1_m1_398400_460800 n1_m1_396000_460800 2.678118
R13824 n1_m1_398400_460800 n1_m1_403200_460800 5.356235
R13825 n1_m1_403200_460800 n1_m1_408000_460800 5.356235
R13826 n1_m1_408000_460800 n1_m1_412800_460800 5.356235
R13827 n1_m1_412800_460800 n1_m1_417600_460800 5.356235
R13828 n1_m1_417600_460800 n1_m1_422400_460800 5.356235
R13829 n1_m1_422400_460800 n1_m1_424000_460800 1.785412
R13830 n1_m1_427200_460800 n1_m1_424000_460800 3.570824
R13831 n1_m1_427200_460800 n1_m1_432000_460800 5.356235
R13832 n1_m1_432000_460800 n1_m1_436800_460800 5.356235
R13833 n1_m1_436800_460800 n1_m1_441600_460800 5.356235
R13834 n1_m1_441600_460800 n1_m1_446400_460800 5.356235
R13835 n1_m1_446400_460800 n1_m1_451200_460800 5.356235
R13836 n1_m1_451200_460800 n1_m1_452000_460800 0.892706
R13837 n1_m1_456000_460800 n1_m1_452000_460800 4.463529
R13838 n1_m1_456000_460800 n1_m1_460800_460800 5.356235
R13839 n1_m1_460800_460800 n1_m1_465600_460800 5.356235
R13840 n1_m1_465600_460800 n1_m1_470400_460800 5.356235
R13841 n1_m1_470400_460800 n1_m1_475200_460800 5.356235
R13842 n1_m1_475200_460800 n1_m1_480000_460800 5.356235
R13843 n1_m1_480000_460800 n1_m1_484800_460800 5.356235
R13844 n1_m1_484800_460800 n1_m1_489600_460800 5.356235
R13845 n1_m1_489600_460800 n1_m1_494400_460800 5.356235
R13846 n1_m1_494400_460800 n1_m1_499200_460800 5.356235
R13847 n1_m1_499200_460800 n1_m1_504000_460800 5.356235
R13848 n1_m1_504000_460800 n1_m1_508000_460800 4.463529
R13849 n1_m1_508800_460800 n1_m1_508000_460800 0.892706
R13850 n1_m1_508800_460800 n1_m1_513600_460800 5.356235
R13851 n1_m1_513600_460800 n1_m1_518400_460800 5.356235
R13852 n1_m1_518400_460800 n1_m1_523200_460800 5.356235
R13853 n1_m1_523200_460800 n1_m1_528000_460800 5.356235
R13854 n1_m1_528000_460800 n1_m1_532800_460800 5.356235
R13855 n1_m1_532800_460800 n1_m1_536000_460800 3.570824
R13856 n1_m1_537600_460800 n1_m1_536000_460800 1.785412
R13857 n1_m1_537600_460800 n1_m1_542400_460800 5.356235
R13858 n1_m1_542400_460800 n1_m1_547200_460800 5.356235
R13859 n1_m1_547200_460800 n1_m1_552000_460800 5.356235
R13860 n1_m1_552000_460800 n1_m1_556800_460800 5.356235
R13861 n1_m1_556800_460800 n1_m1_561600_460800 5.356235
R13862 n1_m1_561600_460800 n1_m1_564000_460800 2.678118
R13863 n1_m1_566400_460800 n1_m1_564000_460800 2.678118
R13864 n1_m1_566400_460800 n1_m1_571200_460800 5.356235
R13865 n1_m1_571200_460800 n1_m1_576000_460800 5.356235
R13866 n1_m1_576000_460800 n1_m1_580800_460800 5.356235
R13867 n1_m1_580800_460800 n1_m1_585600_460800 5.356235
R13868 n1_m1_585600_460800 n1_m1_590400_460800 5.356235
R13869 n1_m1_590400_460800 n1_m1_592000_460800 1.785412
R13870 n1_m1_595200_460800 n1_m1_592000_460800 3.570824
R13871 n1_m1_0_465600 n1_m1_4000_465600 4.463529
R13872 n1_m1_4800_465600 n1_m1_4000_465600 0.892706
R13873 n1_m1_4800_465600 n1_m1_9600_465600 5.356235
R13874 n1_m1_9600_465600 n1_m1_14400_465600 5.356235
R13875 n1_m1_14400_465600 n1_m1_19200_465600 5.356235
R13876 n1_m1_19200_465600 n1_m1_24000_465600 5.356235
R13877 n1_m1_24000_465600 n1_m1_28800_465600 5.356235
R13878 n1_m1_28800_465600 n1_m1_32000_465600 3.570824
R13879 n1_m1_33600_465600 n1_m1_32000_465600 1.785412
R13880 n1_m1_33600_465600 n1_m1_38400_465600 5.356235
R13881 n1_m1_38400_465600 n1_m1_43200_465600 5.356235
R13882 n1_m1_43200_465600 n1_m1_48000_465600 5.356235
R13883 n1_m1_48000_465600 n1_m1_52800_465600 5.356235
R13884 n1_m1_52800_465600 n1_m1_57600_465600 5.356235
R13885 n1_m1_57600_465600 n1_m1_60000_465600 2.678118
R13886 n1_m1_62400_465600 n1_m1_60000_465600 2.678118
R13887 n1_m1_62400_465600 n1_m1_67200_465600 5.356235
R13888 n1_m1_67200_465600 n1_m1_72000_465600 5.356235
R13889 n1_m1_72000_465600 n1_m1_76800_465600 5.356235
R13890 n1_m1_76800_465600 n1_m1_81600_465600 5.356235
R13891 n1_m1_81600_465600 n1_m1_86400_465600 5.356235
R13892 n1_m1_86400_465600 n1_m1_88000_465600 1.785412
R13893 n1_m1_91200_465600 n1_m1_88000_465600 3.570824
R13894 n1_m1_91200_465600 n1_m1_96000_465600 5.356235
R13895 n1_m1_96000_465600 n1_m1_100800_465600 5.356235
R13896 n1_m1_100800_465600 n1_m1_105600_465600 5.356235
R13897 n1_m1_105600_465600 n1_m1_110400_465600 5.356235
R13898 n1_m1_110400_465600 n1_m1_115200_465600 5.356235
R13899 n1_m1_115200_465600 n1_m1_116000_465600 0.892706
R13900 n1_m1_120000_465600 n1_m1_116000_465600 4.463529
R13901 n1_m1_120000_465600 n1_m1_124800_465600 5.356235
R13902 n1_m1_124800_465600 n1_m1_129600_465600 5.356235
R13903 n1_m1_129600_465600 n1_m1_134400_465600 5.356235
R13904 n1_m1_134400_465600 n1_m1_139200_465600 5.356235
R13905 n1_m1_139200_465600 n1_m1_144000_465600 5.356235
R13906 n1_m1_144000_465600 n1_m1_148800_465600 5.356235
R13907 n1_m1_148800_465600 n1_m1_153600_465600 5.356235
R13908 n1_m1_153600_465600 n1_m1_158400_465600 5.356235
R13909 n1_m1_158400_465600 n1_m1_163200_465600 5.356235
R13910 n1_m1_163200_465600 n1_m1_168000_465600 5.356235
R13911 n1_m1_168000_465600 n1_m1_172000_465600 4.463529
R13912 n1_m1_172800_465600 n1_m1_172000_465600 0.892706
R13913 n1_m1_172800_465600 n1_m1_177600_465600 5.356235
R13914 n1_m1_177600_465600 n1_m1_182400_465600 5.356235
R13915 n1_m1_182400_465600 n1_m1_187200_465600 5.356235
R13916 n1_m1_187200_465600 n1_m1_192000_465600 5.356235
R13917 n1_m1_192000_465600 n1_m1_196800_465600 5.356235
R13918 n1_m1_196800_465600 n1_m1_200000_465600 3.570824
R13919 n1_m1_201600_465600 n1_m1_200000_465600 1.785412
R13920 n1_m1_201600_465600 n1_m1_206400_465600 5.356235
R13921 n1_m1_206400_465600 n1_m1_211200_465600 5.356235
R13922 n1_m1_211200_465600 n1_m1_216000_465600 5.356235
R13923 n1_m1_216000_465600 n1_m1_220800_465600 5.356235
R13924 n1_m1_220800_465600 n1_m1_225600_465600 5.356235
R13925 n1_m1_225600_465600 n1_m1_228000_465600 2.678118
R13926 n1_m1_230400_465600 n1_m1_228000_465600 2.678118
R13927 n1_m1_230400_465600 n1_m1_235200_465600 5.356235
R13928 n1_m1_235200_465600 n1_m1_240000_465600 5.356235
R13929 n1_m1_240000_465600 n1_m1_244800_465600 5.356235
R13930 n1_m1_244800_465600 n1_m1_249600_465600 5.356235
R13931 n1_m1_249600_465600 n1_m1_254400_465600 5.356235
R13932 n1_m1_254400_465600 n1_m1_256000_465600 1.785412
R13933 n1_m1_259200_465600 n1_m1_256000_465600 3.570824
R13934 n1_m1_259200_465600 n1_m1_264000_465600 5.356235
R13935 n1_m1_264000_465600 n1_m1_268800_465600 5.356235
R13936 n1_m1_268800_465600 n1_m1_273600_465600 5.356235
R13937 n1_m1_273600_465600 n1_m1_278400_465600 5.356235
R13938 n1_m1_278400_465600 n1_m1_283200_465600 5.356235
R13939 n1_m1_283200_465600 n1_m1_284000_465600 0.892706
R13940 n1_m1_288000_465600 n1_m1_284000_465600 4.463529
R13941 n1_m1_288000_465600 n1_m1_292800_465600 5.356235
R13942 n1_m1_292800_465600 n1_m1_297600_465600 5.356235
R13943 n1_m1_297600_465600 n1_m1_302400_465600 5.356235
R13944 n1_m1_302400_465600 n1_m1_307200_465600 5.356235
R13945 n1_m1_307200_465600 n1_m1_312000_465600 5.356235
R13946 n1_m1_312000_465600 n1_m1_316800_465600 5.356235
R13947 n1_m1_316800_465600 n1_m1_321600_465600 5.356235
R13948 n1_m1_321600_465600 n1_m1_326400_465600 5.356235
R13949 n1_m1_326400_465600 n1_m1_331200_465600 5.356235
R13950 n1_m1_331200_465600 n1_m1_336000_465600 5.356235
R13951 n1_m1_336000_465600 n1_m1_340000_465600 4.463529
R13952 n1_m1_340800_465600 n1_m1_340000_465600 0.892706
R13953 n1_m1_340800_465600 n1_m1_345600_465600 5.356235
R13954 n1_m1_345600_465600 n1_m1_350400_465600 5.356235
R13955 n1_m1_350400_465600 n1_m1_355200_465600 5.356235
R13956 n1_m1_355200_465600 n1_m1_360000_465600 5.356235
R13957 n1_m1_360000_465600 n1_m1_364800_465600 5.356235
R13958 n1_m1_364800_465600 n1_m1_368000_465600 3.570824
R13959 n1_m1_369600_465600 n1_m1_368000_465600 1.785412
R13960 n1_m1_369600_465600 n1_m1_374400_465600 5.356235
R13961 n1_m1_374400_465600 n1_m1_379200_465600 5.356235
R13962 n1_m1_379200_465600 n1_m1_384000_465600 5.356235
R13963 n1_m1_384000_465600 n1_m1_388800_465600 5.356235
R13964 n1_m1_388800_465600 n1_m1_393600_465600 5.356235
R13965 n1_m1_393600_465600 n1_m1_396000_465600 2.678118
R13966 n1_m1_398400_465600 n1_m1_396000_465600 2.678118
R13967 n1_m1_398400_465600 n1_m1_403200_465600 5.356235
R13968 n1_m1_403200_465600 n1_m1_408000_465600 5.356235
R13969 n1_m1_408000_465600 n1_m1_412800_465600 5.356235
R13970 n1_m1_412800_465600 n1_m1_417600_465600 5.356235
R13971 n1_m1_417600_465600 n1_m1_422400_465600 5.356235
R13972 n1_m1_422400_465600 n1_m1_424000_465600 1.785412
R13973 n1_m1_427200_465600 n1_m1_424000_465600 3.570824
R13974 n1_m1_427200_465600 n1_m1_432000_465600 5.356235
R13975 n1_m1_432000_465600 n1_m1_436800_465600 5.356235
R13976 n1_m1_436800_465600 n1_m1_441600_465600 5.356235
R13977 n1_m1_441600_465600 n1_m1_446400_465600 5.356235
R13978 n1_m1_446400_465600 n1_m1_451200_465600 5.356235
R13979 n1_m1_451200_465600 n1_m1_452000_465600 0.892706
R13980 n1_m1_456000_465600 n1_m1_452000_465600 4.463529
R13981 n1_m1_456000_465600 n1_m1_460800_465600 5.356235
R13982 n1_m1_460800_465600 n1_m1_465600_465600 5.356235
R13983 n1_m1_465600_465600 n1_m1_470400_465600 5.356235
R13984 n1_m1_470400_465600 n1_m1_475200_465600 5.356235
R13985 n1_m1_475200_465600 n1_m1_480000_465600 5.356235
R13986 n1_m1_480000_465600 n1_m1_484800_465600 5.356235
R13987 n1_m1_484800_465600 n1_m1_489600_465600 5.356235
R13988 n1_m1_489600_465600 n1_m1_494400_465600 5.356235
R13989 n1_m1_494400_465600 n1_m1_499200_465600 5.356235
R13990 n1_m1_499200_465600 n1_m1_504000_465600 5.356235
R13991 n1_m1_504000_465600 n1_m1_508000_465600 4.463529
R13992 n1_m1_508800_465600 n1_m1_508000_465600 0.892706
R13993 n1_m1_508800_465600 n1_m1_513600_465600 5.356235
R13994 n1_m1_513600_465600 n1_m1_518400_465600 5.356235
R13995 n1_m1_518400_465600 n1_m1_523200_465600 5.356235
R13996 n1_m1_523200_465600 n1_m1_528000_465600 5.356235
R13997 n1_m1_528000_465600 n1_m1_532800_465600 5.356235
R13998 n1_m1_532800_465600 n1_m1_536000_465600 3.570824
R13999 n1_m1_537600_465600 n1_m1_536000_465600 1.785412
R14000 n1_m1_537600_465600 n1_m1_542400_465600 5.356235
R14001 n1_m1_542400_465600 n1_m1_547200_465600 5.356235
R14002 n1_m1_547200_465600 n1_m1_552000_465600 5.356235
R14003 n1_m1_552000_465600 n1_m1_556800_465600 5.356235
R14004 n1_m1_556800_465600 n1_m1_561600_465600 5.356235
R14005 n1_m1_561600_465600 n1_m1_564000_465600 2.678118
R14006 n1_m1_566400_465600 n1_m1_564000_465600 2.678118
R14007 n1_m1_566400_465600 n1_m1_571200_465600 5.356235
R14008 n1_m1_571200_465600 n1_m1_576000_465600 5.356235
R14009 n1_m1_576000_465600 n1_m1_580800_465600 5.356235
R14010 n1_m1_580800_465600 n1_m1_585600_465600 5.356235
R14011 n1_m1_585600_465600 n1_m1_590400_465600 5.356235
R14012 n1_m1_590400_465600 n1_m1_592000_465600 1.785412
R14013 n1_m1_595200_465600 n1_m1_592000_465600 3.570824
R14014 n1_m1_0_470400 n1_m1_4000_470400 4.463529
R14015 n1_m1_4800_470400 n1_m1_4000_470400 0.892706
R14016 n1_m1_4800_470400 n1_m1_9600_470400 5.356235
R14017 n1_m1_9600_470400 n1_m1_14400_470400 5.356235
R14018 n1_m1_14400_470400 n1_m1_19200_470400 5.356235
R14019 n1_m1_19200_470400 n1_m1_24000_470400 5.356235
R14020 n1_m1_24000_470400 n1_m1_28800_470400 5.356235
R14021 n1_m1_28800_470400 n1_m1_32000_470400 3.570824
R14022 n1_m1_33600_470400 n1_m1_32000_470400 1.785412
R14023 n1_m1_33600_470400 n1_m1_38400_470400 5.356235
R14024 n1_m1_38400_470400 n1_m1_43200_470400 5.356235
R14025 n1_m1_43200_470400 n1_m1_48000_470400 5.356235
R14026 n1_m1_48000_470400 n1_m1_52800_470400 5.356235
R14027 n1_m1_52800_470400 n1_m1_57600_470400 5.356235
R14028 n1_m1_57600_470400 n1_m1_60000_470400 2.678118
R14029 n1_m1_62400_470400 n1_m1_60000_470400 2.678118
R14030 n1_m1_62400_470400 n1_m1_67200_470400 5.356235
R14031 n1_m1_67200_470400 n1_m1_72000_470400 5.356235
R14032 n1_m1_72000_470400 n1_m1_76800_470400 5.356235
R14033 n1_m1_76800_470400 n1_m1_81600_470400 5.356235
R14034 n1_m1_81600_470400 n1_m1_86400_470400 5.356235
R14035 n1_m1_86400_470400 n1_m1_88000_470400 1.785412
R14036 n1_m1_91200_470400 n1_m1_88000_470400 3.570824
R14037 n1_m1_91200_470400 n1_m1_96000_470400 5.356235
R14038 n1_m1_96000_470400 n1_m1_100800_470400 5.356235
R14039 n1_m1_100800_470400 n1_m1_105600_470400 5.356235
R14040 n1_m1_105600_470400 n1_m1_110400_470400 5.356235
R14041 n1_m1_110400_470400 n1_m1_115200_470400 5.356235
R14042 n1_m1_115200_470400 n1_m1_116000_470400 0.892706
R14043 n1_m1_120000_470400 n1_m1_116000_470400 4.463529
R14044 n1_m1_120000_470400 n1_m1_124800_470400 5.356235
R14045 n1_m1_124800_470400 n1_m1_129600_470400 5.356235
R14046 n1_m1_129600_470400 n1_m1_134400_470400 5.356235
R14047 n1_m1_134400_470400 n1_m1_139200_470400 5.356235
R14048 n1_m1_139200_470400 n1_m1_144000_470400 5.356235
R14049 n1_m1_144000_470400 n1_m1_148800_470400 5.356235
R14050 n1_m1_148800_470400 n1_m1_153600_470400 5.356235
R14051 n1_m1_153600_470400 n1_m1_158400_470400 5.356235
R14052 n1_m1_158400_470400 n1_m1_163200_470400 5.356235
R14053 n1_m1_163200_470400 n1_m1_168000_470400 5.356235
R14054 n1_m1_168000_470400 n1_m1_172000_470400 4.463529
R14055 n1_m1_172800_470400 n1_m1_172000_470400 0.892706
R14056 n1_m1_172800_470400 n1_m1_177600_470400 5.356235
R14057 n1_m1_177600_470400 n1_m1_182400_470400 5.356235
R14058 n1_m1_182400_470400 n1_m1_187200_470400 5.356235
R14059 n1_m1_187200_470400 n1_m1_192000_470400 5.356235
R14060 n1_m1_192000_470400 n1_m1_196800_470400 5.356235
R14061 n1_m1_196800_470400 n1_m1_200000_470400 3.570824
R14062 n1_m1_201600_470400 n1_m1_200000_470400 1.785412
R14063 n1_m1_201600_470400 n1_m1_206400_470400 5.356235
R14064 n1_m1_206400_470400 n1_m1_211200_470400 5.356235
R14065 n1_m1_211200_470400 n1_m1_216000_470400 5.356235
R14066 n1_m1_216000_470400 n1_m1_220800_470400 5.356235
R14067 n1_m1_220800_470400 n1_m1_225600_470400 5.356235
R14068 n1_m1_225600_470400 n1_m1_228000_470400 2.678118
R14069 n1_m1_230400_470400 n1_m1_228000_470400 2.678118
R14070 n1_m1_230400_470400 n1_m1_235200_470400 5.356235
R14071 n1_m1_235200_470400 n1_m1_240000_470400 5.356235
R14072 n1_m1_240000_470400 n1_m1_244800_470400 5.356235
R14073 n1_m1_244800_470400 n1_m1_249600_470400 5.356235
R14074 n1_m1_249600_470400 n1_m1_254400_470400 5.356235
R14075 n1_m1_254400_470400 n1_m1_256000_470400 1.785412
R14076 n1_m1_259200_470400 n1_m1_256000_470400 3.570824
R14077 n1_m1_259200_470400 n1_m1_264000_470400 5.356235
R14078 n1_m1_264000_470400 n1_m1_268800_470400 5.356235
R14079 n1_m1_268800_470400 n1_m1_273600_470400 5.356235
R14080 n1_m1_273600_470400 n1_m1_278400_470400 5.356235
R14081 n1_m1_278400_470400 n1_m1_283200_470400 5.356235
R14082 n1_m1_283200_470400 n1_m1_284000_470400 0.892706
R14083 n1_m1_288000_470400 n1_m1_284000_470400 4.463529
R14084 n1_m1_288000_470400 n1_m1_292800_470400 5.356235
R14085 n1_m1_292800_470400 n1_m1_297600_470400 5.356235
R14086 n1_m1_297600_470400 n1_m1_302400_470400 5.356235
R14087 n1_m1_302400_470400 n1_m1_307200_470400 5.356235
R14088 n1_m1_307200_470400 n1_m1_312000_470400 5.356235
R14089 n1_m1_312000_470400 n1_m1_316800_470400 5.356235
R14090 n1_m1_316800_470400 n1_m1_321600_470400 5.356235
R14091 n1_m1_321600_470400 n1_m1_326400_470400 5.356235
R14092 n1_m1_326400_470400 n1_m1_331200_470400 5.356235
R14093 n1_m1_331200_470400 n1_m1_336000_470400 5.356235
R14094 n1_m1_336000_470400 n1_m1_340000_470400 4.463529
R14095 n1_m1_340800_470400 n1_m1_340000_470400 0.892706
R14096 n1_m1_340800_470400 n1_m1_345600_470400 5.356235
R14097 n1_m1_345600_470400 n1_m1_350400_470400 5.356235
R14098 n1_m1_350400_470400 n1_m1_355200_470400 5.356235
R14099 n1_m1_355200_470400 n1_m1_360000_470400 5.356235
R14100 n1_m1_360000_470400 n1_m1_364800_470400 5.356235
R14101 n1_m1_364800_470400 n1_m1_368000_470400 3.570824
R14102 n1_m1_369600_470400 n1_m1_368000_470400 1.785412
R14103 n1_m1_369600_470400 n1_m1_374400_470400 5.356235
R14104 n1_m1_374400_470400 n1_m1_379200_470400 5.356235
R14105 n1_m1_379200_470400 n1_m1_384000_470400 5.356235
R14106 n1_m1_384000_470400 n1_m1_388800_470400 5.356235
R14107 n1_m1_388800_470400 n1_m1_393600_470400 5.356235
R14108 n1_m1_393600_470400 n1_m1_396000_470400 2.678118
R14109 n1_m1_398400_470400 n1_m1_396000_470400 2.678118
R14110 n1_m1_398400_470400 n1_m1_403200_470400 5.356235
R14111 n1_m1_403200_470400 n1_m1_408000_470400 5.356235
R14112 n1_m1_408000_470400 n1_m1_412800_470400 5.356235
R14113 n1_m1_412800_470400 n1_m1_417600_470400 5.356235
R14114 n1_m1_417600_470400 n1_m1_422400_470400 5.356235
R14115 n1_m1_422400_470400 n1_m1_424000_470400 1.785412
R14116 n1_m1_427200_470400 n1_m1_424000_470400 3.570824
R14117 n1_m1_427200_470400 n1_m1_432000_470400 5.356235
R14118 n1_m1_432000_470400 n1_m1_436800_470400 5.356235
R14119 n1_m1_436800_470400 n1_m1_441600_470400 5.356235
R14120 n1_m1_441600_470400 n1_m1_446400_470400 5.356235
R14121 n1_m1_446400_470400 n1_m1_451200_470400 5.356235
R14122 n1_m1_451200_470400 n1_m1_452000_470400 0.892706
R14123 n1_m1_456000_470400 n1_m1_452000_470400 4.463529
R14124 n1_m1_456000_470400 n1_m1_460800_470400 5.356235
R14125 n1_m1_460800_470400 n1_m1_465600_470400 5.356235
R14126 n1_m1_465600_470400 n1_m1_470400_470400 5.356235
R14127 n1_m1_470400_470400 n1_m1_475200_470400 5.356235
R14128 n1_m1_475200_470400 n1_m1_480000_470400 5.356235
R14129 n1_m1_480000_470400 n1_m1_484800_470400 5.356235
R14130 n1_m1_484800_470400 n1_m1_489600_470400 5.356235
R14131 n1_m1_489600_470400 n1_m1_494400_470400 5.356235
R14132 n1_m1_494400_470400 n1_m1_499200_470400 5.356235
R14133 n1_m1_499200_470400 n1_m1_504000_470400 5.356235
R14134 n1_m1_504000_470400 n1_m1_508000_470400 4.463529
R14135 n1_m1_508800_470400 n1_m1_508000_470400 0.892706
R14136 n1_m1_508800_470400 n1_m1_513600_470400 5.356235
R14137 n1_m1_513600_470400 n1_m1_518400_470400 5.356235
R14138 n1_m1_518400_470400 n1_m1_523200_470400 5.356235
R14139 n1_m1_523200_470400 n1_m1_528000_470400 5.356235
R14140 n1_m1_528000_470400 n1_m1_532800_470400 5.356235
R14141 n1_m1_532800_470400 n1_m1_536000_470400 3.570824
R14142 n1_m1_537600_470400 n1_m1_536000_470400 1.785412
R14143 n1_m1_537600_470400 n1_m1_542400_470400 5.356235
R14144 n1_m1_542400_470400 n1_m1_547200_470400 5.356235
R14145 n1_m1_547200_470400 n1_m1_552000_470400 5.356235
R14146 n1_m1_552000_470400 n1_m1_556800_470400 5.356235
R14147 n1_m1_556800_470400 n1_m1_561600_470400 5.356235
R14148 n1_m1_561600_470400 n1_m1_564000_470400 2.678118
R14149 n1_m1_566400_470400 n1_m1_564000_470400 2.678118
R14150 n1_m1_566400_470400 n1_m1_571200_470400 5.356235
R14151 n1_m1_571200_470400 n1_m1_576000_470400 5.356235
R14152 n1_m1_576000_470400 n1_m1_580800_470400 5.356235
R14153 n1_m1_580800_470400 n1_m1_585600_470400 5.356235
R14154 n1_m1_585600_470400 n1_m1_590400_470400 5.356235
R14155 n1_m1_590400_470400 n1_m1_592000_470400 1.785412
R14156 n1_m1_595200_470400 n1_m1_592000_470400 3.570824
R14157 n1_m1_0_475200 n1_m1_4000_475200 4.463529
R14158 n1_m1_4800_475200 n1_m1_4000_475200 0.892706
R14159 n1_m1_4800_475200 n1_m1_9600_475200 5.356235
R14160 n1_m1_9600_475200 n1_m1_14400_475200 5.356235
R14161 n1_m1_14400_475200 n1_m1_19200_475200 5.356235
R14162 n1_m1_19200_475200 n1_m1_24000_475200 5.356235
R14163 n1_m1_24000_475200 n1_m1_28800_475200 5.356235
R14164 n1_m1_28800_475200 n1_m1_32000_475200 3.570824
R14165 n1_m1_33600_475200 n1_m1_32000_475200 1.785412
R14166 n1_m1_33600_475200 n1_m1_38400_475200 5.356235
R14167 n1_m1_38400_475200 n1_m1_43200_475200 5.356235
R14168 n1_m1_43200_475200 n1_m1_48000_475200 5.356235
R14169 n1_m1_48000_475200 n1_m1_52800_475200 5.356235
R14170 n1_m1_52800_475200 n1_m1_57600_475200 5.356235
R14171 n1_m1_57600_475200 n1_m1_60000_475200 2.678118
R14172 n1_m1_62400_475200 n1_m1_60000_475200 2.678118
R14173 n1_m1_62400_475200 n1_m1_67200_475200 5.356235
R14174 n1_m1_67200_475200 n1_m1_72000_475200 5.356235
R14175 n1_m1_72000_475200 n1_m1_76800_475200 5.356235
R14176 n1_m1_76800_475200 n1_m1_81600_475200 5.356235
R14177 n1_m1_81600_475200 n1_m1_86400_475200 5.356235
R14178 n1_m1_86400_475200 n1_m1_88000_475200 1.785412
R14179 n1_m1_91200_475200 n1_m1_88000_475200 3.570824
R14180 n1_m1_91200_475200 n1_m1_96000_475200 5.356235
R14181 n1_m1_96000_475200 n1_m1_100800_475200 5.356235
R14182 n1_m1_100800_475200 n1_m1_105600_475200 5.356235
R14183 n1_m1_105600_475200 n1_m1_110400_475200 5.356235
R14184 n1_m1_110400_475200 n1_m1_115200_475200 5.356235
R14185 n1_m1_115200_475200 n1_m1_116000_475200 0.892706
R14186 n1_m1_120000_475200 n1_m1_116000_475200 4.463529
R14187 n1_m1_120000_475200 n1_m1_124800_475200 5.356235
R14188 n1_m1_124800_475200 n1_m1_129600_475200 5.356235
R14189 n1_m1_129600_475200 n1_m1_134400_475200 5.356235
R14190 n1_m1_134400_475200 n1_m1_139200_475200 5.356235
R14191 n1_m1_139200_475200 n1_m1_144000_475200 5.356235
R14192 n1_m1_144000_475200 n1_m1_148800_475200 5.356235
R14193 n1_m1_148800_475200 n1_m1_153600_475200 5.356235
R14194 n1_m1_153600_475200 n1_m1_158400_475200 5.356235
R14195 n1_m1_158400_475200 n1_m1_163200_475200 5.356235
R14196 n1_m1_163200_475200 n1_m1_168000_475200 5.356235
R14197 n1_m1_168000_475200 n1_m1_172000_475200 4.463529
R14198 n1_m1_172800_475200 n1_m1_172000_475200 0.892706
R14199 n1_m1_172800_475200 n1_m1_177600_475200 5.356235
R14200 n1_m1_177600_475200 n1_m1_182400_475200 5.356235
R14201 n1_m1_182400_475200 n1_m1_187200_475200 5.356235
R14202 n1_m1_187200_475200 n1_m1_192000_475200 5.356235
R14203 n1_m1_192000_475200 n1_m1_196800_475200 5.356235
R14204 n1_m1_196800_475200 n1_m1_200000_475200 3.570824
R14205 n1_m1_201600_475200 n1_m1_200000_475200 1.785412
R14206 n1_m1_201600_475200 n1_m1_206400_475200 5.356235
R14207 n1_m1_206400_475200 n1_m1_211200_475200 5.356235
R14208 n1_m1_211200_475200 n1_m1_216000_475200 5.356235
R14209 n1_m1_216000_475200 n1_m1_220800_475200 5.356235
R14210 n1_m1_220800_475200 n1_m1_225600_475200 5.356235
R14211 n1_m1_225600_475200 n1_m1_228000_475200 2.678118
R14212 n1_m1_230400_475200 n1_m1_228000_475200 2.678118
R14213 n1_m1_230400_475200 n1_m1_235200_475200 5.356235
R14214 n1_m1_235200_475200 n1_m1_240000_475200 5.356235
R14215 n1_m1_240000_475200 n1_m1_244800_475200 5.356235
R14216 n1_m1_244800_475200 n1_m1_249600_475200 5.356235
R14217 n1_m1_249600_475200 n1_m1_254400_475200 5.356235
R14218 n1_m1_254400_475200 n1_m1_256000_475200 1.785412
R14219 n1_m1_259200_475200 n1_m1_256000_475200 3.570824
R14220 n1_m1_259200_475200 n1_m1_264000_475200 5.356235
R14221 n1_m1_264000_475200 n1_m1_268800_475200 5.356235
R14222 n1_m1_268800_475200 n1_m1_273600_475200 5.356235
R14223 n1_m1_273600_475200 n1_m1_278400_475200 5.356235
R14224 n1_m1_278400_475200 n1_m1_283200_475200 5.356235
R14225 n1_m1_283200_475200 n1_m1_284000_475200 0.892706
R14226 n1_m1_288000_475200 n1_m1_284000_475200 4.463529
R14227 n1_m1_288000_475200 n1_m1_292800_475200 5.356235
R14228 n1_m1_292800_475200 n1_m1_297600_475200 5.356235
R14229 n1_m1_297600_475200 n1_m1_302400_475200 5.356235
R14230 n1_m1_302400_475200 n1_m1_307200_475200 5.356235
R14231 n1_m1_307200_475200 n1_m1_312000_475200 5.356235
R14232 n1_m1_312000_475200 n1_m1_316800_475200 5.356235
R14233 n1_m1_316800_475200 n1_m1_321600_475200 5.356235
R14234 n1_m1_321600_475200 n1_m1_326400_475200 5.356235
R14235 n1_m1_326400_475200 n1_m1_331200_475200 5.356235
R14236 n1_m1_331200_475200 n1_m1_336000_475200 5.356235
R14237 n1_m1_336000_475200 n1_m1_340000_475200 4.463529
R14238 n1_m1_340800_475200 n1_m1_340000_475200 0.892706
R14239 n1_m1_340800_475200 n1_m1_345600_475200 5.356235
R14240 n1_m1_345600_475200 n1_m1_350400_475200 5.356235
R14241 n1_m1_350400_475200 n1_m1_355200_475200 5.356235
R14242 n1_m1_355200_475200 n1_m1_360000_475200 5.356235
R14243 n1_m1_360000_475200 n1_m1_364800_475200 5.356235
R14244 n1_m1_364800_475200 n1_m1_368000_475200 3.570824
R14245 n1_m1_369600_475200 n1_m1_368000_475200 1.785412
R14246 n1_m1_369600_475200 n1_m1_374400_475200 5.356235
R14247 n1_m1_374400_475200 n1_m1_379200_475200 5.356235
R14248 n1_m1_379200_475200 n1_m1_384000_475200 5.356235
R14249 n1_m1_384000_475200 n1_m1_388800_475200 5.356235
R14250 n1_m1_388800_475200 n1_m1_393600_475200 5.356235
R14251 n1_m1_393600_475200 n1_m1_396000_475200 2.678118
R14252 n1_m1_398400_475200 n1_m1_396000_475200 2.678118
R14253 n1_m1_398400_475200 n1_m1_403200_475200 5.356235
R14254 n1_m1_403200_475200 n1_m1_408000_475200 5.356235
R14255 n1_m1_408000_475200 n1_m1_412800_475200 5.356235
R14256 n1_m1_412800_475200 n1_m1_417600_475200 5.356235
R14257 n1_m1_417600_475200 n1_m1_422400_475200 5.356235
R14258 n1_m1_422400_475200 n1_m1_424000_475200 1.785412
R14259 n1_m1_427200_475200 n1_m1_424000_475200 3.570824
R14260 n1_m1_427200_475200 n1_m1_432000_475200 5.356235
R14261 n1_m1_432000_475200 n1_m1_436800_475200 5.356235
R14262 n1_m1_436800_475200 n1_m1_441600_475200 5.356235
R14263 n1_m1_441600_475200 n1_m1_446400_475200 5.356235
R14264 n1_m1_446400_475200 n1_m1_451200_475200 5.356235
R14265 n1_m1_451200_475200 n1_m1_452000_475200 0.892706
R14266 n1_m1_456000_475200 n1_m1_452000_475200 4.463529
R14267 n1_m1_456000_475200 n1_m1_460800_475200 5.356235
R14268 n1_m1_460800_475200 n1_m1_465600_475200 5.356235
R14269 n1_m1_465600_475200 n1_m1_470400_475200 5.356235
R14270 n1_m1_470400_475200 n1_m1_475200_475200 5.356235
R14271 n1_m1_475200_475200 n1_m1_480000_475200 5.356235
R14272 n1_m1_480000_475200 n1_m1_484800_475200 5.356235
R14273 n1_m1_484800_475200 n1_m1_489600_475200 5.356235
R14274 n1_m1_489600_475200 n1_m1_494400_475200 5.356235
R14275 n1_m1_494400_475200 n1_m1_499200_475200 5.356235
R14276 n1_m1_499200_475200 n1_m1_504000_475200 5.356235
R14277 n1_m1_504000_475200 n1_m1_508000_475200 4.463529
R14278 n1_m1_508800_475200 n1_m1_508000_475200 0.892706
R14279 n1_m1_508800_475200 n1_m1_513600_475200 5.356235
R14280 n1_m1_513600_475200 n1_m1_518400_475200 5.356235
R14281 n1_m1_518400_475200 n1_m1_523200_475200 5.356235
R14282 n1_m1_523200_475200 n1_m1_528000_475200 5.356235
R14283 n1_m1_528000_475200 n1_m1_532800_475200 5.356235
R14284 n1_m1_532800_475200 n1_m1_536000_475200 3.570824
R14285 n1_m1_537600_475200 n1_m1_536000_475200 1.785412
R14286 n1_m1_537600_475200 n1_m1_542400_475200 5.356235
R14287 n1_m1_542400_475200 n1_m1_547200_475200 5.356235
R14288 n1_m1_547200_475200 n1_m1_552000_475200 5.356235
R14289 n1_m1_552000_475200 n1_m1_556800_475200 5.356235
R14290 n1_m1_556800_475200 n1_m1_561600_475200 5.356235
R14291 n1_m1_561600_475200 n1_m1_564000_475200 2.678118
R14292 n1_m1_566400_475200 n1_m1_564000_475200 2.678118
R14293 n1_m1_566400_475200 n1_m1_571200_475200 5.356235
R14294 n1_m1_571200_475200 n1_m1_576000_475200 5.356235
R14295 n1_m1_576000_475200 n1_m1_580800_475200 5.356235
R14296 n1_m1_580800_475200 n1_m1_585600_475200 5.356235
R14297 n1_m1_585600_475200 n1_m1_590400_475200 5.356235
R14298 n1_m1_590400_475200 n1_m1_592000_475200 1.785412
R14299 n1_m1_595200_475200 n1_m1_592000_475200 3.570824
R14300 n1_m1_0_480000 n1_m1_4000_480000 4.463529
R14301 n1_m1_4800_480000 n1_m1_4000_480000 0.892706
R14302 n1_m1_4800_480000 n1_m1_9600_480000 5.356235
R14303 n1_m1_9600_480000 n1_m1_14400_480000 5.356235
R14304 n1_m1_14400_480000 n1_m1_19200_480000 5.356235
R14305 n1_m1_19200_480000 n1_m1_24000_480000 5.356235
R14306 n1_m1_24000_480000 n1_m1_28800_480000 5.356235
R14307 n1_m1_28800_480000 n1_m1_32000_480000 3.570824
R14308 n1_m1_33600_480000 n1_m1_32000_480000 1.785412
R14309 n1_m1_33600_480000 n1_m1_38400_480000 5.356235
R14310 n1_m1_38400_480000 n1_m1_43200_480000 5.356235
R14311 n1_m1_43200_480000 n1_m1_48000_480000 5.356235
R14312 n1_m1_48000_480000 n1_m1_52800_480000 5.356235
R14313 n1_m1_52800_480000 n1_m1_57600_480000 5.356235
R14314 n1_m1_57600_480000 n1_m1_60000_480000 2.678118
R14315 n1_m1_62400_480000 n1_m1_60000_480000 2.678118
R14316 n1_m1_62400_480000 n1_m1_67200_480000 5.356235
R14317 n1_m1_67200_480000 n1_m1_72000_480000 5.356235
R14318 n1_m1_72000_480000 n1_m1_76800_480000 5.356235
R14319 n1_m1_76800_480000 n1_m1_81600_480000 5.356235
R14320 n1_m1_81600_480000 n1_m1_86400_480000 5.356235
R14321 n1_m1_86400_480000 n1_m1_88000_480000 1.785412
R14322 n1_m1_91200_480000 n1_m1_88000_480000 3.570824
R14323 n1_m1_91200_480000 n1_m1_96000_480000 5.356235
R14324 n1_m1_96000_480000 n1_m1_100800_480000 5.356235
R14325 n1_m1_100800_480000 n1_m1_105600_480000 5.356235
R14326 n1_m1_105600_480000 n1_m1_110400_480000 5.356235
R14327 n1_m1_110400_480000 n1_m1_115200_480000 5.356235
R14328 n1_m1_115200_480000 n1_m1_116000_480000 0.892706
R14329 n1_m1_120000_480000 n1_m1_116000_480000 4.463529
R14330 n1_m1_120000_480000 n1_m1_124800_480000 5.356235
R14331 n1_m1_124800_480000 n1_m1_129600_480000 5.356235
R14332 n1_m1_129600_480000 n1_m1_134400_480000 5.356235
R14333 n1_m1_134400_480000 n1_m1_139200_480000 5.356235
R14334 n1_m1_139200_480000 n1_m1_144000_480000 5.356235
R14335 n1_m1_144000_480000 n1_m1_148800_480000 5.356235
R14336 n1_m1_148800_480000 n1_m1_153600_480000 5.356235
R14337 n1_m1_153600_480000 n1_m1_158400_480000 5.356235
R14338 n1_m1_158400_480000 n1_m1_163200_480000 5.356235
R14339 n1_m1_163200_480000 n1_m1_168000_480000 5.356235
R14340 n1_m1_168000_480000 n1_m1_172000_480000 4.463529
R14341 n1_m1_172800_480000 n1_m1_172000_480000 0.892706
R14342 n1_m1_172800_480000 n1_m1_177600_480000 5.356235
R14343 n1_m1_177600_480000 n1_m1_182400_480000 5.356235
R14344 n1_m1_182400_480000 n1_m1_187200_480000 5.356235
R14345 n1_m1_187200_480000 n1_m1_192000_480000 5.356235
R14346 n1_m1_192000_480000 n1_m1_196800_480000 5.356235
R14347 n1_m1_196800_480000 n1_m1_200000_480000 3.570824
R14348 n1_m1_201600_480000 n1_m1_200000_480000 1.785412
R14349 n1_m1_201600_480000 n1_m1_206400_480000 5.356235
R14350 n1_m1_206400_480000 n1_m1_211200_480000 5.356235
R14351 n1_m1_211200_480000 n1_m1_216000_480000 5.356235
R14352 n1_m1_216000_480000 n1_m1_220800_480000 5.356235
R14353 n1_m1_220800_480000 n1_m1_225600_480000 5.356235
R14354 n1_m1_225600_480000 n1_m1_228000_480000 2.678118
R14355 n1_m1_230400_480000 n1_m1_228000_480000 2.678118
R14356 n1_m1_230400_480000 n1_m1_235200_480000 5.356235
R14357 n1_m1_235200_480000 n1_m1_240000_480000 5.356235
R14358 n1_m1_240000_480000 n1_m1_244800_480000 5.356235
R14359 n1_m1_244800_480000 n1_m1_249600_480000 5.356235
R14360 n1_m1_249600_480000 n1_m1_254400_480000 5.356235
R14361 n1_m1_254400_480000 n1_m1_256000_480000 1.785412
R14362 n1_m1_259200_480000 n1_m1_256000_480000 3.570824
R14363 n1_m1_259200_480000 n1_m1_264000_480000 5.356235
R14364 n1_m1_264000_480000 n1_m1_268800_480000 5.356235
R14365 n1_m1_268800_480000 n1_m1_273600_480000 5.356235
R14366 n1_m1_273600_480000 n1_m1_278400_480000 5.356235
R14367 n1_m1_278400_480000 n1_m1_283200_480000 5.356235
R14368 n1_m1_283200_480000 n1_m1_284000_480000 0.892706
R14369 n1_m1_288000_480000 n1_m1_284000_480000 4.463529
R14370 n1_m1_288000_480000 n1_m1_292800_480000 5.356235
R14371 n1_m1_292800_480000 n1_m1_297600_480000 5.356235
R14372 n1_m1_297600_480000 n1_m1_302400_480000 5.356235
R14373 n1_m1_302400_480000 n1_m1_307200_480000 5.356235
R14374 n1_m1_307200_480000 n1_m1_312000_480000 5.356235
R14375 n1_m1_312000_480000 n1_m1_316800_480000 5.356235
R14376 n1_m1_316800_480000 n1_m1_321600_480000 5.356235
R14377 n1_m1_321600_480000 n1_m1_326400_480000 5.356235
R14378 n1_m1_326400_480000 n1_m1_331200_480000 5.356235
R14379 n1_m1_331200_480000 n1_m1_336000_480000 5.356235
R14380 n1_m1_336000_480000 n1_m1_340000_480000 4.463529
R14381 n1_m1_340800_480000 n1_m1_340000_480000 0.892706
R14382 n1_m1_340800_480000 n1_m1_345600_480000 5.356235
R14383 n1_m1_345600_480000 n1_m1_350400_480000 5.356235
R14384 n1_m1_350400_480000 n1_m1_355200_480000 5.356235
R14385 n1_m1_355200_480000 n1_m1_360000_480000 5.356235
R14386 n1_m1_360000_480000 n1_m1_364800_480000 5.356235
R14387 n1_m1_364800_480000 n1_m1_368000_480000 3.570824
R14388 n1_m1_369600_480000 n1_m1_368000_480000 1.785412
R14389 n1_m1_369600_480000 n1_m1_374400_480000 5.356235
R14390 n1_m1_374400_480000 n1_m1_379200_480000 5.356235
R14391 n1_m1_379200_480000 n1_m1_384000_480000 5.356235
R14392 n1_m1_384000_480000 n1_m1_388800_480000 5.356235
R14393 n1_m1_388800_480000 n1_m1_393600_480000 5.356235
R14394 n1_m1_393600_480000 n1_m1_396000_480000 2.678118
R14395 n1_m1_398400_480000 n1_m1_396000_480000 2.678118
R14396 n1_m1_398400_480000 n1_m1_403200_480000 5.356235
R14397 n1_m1_403200_480000 n1_m1_408000_480000 5.356235
R14398 n1_m1_408000_480000 n1_m1_412800_480000 5.356235
R14399 n1_m1_412800_480000 n1_m1_417600_480000 5.356235
R14400 n1_m1_417600_480000 n1_m1_422400_480000 5.356235
R14401 n1_m1_422400_480000 n1_m1_424000_480000 1.785412
R14402 n1_m1_427200_480000 n1_m1_424000_480000 3.570824
R14403 n1_m1_427200_480000 n1_m1_432000_480000 5.356235
R14404 n1_m1_432000_480000 n1_m1_436800_480000 5.356235
R14405 n1_m1_436800_480000 n1_m1_441600_480000 5.356235
R14406 n1_m1_441600_480000 n1_m1_446400_480000 5.356235
R14407 n1_m1_446400_480000 n1_m1_451200_480000 5.356235
R14408 n1_m1_451200_480000 n1_m1_452000_480000 0.892706
R14409 n1_m1_456000_480000 n1_m1_452000_480000 4.463529
R14410 n1_m1_456000_480000 n1_m1_460800_480000 5.356235
R14411 n1_m1_460800_480000 n1_m1_465600_480000 5.356235
R14412 n1_m1_465600_480000 n1_m1_470400_480000 5.356235
R14413 n1_m1_470400_480000 n1_m1_475200_480000 5.356235
R14414 n1_m1_475200_480000 n1_m1_480000_480000 5.356235
R14415 n1_m1_480000_480000 n1_m1_484800_480000 5.356235
R14416 n1_m1_484800_480000 n1_m1_489600_480000 5.356235
R14417 n1_m1_489600_480000 n1_m1_494400_480000 5.356235
R14418 n1_m1_494400_480000 n1_m1_499200_480000 5.356235
R14419 n1_m1_499200_480000 n1_m1_504000_480000 5.356235
R14420 n1_m1_504000_480000 n1_m1_508000_480000 4.463529
R14421 n1_m1_508800_480000 n1_m1_508000_480000 0.892706
R14422 n1_m1_508800_480000 n1_m1_513600_480000 5.356235
R14423 n1_m1_513600_480000 n1_m1_518400_480000 5.356235
R14424 n1_m1_518400_480000 n1_m1_523200_480000 5.356235
R14425 n1_m1_523200_480000 n1_m1_528000_480000 5.356235
R14426 n1_m1_528000_480000 n1_m1_532800_480000 5.356235
R14427 n1_m1_532800_480000 n1_m1_536000_480000 3.570824
R14428 n1_m1_537600_480000 n1_m1_536000_480000 1.785412
R14429 n1_m1_537600_480000 n1_m1_542400_480000 5.356235
R14430 n1_m1_542400_480000 n1_m1_547200_480000 5.356235
R14431 n1_m1_547200_480000 n1_m1_552000_480000 5.356235
R14432 n1_m1_552000_480000 n1_m1_556800_480000 5.356235
R14433 n1_m1_556800_480000 n1_m1_561600_480000 5.356235
R14434 n1_m1_561600_480000 n1_m1_564000_480000 2.678118
R14435 n1_m1_566400_480000 n1_m1_564000_480000 2.678118
R14436 n1_m1_566400_480000 n1_m1_571200_480000 5.356235
R14437 n1_m1_571200_480000 n1_m1_576000_480000 5.356235
R14438 n1_m1_576000_480000 n1_m1_580800_480000 5.356235
R14439 n1_m1_580800_480000 n1_m1_585600_480000 5.356235
R14440 n1_m1_585600_480000 n1_m1_590400_480000 5.356235
R14441 n1_m1_590400_480000 n1_m1_592000_480000 1.785412
R14442 n1_m1_595200_480000 n1_m1_592000_480000 3.570824
R14443 n1_m1_0_484800 n1_m1_4000_484800 4.463529
R14444 n1_m1_4800_484800 n1_m1_4000_484800 0.892706
R14445 n1_m1_4800_484800 n1_m1_9600_484800 5.356235
R14446 n1_m1_9600_484800 n1_m1_14400_484800 5.356235
R14447 n1_m1_14400_484800 n1_m1_19200_484800 5.356235
R14448 n1_m1_19200_484800 n1_m1_24000_484800 5.356235
R14449 n1_m1_24000_484800 n1_m1_28800_484800 5.356235
R14450 n1_m1_28800_484800 n1_m1_32000_484800 3.570824
R14451 n1_m1_33600_484800 n1_m1_32000_484800 1.785412
R14452 n1_m1_33600_484800 n1_m1_38400_484800 5.356235
R14453 n1_m1_38400_484800 n1_m1_43200_484800 5.356235
R14454 n1_m1_43200_484800 n1_m1_48000_484800 5.356235
R14455 n1_m1_48000_484800 n1_m1_52800_484800 5.356235
R14456 n1_m1_52800_484800 n1_m1_57600_484800 5.356235
R14457 n1_m1_57600_484800 n1_m1_60000_484800 2.678118
R14458 n1_m1_62400_484800 n1_m1_60000_484800 2.678118
R14459 n1_m1_62400_484800 n1_m1_67200_484800 5.356235
R14460 n1_m1_67200_484800 n1_m1_72000_484800 5.356235
R14461 n1_m1_72000_484800 n1_m1_76800_484800 5.356235
R14462 n1_m1_76800_484800 n1_m1_81600_484800 5.356235
R14463 n1_m1_81600_484800 n1_m1_86400_484800 5.356235
R14464 n1_m1_86400_484800 n1_m1_88000_484800 1.785412
R14465 n1_m1_91200_484800 n1_m1_88000_484800 3.570824
R14466 n1_m1_91200_484800 n1_m1_96000_484800 5.356235
R14467 n1_m1_96000_484800 n1_m1_100800_484800 5.356235
R14468 n1_m1_100800_484800 n1_m1_105600_484800 5.356235
R14469 n1_m1_105600_484800 n1_m1_110400_484800 5.356235
R14470 n1_m1_110400_484800 n1_m1_115200_484800 5.356235
R14471 n1_m1_115200_484800 n1_m1_116000_484800 0.892706
R14472 n1_m1_120000_484800 n1_m1_116000_484800 4.463529
R14473 n1_m1_120000_484800 n1_m1_124800_484800 5.356235
R14474 n1_m1_124800_484800 n1_m1_129600_484800 5.356235
R14475 n1_m1_129600_484800 n1_m1_134400_484800 5.356235
R14476 n1_m1_134400_484800 n1_m1_139200_484800 5.356235
R14477 n1_m1_139200_484800 n1_m1_144000_484800 5.356235
R14478 n1_m1_144000_484800 n1_m1_148800_484800 5.356235
R14479 n1_m1_148800_484800 n1_m1_153600_484800 5.356235
R14480 n1_m1_153600_484800 n1_m1_158400_484800 5.356235
R14481 n1_m1_158400_484800 n1_m1_163200_484800 5.356235
R14482 n1_m1_163200_484800 n1_m1_168000_484800 5.356235
R14483 n1_m1_168000_484800 n1_m1_172000_484800 4.463529
R14484 n1_m1_172800_484800 n1_m1_172000_484800 0.892706
R14485 n1_m1_172800_484800 n1_m1_177600_484800 5.356235
R14486 n1_m1_177600_484800 n1_m1_182400_484800 5.356235
R14487 n1_m1_182400_484800 n1_m1_187200_484800 5.356235
R14488 n1_m1_187200_484800 n1_m1_192000_484800 5.356235
R14489 n1_m1_192000_484800 n1_m1_196800_484800 5.356235
R14490 n1_m1_196800_484800 n1_m1_200000_484800 3.570824
R14491 n1_m1_201600_484800 n1_m1_200000_484800 1.785412
R14492 n1_m1_201600_484800 n1_m1_206400_484800 5.356235
R14493 n1_m1_206400_484800 n1_m1_211200_484800 5.356235
R14494 n1_m1_211200_484800 n1_m1_216000_484800 5.356235
R14495 n1_m1_216000_484800 n1_m1_220800_484800 5.356235
R14496 n1_m1_220800_484800 n1_m1_225600_484800 5.356235
R14497 n1_m1_225600_484800 n1_m1_228000_484800 2.678118
R14498 n1_m1_230400_484800 n1_m1_228000_484800 2.678118
R14499 n1_m1_230400_484800 n1_m1_235200_484800 5.356235
R14500 n1_m1_235200_484800 n1_m1_240000_484800 5.356235
R14501 n1_m1_240000_484800 n1_m1_244800_484800 5.356235
R14502 n1_m1_244800_484800 n1_m1_249600_484800 5.356235
R14503 n1_m1_249600_484800 n1_m1_254400_484800 5.356235
R14504 n1_m1_254400_484800 n1_m1_256000_484800 1.785412
R14505 n1_m1_259200_484800 n1_m1_256000_484800 3.570824
R14506 n1_m1_259200_484800 n1_m1_264000_484800 5.356235
R14507 n1_m1_264000_484800 n1_m1_268800_484800 5.356235
R14508 n1_m1_268800_484800 n1_m1_273600_484800 5.356235
R14509 n1_m1_273600_484800 n1_m1_278400_484800 5.356235
R14510 n1_m1_278400_484800 n1_m1_283200_484800 5.356235
R14511 n1_m1_283200_484800 n1_m1_284000_484800 0.892706
R14512 n1_m1_288000_484800 n1_m1_284000_484800 4.463529
R14513 n1_m1_288000_484800 n1_m1_292800_484800 5.356235
R14514 n1_m1_292800_484800 n1_m1_297600_484800 5.356235
R14515 n1_m1_297600_484800 n1_m1_302400_484800 5.356235
R14516 n1_m1_302400_484800 n1_m1_307200_484800 5.356235
R14517 n1_m1_307200_484800 n1_m1_312000_484800 5.356235
R14518 n1_m1_312000_484800 n1_m1_316800_484800 5.356235
R14519 n1_m1_316800_484800 n1_m1_321600_484800 5.356235
R14520 n1_m1_321600_484800 n1_m1_326400_484800 5.356235
R14521 n1_m1_326400_484800 n1_m1_331200_484800 5.356235
R14522 n1_m1_331200_484800 n1_m1_336000_484800 5.356235
R14523 n1_m1_336000_484800 n1_m1_340000_484800 4.463529
R14524 n1_m1_340800_484800 n1_m1_340000_484800 0.892706
R14525 n1_m1_340800_484800 n1_m1_345600_484800 5.356235
R14526 n1_m1_345600_484800 n1_m1_350400_484800 5.356235
R14527 n1_m1_350400_484800 n1_m1_355200_484800 5.356235
R14528 n1_m1_355200_484800 n1_m1_360000_484800 5.356235
R14529 n1_m1_360000_484800 n1_m1_364800_484800 5.356235
R14530 n1_m1_364800_484800 n1_m1_368000_484800 3.570824
R14531 n1_m1_369600_484800 n1_m1_368000_484800 1.785412
R14532 n1_m1_369600_484800 n1_m1_374400_484800 5.356235
R14533 n1_m1_374400_484800 n1_m1_379200_484800 5.356235
R14534 n1_m1_379200_484800 n1_m1_384000_484800 5.356235
R14535 n1_m1_384000_484800 n1_m1_388800_484800 5.356235
R14536 n1_m1_388800_484800 n1_m1_393600_484800 5.356235
R14537 n1_m1_393600_484800 n1_m1_396000_484800 2.678118
R14538 n1_m1_398400_484800 n1_m1_396000_484800 2.678118
R14539 n1_m1_398400_484800 n1_m1_403200_484800 5.356235
R14540 n1_m1_403200_484800 n1_m1_408000_484800 5.356235
R14541 n1_m1_408000_484800 n1_m1_412800_484800 5.356235
R14542 n1_m1_412800_484800 n1_m1_417600_484800 5.356235
R14543 n1_m1_417600_484800 n1_m1_422400_484800 5.356235
R14544 n1_m1_422400_484800 n1_m1_424000_484800 1.785412
R14545 n1_m1_427200_484800 n1_m1_424000_484800 3.570824
R14546 n1_m1_427200_484800 n1_m1_432000_484800 5.356235
R14547 n1_m1_432000_484800 n1_m1_436800_484800 5.356235
R14548 n1_m1_436800_484800 n1_m1_441600_484800 5.356235
R14549 n1_m1_441600_484800 n1_m1_446400_484800 5.356235
R14550 n1_m1_446400_484800 n1_m1_451200_484800 5.356235
R14551 n1_m1_451200_484800 n1_m1_452000_484800 0.892706
R14552 n1_m1_456000_484800 n1_m1_452000_484800 4.463529
R14553 n1_m1_456000_484800 n1_m1_460800_484800 5.356235
R14554 n1_m1_460800_484800 n1_m1_465600_484800 5.356235
R14555 n1_m1_465600_484800 n1_m1_470400_484800 5.356235
R14556 n1_m1_470400_484800 n1_m1_475200_484800 5.356235
R14557 n1_m1_475200_484800 n1_m1_480000_484800 5.356235
R14558 n1_m1_480000_484800 n1_m1_484800_484800 5.356235
R14559 n1_m1_484800_484800 n1_m1_489600_484800 5.356235
R14560 n1_m1_489600_484800 n1_m1_494400_484800 5.356235
R14561 n1_m1_494400_484800 n1_m1_499200_484800 5.356235
R14562 n1_m1_499200_484800 n1_m1_504000_484800 5.356235
R14563 n1_m1_504000_484800 n1_m1_508000_484800 4.463529
R14564 n1_m1_508800_484800 n1_m1_508000_484800 0.892706
R14565 n1_m1_508800_484800 n1_m1_513600_484800 5.356235
R14566 n1_m1_513600_484800 n1_m1_518400_484800 5.356235
R14567 n1_m1_518400_484800 n1_m1_523200_484800 5.356235
R14568 n1_m1_523200_484800 n1_m1_528000_484800 5.356235
R14569 n1_m1_528000_484800 n1_m1_532800_484800 5.356235
R14570 n1_m1_532800_484800 n1_m1_536000_484800 3.570824
R14571 n1_m1_537600_484800 n1_m1_536000_484800 1.785412
R14572 n1_m1_537600_484800 n1_m1_542400_484800 5.356235
R14573 n1_m1_542400_484800 n1_m1_547200_484800 5.356235
R14574 n1_m1_547200_484800 n1_m1_552000_484800 5.356235
R14575 n1_m1_552000_484800 n1_m1_556800_484800 5.356235
R14576 n1_m1_556800_484800 n1_m1_561600_484800 5.356235
R14577 n1_m1_561600_484800 n1_m1_564000_484800 2.678118
R14578 n1_m1_566400_484800 n1_m1_564000_484800 2.678118
R14579 n1_m1_566400_484800 n1_m1_571200_484800 5.356235
R14580 n1_m1_571200_484800 n1_m1_576000_484800 5.356235
R14581 n1_m1_576000_484800 n1_m1_580800_484800 5.356235
R14582 n1_m1_580800_484800 n1_m1_585600_484800 5.356235
R14583 n1_m1_585600_484800 n1_m1_590400_484800 5.356235
R14584 n1_m1_590400_484800 n1_m1_592000_484800 1.785412
R14585 n1_m1_595200_484800 n1_m1_592000_484800 3.570824
R14586 n1_m1_0_489600 n1_m1_4000_489600 4.463529
R14587 n1_m1_4800_489600 n1_m1_4000_489600 0.892706
R14588 n1_m1_4800_489600 n1_m1_9600_489600 5.356235
R14589 n1_m1_9600_489600 n1_m1_14400_489600 5.356235
R14590 n1_m1_14400_489600 n1_m1_19200_489600 5.356235
R14591 n1_m1_19200_489600 n1_m1_24000_489600 5.356235
R14592 n1_m1_24000_489600 n1_m1_28800_489600 5.356235
R14593 n1_m1_28800_489600 n1_m1_32000_489600 3.570824
R14594 n1_m1_33600_489600 n1_m1_32000_489600 1.785412
R14595 n1_m1_33600_489600 n1_m1_38400_489600 5.356235
R14596 n1_m1_38400_489600 n1_m1_43200_489600 5.356235
R14597 n1_m1_43200_489600 n1_m1_48000_489600 5.356235
R14598 n1_m1_48000_489600 n1_m1_52800_489600 5.356235
R14599 n1_m1_52800_489600 n1_m1_57600_489600 5.356235
R14600 n1_m1_57600_489600 n1_m1_60000_489600 2.678118
R14601 n1_m1_62400_489600 n1_m1_60000_489600 2.678118
R14602 n1_m1_62400_489600 n1_m1_67200_489600 5.356235
R14603 n1_m1_67200_489600 n1_m1_72000_489600 5.356235
R14604 n1_m1_72000_489600 n1_m1_76800_489600 5.356235
R14605 n1_m1_76800_489600 n1_m1_81600_489600 5.356235
R14606 n1_m1_81600_489600 n1_m1_86400_489600 5.356235
R14607 n1_m1_86400_489600 n1_m1_88000_489600 1.785412
R14608 n1_m1_91200_489600 n1_m1_88000_489600 3.570824
R14609 n1_m1_91200_489600 n1_m1_96000_489600 5.356235
R14610 n1_m1_96000_489600 n1_m1_100800_489600 5.356235
R14611 n1_m1_100800_489600 n1_m1_105600_489600 5.356235
R14612 n1_m1_105600_489600 n1_m1_110400_489600 5.356235
R14613 n1_m1_110400_489600 n1_m1_115200_489600 5.356235
R14614 n1_m1_115200_489600 n1_m1_116000_489600 0.892706
R14615 n1_m1_120000_489600 n1_m1_116000_489600 4.463529
R14616 n1_m1_120000_489600 n1_m1_124800_489600 5.356235
R14617 n1_m1_124800_489600 n1_m1_129600_489600 5.356235
R14618 n1_m1_129600_489600 n1_m1_134400_489600 5.356235
R14619 n1_m1_134400_489600 n1_m1_139200_489600 5.356235
R14620 n1_m1_139200_489600 n1_m1_144000_489600 5.356235
R14621 n1_m1_144000_489600 n1_m1_148800_489600 5.356235
R14622 n1_m1_148800_489600 n1_m1_153600_489600 5.356235
R14623 n1_m1_153600_489600 n1_m1_158400_489600 5.356235
R14624 n1_m1_158400_489600 n1_m1_163200_489600 5.356235
R14625 n1_m1_163200_489600 n1_m1_168000_489600 5.356235
R14626 n1_m1_168000_489600 n1_m1_172000_489600 4.463529
R14627 n1_m1_172800_489600 n1_m1_172000_489600 0.892706
R14628 n1_m1_172800_489600 n1_m1_177600_489600 5.356235
R14629 n1_m1_177600_489600 n1_m1_182400_489600 5.356235
R14630 n1_m1_182400_489600 n1_m1_187200_489600 5.356235
R14631 n1_m1_187200_489600 n1_m1_192000_489600 5.356235
R14632 n1_m1_192000_489600 n1_m1_196800_489600 5.356235
R14633 n1_m1_196800_489600 n1_m1_200000_489600 3.570824
R14634 n1_m1_201600_489600 n1_m1_200000_489600 1.785412
R14635 n1_m1_201600_489600 n1_m1_206400_489600 5.356235
R14636 n1_m1_206400_489600 n1_m1_211200_489600 5.356235
R14637 n1_m1_211200_489600 n1_m1_216000_489600 5.356235
R14638 n1_m1_216000_489600 n1_m1_220800_489600 5.356235
R14639 n1_m1_220800_489600 n1_m1_225600_489600 5.356235
R14640 n1_m1_225600_489600 n1_m1_228000_489600 2.678118
R14641 n1_m1_230400_489600 n1_m1_228000_489600 2.678118
R14642 n1_m1_230400_489600 n1_m1_235200_489600 5.356235
R14643 n1_m1_235200_489600 n1_m1_240000_489600 5.356235
R14644 n1_m1_240000_489600 n1_m1_244800_489600 5.356235
R14645 n1_m1_244800_489600 n1_m1_249600_489600 5.356235
R14646 n1_m1_249600_489600 n1_m1_254400_489600 5.356235
R14647 n1_m1_254400_489600 n1_m1_256000_489600 1.785412
R14648 n1_m1_259200_489600 n1_m1_256000_489600 3.570824
R14649 n1_m1_259200_489600 n1_m1_264000_489600 5.356235
R14650 n1_m1_264000_489600 n1_m1_268800_489600 5.356235
R14651 n1_m1_268800_489600 n1_m1_273600_489600 5.356235
R14652 n1_m1_273600_489600 n1_m1_278400_489600 5.356235
R14653 n1_m1_278400_489600 n1_m1_283200_489600 5.356235
R14654 n1_m1_283200_489600 n1_m1_284000_489600 0.892706
R14655 n1_m1_288000_489600 n1_m1_284000_489600 4.463529
R14656 n1_m1_288000_489600 n1_m1_292800_489600 5.356235
R14657 n1_m1_292800_489600 n1_m1_297600_489600 5.356235
R14658 n1_m1_297600_489600 n1_m1_302400_489600 5.356235
R14659 n1_m1_302400_489600 n1_m1_307200_489600 5.356235
R14660 n1_m1_307200_489600 n1_m1_312000_489600 5.356235
R14661 n1_m1_312000_489600 n1_m1_316800_489600 5.356235
R14662 n1_m1_316800_489600 n1_m1_321600_489600 5.356235
R14663 n1_m1_321600_489600 n1_m1_326400_489600 5.356235
R14664 n1_m1_326400_489600 n1_m1_331200_489600 5.356235
R14665 n1_m1_331200_489600 n1_m1_336000_489600 5.356235
R14666 n1_m1_336000_489600 n1_m1_340000_489600 4.463529
R14667 n1_m1_340800_489600 n1_m1_340000_489600 0.892706
R14668 n1_m1_340800_489600 n1_m1_345600_489600 5.356235
R14669 n1_m1_345600_489600 n1_m1_350400_489600 5.356235
R14670 n1_m1_350400_489600 n1_m1_355200_489600 5.356235
R14671 n1_m1_355200_489600 n1_m1_360000_489600 5.356235
R14672 n1_m1_360000_489600 n1_m1_364800_489600 5.356235
R14673 n1_m1_364800_489600 n1_m1_368000_489600 3.570824
R14674 n1_m1_369600_489600 n1_m1_368000_489600 1.785412
R14675 n1_m1_369600_489600 n1_m1_374400_489600 5.356235
R14676 n1_m1_374400_489600 n1_m1_379200_489600 5.356235
R14677 n1_m1_379200_489600 n1_m1_384000_489600 5.356235
R14678 n1_m1_384000_489600 n1_m1_388800_489600 5.356235
R14679 n1_m1_388800_489600 n1_m1_393600_489600 5.356235
R14680 n1_m1_393600_489600 n1_m1_396000_489600 2.678118
R14681 n1_m1_398400_489600 n1_m1_396000_489600 2.678118
R14682 n1_m1_398400_489600 n1_m1_403200_489600 5.356235
R14683 n1_m1_403200_489600 n1_m1_408000_489600 5.356235
R14684 n1_m1_408000_489600 n1_m1_412800_489600 5.356235
R14685 n1_m1_412800_489600 n1_m1_417600_489600 5.356235
R14686 n1_m1_417600_489600 n1_m1_422400_489600 5.356235
R14687 n1_m1_422400_489600 n1_m1_424000_489600 1.785412
R14688 n1_m1_427200_489600 n1_m1_424000_489600 3.570824
R14689 n1_m1_427200_489600 n1_m1_432000_489600 5.356235
R14690 n1_m1_432000_489600 n1_m1_436800_489600 5.356235
R14691 n1_m1_436800_489600 n1_m1_441600_489600 5.356235
R14692 n1_m1_441600_489600 n1_m1_446400_489600 5.356235
R14693 n1_m1_446400_489600 n1_m1_451200_489600 5.356235
R14694 n1_m1_451200_489600 n1_m1_452000_489600 0.892706
R14695 n1_m1_456000_489600 n1_m1_452000_489600 4.463529
R14696 n1_m1_456000_489600 n1_m1_460800_489600 5.356235
R14697 n1_m1_460800_489600 n1_m1_465600_489600 5.356235
R14698 n1_m1_465600_489600 n1_m1_470400_489600 5.356235
R14699 n1_m1_470400_489600 n1_m1_475200_489600 5.356235
R14700 n1_m1_475200_489600 n1_m1_480000_489600 5.356235
R14701 n1_m1_480000_489600 n1_m1_484800_489600 5.356235
R14702 n1_m1_484800_489600 n1_m1_489600_489600 5.356235
R14703 n1_m1_489600_489600 n1_m1_494400_489600 5.356235
R14704 n1_m1_494400_489600 n1_m1_499200_489600 5.356235
R14705 n1_m1_499200_489600 n1_m1_504000_489600 5.356235
R14706 n1_m1_504000_489600 n1_m1_508000_489600 4.463529
R14707 n1_m1_508800_489600 n1_m1_508000_489600 0.892706
R14708 n1_m1_508800_489600 n1_m1_513600_489600 5.356235
R14709 n1_m1_513600_489600 n1_m1_518400_489600 5.356235
R14710 n1_m1_518400_489600 n1_m1_523200_489600 5.356235
R14711 n1_m1_523200_489600 n1_m1_528000_489600 5.356235
R14712 n1_m1_528000_489600 n1_m1_532800_489600 5.356235
R14713 n1_m1_532800_489600 n1_m1_536000_489600 3.570824
R14714 n1_m1_537600_489600 n1_m1_536000_489600 1.785412
R14715 n1_m1_537600_489600 n1_m1_542400_489600 5.356235
R14716 n1_m1_542400_489600 n1_m1_547200_489600 5.356235
R14717 n1_m1_547200_489600 n1_m1_552000_489600 5.356235
R14718 n1_m1_552000_489600 n1_m1_556800_489600 5.356235
R14719 n1_m1_556800_489600 n1_m1_561600_489600 5.356235
R14720 n1_m1_561600_489600 n1_m1_564000_489600 2.678118
R14721 n1_m1_566400_489600 n1_m1_564000_489600 2.678118
R14722 n1_m1_566400_489600 n1_m1_571200_489600 5.356235
R14723 n1_m1_571200_489600 n1_m1_576000_489600 5.356235
R14724 n1_m1_576000_489600 n1_m1_580800_489600 5.356235
R14725 n1_m1_580800_489600 n1_m1_585600_489600 5.356235
R14726 n1_m1_585600_489600 n1_m1_590400_489600 5.356235
R14727 n1_m1_590400_489600 n1_m1_592000_489600 1.785412
R14728 n1_m1_595200_489600 n1_m1_592000_489600 3.570824
R14729 n1_m1_0_494400 n1_m1_4000_494400 4.463529
R14730 n1_m1_4800_494400 n1_m1_4000_494400 0.892706
R14731 n1_m1_4800_494400 n1_m1_9600_494400 5.356235
R14732 n1_m1_9600_494400 n1_m1_14400_494400 5.356235
R14733 n1_m1_14400_494400 n1_m1_19200_494400 5.356235
R14734 n1_m1_19200_494400 n1_m1_24000_494400 5.356235
R14735 n1_m1_24000_494400 n1_m1_28800_494400 5.356235
R14736 n1_m1_28800_494400 n1_m1_32000_494400 3.570824
R14737 n1_m1_33600_494400 n1_m1_32000_494400 1.785412
R14738 n1_m1_33600_494400 n1_m1_38400_494400 5.356235
R14739 n1_m1_38400_494400 n1_m1_43200_494400 5.356235
R14740 n1_m1_43200_494400 n1_m1_48000_494400 5.356235
R14741 n1_m1_48000_494400 n1_m1_52800_494400 5.356235
R14742 n1_m1_52800_494400 n1_m1_57600_494400 5.356235
R14743 n1_m1_57600_494400 n1_m1_60000_494400 2.678118
R14744 n1_m1_62400_494400 n1_m1_60000_494400 2.678118
R14745 n1_m1_62400_494400 n1_m1_67200_494400 5.356235
R14746 n1_m1_67200_494400 n1_m1_72000_494400 5.356235
R14747 n1_m1_72000_494400 n1_m1_76800_494400 5.356235
R14748 n1_m1_76800_494400 n1_m1_81600_494400 5.356235
R14749 n1_m1_81600_494400 n1_m1_86400_494400 5.356235
R14750 n1_m1_86400_494400 n1_m1_88000_494400 1.785412
R14751 n1_m1_91200_494400 n1_m1_88000_494400 3.570824
R14752 n1_m1_91200_494400 n1_m1_96000_494400 5.356235
R14753 n1_m1_96000_494400 n1_m1_100800_494400 5.356235
R14754 n1_m1_100800_494400 n1_m1_105600_494400 5.356235
R14755 n1_m1_105600_494400 n1_m1_110400_494400 5.356235
R14756 n1_m1_110400_494400 n1_m1_115200_494400 5.356235
R14757 n1_m1_115200_494400 n1_m1_116000_494400 0.892706
R14758 n1_m1_120000_494400 n1_m1_116000_494400 4.463529
R14759 n1_m1_120000_494400 n1_m1_124800_494400 5.356235
R14760 n1_m1_124800_494400 n1_m1_129600_494400 5.356235
R14761 n1_m1_129600_494400 n1_m1_134400_494400 5.356235
R14762 n1_m1_134400_494400 n1_m1_139200_494400 5.356235
R14763 n1_m1_139200_494400 n1_m1_144000_494400 5.356235
R14764 n1_m1_144000_494400 n1_m1_148800_494400 5.356235
R14765 n1_m1_148800_494400 n1_m1_153600_494400 5.356235
R14766 n1_m1_153600_494400 n1_m1_158400_494400 5.356235
R14767 n1_m1_158400_494400 n1_m1_163200_494400 5.356235
R14768 n1_m1_163200_494400 n1_m1_168000_494400 5.356235
R14769 n1_m1_168000_494400 n1_m1_172000_494400 4.463529
R14770 n1_m1_172800_494400 n1_m1_172000_494400 0.892706
R14771 n1_m1_172800_494400 n1_m1_177600_494400 5.356235
R14772 n1_m1_177600_494400 n1_m1_182400_494400 5.356235
R14773 n1_m1_182400_494400 n1_m1_187200_494400 5.356235
R14774 n1_m1_187200_494400 n1_m1_192000_494400 5.356235
R14775 n1_m1_192000_494400 n1_m1_196800_494400 5.356235
R14776 n1_m1_196800_494400 n1_m1_200000_494400 3.570824
R14777 n1_m1_201600_494400 n1_m1_200000_494400 1.785412
R14778 n1_m1_201600_494400 n1_m1_206400_494400 5.356235
R14779 n1_m1_206400_494400 n1_m1_211200_494400 5.356235
R14780 n1_m1_211200_494400 n1_m1_216000_494400 5.356235
R14781 n1_m1_216000_494400 n1_m1_220800_494400 5.356235
R14782 n1_m1_220800_494400 n1_m1_225600_494400 5.356235
R14783 n1_m1_225600_494400 n1_m1_228000_494400 2.678118
R14784 n1_m1_230400_494400 n1_m1_228000_494400 2.678118
R14785 n1_m1_230400_494400 n1_m1_235200_494400 5.356235
R14786 n1_m1_235200_494400 n1_m1_240000_494400 5.356235
R14787 n1_m1_240000_494400 n1_m1_244800_494400 5.356235
R14788 n1_m1_244800_494400 n1_m1_249600_494400 5.356235
R14789 n1_m1_249600_494400 n1_m1_254400_494400 5.356235
R14790 n1_m1_254400_494400 n1_m1_256000_494400 1.785412
R14791 n1_m1_259200_494400 n1_m1_256000_494400 3.570824
R14792 n1_m1_259200_494400 n1_m1_264000_494400 5.356235
R14793 n1_m1_264000_494400 n1_m1_268800_494400 5.356235
R14794 n1_m1_268800_494400 n1_m1_273600_494400 5.356235
R14795 n1_m1_273600_494400 n1_m1_278400_494400 5.356235
R14796 n1_m1_278400_494400 n1_m1_283200_494400 5.356235
R14797 n1_m1_283200_494400 n1_m1_284000_494400 0.892706
R14798 n1_m1_288000_494400 n1_m1_284000_494400 4.463529
R14799 n1_m1_288000_494400 n1_m1_292800_494400 5.356235
R14800 n1_m1_292800_494400 n1_m1_297600_494400 5.356235
R14801 n1_m1_297600_494400 n1_m1_302400_494400 5.356235
R14802 n1_m1_302400_494400 n1_m1_307200_494400 5.356235
R14803 n1_m1_307200_494400 n1_m1_312000_494400 5.356235
R14804 n1_m1_312000_494400 n1_m1_316800_494400 5.356235
R14805 n1_m1_316800_494400 n1_m1_321600_494400 5.356235
R14806 n1_m1_321600_494400 n1_m1_326400_494400 5.356235
R14807 n1_m1_326400_494400 n1_m1_331200_494400 5.356235
R14808 n1_m1_331200_494400 n1_m1_336000_494400 5.356235
R14809 n1_m1_336000_494400 n1_m1_340000_494400 4.463529
R14810 n1_m1_340800_494400 n1_m1_340000_494400 0.892706
R14811 n1_m1_340800_494400 n1_m1_345600_494400 5.356235
R14812 n1_m1_345600_494400 n1_m1_350400_494400 5.356235
R14813 n1_m1_350400_494400 n1_m1_355200_494400 5.356235
R14814 n1_m1_355200_494400 n1_m1_360000_494400 5.356235
R14815 n1_m1_360000_494400 n1_m1_364800_494400 5.356235
R14816 n1_m1_364800_494400 n1_m1_368000_494400 3.570824
R14817 n1_m1_369600_494400 n1_m1_368000_494400 1.785412
R14818 n1_m1_369600_494400 n1_m1_374400_494400 5.356235
R14819 n1_m1_374400_494400 n1_m1_379200_494400 5.356235
R14820 n1_m1_379200_494400 n1_m1_384000_494400 5.356235
R14821 n1_m1_384000_494400 n1_m1_388800_494400 5.356235
R14822 n1_m1_388800_494400 n1_m1_393600_494400 5.356235
R14823 n1_m1_393600_494400 n1_m1_396000_494400 2.678118
R14824 n1_m1_398400_494400 n1_m1_396000_494400 2.678118
R14825 n1_m1_398400_494400 n1_m1_403200_494400 5.356235
R14826 n1_m1_403200_494400 n1_m1_408000_494400 5.356235
R14827 n1_m1_408000_494400 n1_m1_412800_494400 5.356235
R14828 n1_m1_412800_494400 n1_m1_417600_494400 5.356235
R14829 n1_m1_417600_494400 n1_m1_422400_494400 5.356235
R14830 n1_m1_422400_494400 n1_m1_424000_494400 1.785412
R14831 n1_m1_427200_494400 n1_m1_424000_494400 3.570824
R14832 n1_m1_427200_494400 n1_m1_432000_494400 5.356235
R14833 n1_m1_432000_494400 n1_m1_436800_494400 5.356235
R14834 n1_m1_436800_494400 n1_m1_441600_494400 5.356235
R14835 n1_m1_441600_494400 n1_m1_446400_494400 5.356235
R14836 n1_m1_446400_494400 n1_m1_451200_494400 5.356235
R14837 n1_m1_451200_494400 n1_m1_452000_494400 0.892706
R14838 n1_m1_456000_494400 n1_m1_452000_494400 4.463529
R14839 n1_m1_456000_494400 n1_m1_460800_494400 5.356235
R14840 n1_m1_460800_494400 n1_m1_465600_494400 5.356235
R14841 n1_m1_465600_494400 n1_m1_470400_494400 5.356235
R14842 n1_m1_470400_494400 n1_m1_475200_494400 5.356235
R14843 n1_m1_475200_494400 n1_m1_480000_494400 5.356235
R14844 n1_m1_480000_494400 n1_m1_484800_494400 5.356235
R14845 n1_m1_484800_494400 n1_m1_489600_494400 5.356235
R14846 n1_m1_489600_494400 n1_m1_494400_494400 5.356235
R14847 n1_m1_494400_494400 n1_m1_499200_494400 5.356235
R14848 n1_m1_499200_494400 n1_m1_504000_494400 5.356235
R14849 n1_m1_504000_494400 n1_m1_508000_494400 4.463529
R14850 n1_m1_508800_494400 n1_m1_508000_494400 0.892706
R14851 n1_m1_508800_494400 n1_m1_513600_494400 5.356235
R14852 n1_m1_513600_494400 n1_m1_518400_494400 5.356235
R14853 n1_m1_518400_494400 n1_m1_523200_494400 5.356235
R14854 n1_m1_523200_494400 n1_m1_528000_494400 5.356235
R14855 n1_m1_528000_494400 n1_m1_532800_494400 5.356235
R14856 n1_m1_532800_494400 n1_m1_536000_494400 3.570824
R14857 n1_m1_537600_494400 n1_m1_536000_494400 1.785412
R14858 n1_m1_537600_494400 n1_m1_542400_494400 5.356235
R14859 n1_m1_542400_494400 n1_m1_547200_494400 5.356235
R14860 n1_m1_547200_494400 n1_m1_552000_494400 5.356235
R14861 n1_m1_552000_494400 n1_m1_556800_494400 5.356235
R14862 n1_m1_556800_494400 n1_m1_561600_494400 5.356235
R14863 n1_m1_561600_494400 n1_m1_564000_494400 2.678118
R14864 n1_m1_566400_494400 n1_m1_564000_494400 2.678118
R14865 n1_m1_566400_494400 n1_m1_571200_494400 5.356235
R14866 n1_m1_571200_494400 n1_m1_576000_494400 5.356235
R14867 n1_m1_576000_494400 n1_m1_580800_494400 5.356235
R14868 n1_m1_580800_494400 n1_m1_585600_494400 5.356235
R14869 n1_m1_585600_494400 n1_m1_590400_494400 5.356235
R14870 n1_m1_590400_494400 n1_m1_592000_494400 1.785412
R14871 n1_m1_595200_494400 n1_m1_592000_494400 3.570824
R14872 n1_m1_0_499200 n1_m1_4000_499200 4.463529
R14873 n1_m1_4800_499200 n1_m1_4000_499200 0.892706
R14874 n1_m1_4800_499200 n1_m1_9600_499200 5.356235
R14875 n1_m1_9600_499200 n1_m1_14400_499200 5.356235
R14876 n1_m1_14400_499200 n1_m1_19200_499200 5.356235
R14877 n1_m1_19200_499200 n1_m1_24000_499200 5.356235
R14878 n1_m1_24000_499200 n1_m1_28800_499200 5.356235
R14879 n1_m1_28800_499200 n1_m1_32000_499200 3.570824
R14880 n1_m1_33600_499200 n1_m1_32000_499200 1.785412
R14881 n1_m1_33600_499200 n1_m1_38400_499200 5.356235
R14882 n1_m1_38400_499200 n1_m1_43200_499200 5.356235
R14883 n1_m1_43200_499200 n1_m1_48000_499200 5.356235
R14884 n1_m1_48000_499200 n1_m1_52800_499200 5.356235
R14885 n1_m1_52800_499200 n1_m1_57600_499200 5.356235
R14886 n1_m1_57600_499200 n1_m1_60000_499200 2.678118
R14887 n1_m1_62400_499200 n1_m1_60000_499200 2.678118
R14888 n1_m1_62400_499200 n1_m1_67200_499200 5.356235
R14889 n1_m1_67200_499200 n1_m1_72000_499200 5.356235
R14890 n1_m1_72000_499200 n1_m1_76800_499200 5.356235
R14891 n1_m1_76800_499200 n1_m1_81600_499200 5.356235
R14892 n1_m1_81600_499200 n1_m1_86400_499200 5.356235
R14893 n1_m1_86400_499200 n1_m1_88000_499200 1.785412
R14894 n1_m1_91200_499200 n1_m1_88000_499200 3.570824
R14895 n1_m1_91200_499200 n1_m1_96000_499200 5.356235
R14896 n1_m1_96000_499200 n1_m1_100800_499200 5.356235
R14897 n1_m1_100800_499200 n1_m1_105600_499200 5.356235
R14898 n1_m1_105600_499200 n1_m1_110400_499200 5.356235
R14899 n1_m1_110400_499200 n1_m1_115200_499200 5.356235
R14900 n1_m1_115200_499200 n1_m1_116000_499200 0.892706
R14901 n1_m1_120000_499200 n1_m1_116000_499200 4.463529
R14902 n1_m1_120000_499200 n1_m1_124800_499200 5.356235
R14903 n1_m1_124800_499200 n1_m1_129600_499200 5.356235
R14904 n1_m1_129600_499200 n1_m1_134400_499200 5.356235
R14905 n1_m1_134400_499200 n1_m1_139200_499200 5.356235
R14906 n1_m1_139200_499200 n1_m1_144000_499200 5.356235
R14907 n1_m1_144000_499200 n1_m1_148800_499200 5.356235
R14908 n1_m1_148800_499200 n1_m1_153600_499200 5.356235
R14909 n1_m1_153600_499200 n1_m1_158400_499200 5.356235
R14910 n1_m1_158400_499200 n1_m1_163200_499200 5.356235
R14911 n1_m1_163200_499200 n1_m1_168000_499200 5.356235
R14912 n1_m1_168000_499200 n1_m1_172000_499200 4.463529
R14913 n1_m1_172800_499200 n1_m1_172000_499200 0.892706
R14914 n1_m1_172800_499200 n1_m1_177600_499200 5.356235
R14915 n1_m1_177600_499200 n1_m1_182400_499200 5.356235
R14916 n1_m1_182400_499200 n1_m1_187200_499200 5.356235
R14917 n1_m1_187200_499200 n1_m1_192000_499200 5.356235
R14918 n1_m1_192000_499200 n1_m1_196800_499200 5.356235
R14919 n1_m1_196800_499200 n1_m1_200000_499200 3.570824
R14920 n1_m1_201600_499200 n1_m1_200000_499200 1.785412
R14921 n1_m1_201600_499200 n1_m1_206400_499200 5.356235
R14922 n1_m1_206400_499200 n1_m1_211200_499200 5.356235
R14923 n1_m1_211200_499200 n1_m1_216000_499200 5.356235
R14924 n1_m1_216000_499200 n1_m1_220800_499200 5.356235
R14925 n1_m1_220800_499200 n1_m1_225600_499200 5.356235
R14926 n1_m1_225600_499200 n1_m1_228000_499200 2.678118
R14927 n1_m1_230400_499200 n1_m1_228000_499200 2.678118
R14928 n1_m1_230400_499200 n1_m1_235200_499200 5.356235
R14929 n1_m1_235200_499200 n1_m1_240000_499200 5.356235
R14930 n1_m1_240000_499200 n1_m1_244800_499200 5.356235
R14931 n1_m1_244800_499200 n1_m1_249600_499200 5.356235
R14932 n1_m1_249600_499200 n1_m1_254400_499200 5.356235
R14933 n1_m1_254400_499200 n1_m1_256000_499200 1.785412
R14934 n1_m1_259200_499200 n1_m1_256000_499200 3.570824
R14935 n1_m1_259200_499200 n1_m1_264000_499200 5.356235
R14936 n1_m1_264000_499200 n1_m1_268800_499200 5.356235
R14937 n1_m1_268800_499200 n1_m1_273600_499200 5.356235
R14938 n1_m1_273600_499200 n1_m1_278400_499200 5.356235
R14939 n1_m1_278400_499200 n1_m1_283200_499200 5.356235
R14940 n1_m1_283200_499200 n1_m1_284000_499200 0.892706
R14941 n1_m1_288000_499200 n1_m1_284000_499200 4.463529
R14942 n1_m1_288000_499200 n1_m1_292800_499200 5.356235
R14943 n1_m1_292800_499200 n1_m1_297600_499200 5.356235
R14944 n1_m1_297600_499200 n1_m1_302400_499200 5.356235
R14945 n1_m1_302400_499200 n1_m1_307200_499200 5.356235
R14946 n1_m1_307200_499200 n1_m1_312000_499200 5.356235
R14947 n1_m1_312000_499200 n1_m1_316800_499200 5.356235
R14948 n1_m1_316800_499200 n1_m1_321600_499200 5.356235
R14949 n1_m1_321600_499200 n1_m1_326400_499200 5.356235
R14950 n1_m1_326400_499200 n1_m1_331200_499200 5.356235
R14951 n1_m1_331200_499200 n1_m1_336000_499200 5.356235
R14952 n1_m1_336000_499200 n1_m1_340000_499200 4.463529
R14953 n1_m1_340800_499200 n1_m1_340000_499200 0.892706
R14954 n1_m1_340800_499200 n1_m1_345600_499200 5.356235
R14955 n1_m1_345600_499200 n1_m1_350400_499200 5.356235
R14956 n1_m1_350400_499200 n1_m1_355200_499200 5.356235
R14957 n1_m1_355200_499200 n1_m1_360000_499200 5.356235
R14958 n1_m1_360000_499200 n1_m1_364800_499200 5.356235
R14959 n1_m1_364800_499200 n1_m1_368000_499200 3.570824
R14960 n1_m1_369600_499200 n1_m1_368000_499200 1.785412
R14961 n1_m1_369600_499200 n1_m1_374400_499200 5.356235
R14962 n1_m1_374400_499200 n1_m1_379200_499200 5.356235
R14963 n1_m1_379200_499200 n1_m1_384000_499200 5.356235
R14964 n1_m1_384000_499200 n1_m1_388800_499200 5.356235
R14965 n1_m1_388800_499200 n1_m1_393600_499200 5.356235
R14966 n1_m1_393600_499200 n1_m1_396000_499200 2.678118
R14967 n1_m1_398400_499200 n1_m1_396000_499200 2.678118
R14968 n1_m1_398400_499200 n1_m1_403200_499200 5.356235
R14969 n1_m1_403200_499200 n1_m1_408000_499200 5.356235
R14970 n1_m1_408000_499200 n1_m1_412800_499200 5.356235
R14971 n1_m1_412800_499200 n1_m1_417600_499200 5.356235
R14972 n1_m1_417600_499200 n1_m1_422400_499200 5.356235
R14973 n1_m1_422400_499200 n1_m1_424000_499200 1.785412
R14974 n1_m1_427200_499200 n1_m1_424000_499200 3.570824
R14975 n1_m1_427200_499200 n1_m1_432000_499200 5.356235
R14976 n1_m1_432000_499200 n1_m1_436800_499200 5.356235
R14977 n1_m1_436800_499200 n1_m1_441600_499200 5.356235
R14978 n1_m1_441600_499200 n1_m1_446400_499200 5.356235
R14979 n1_m1_446400_499200 n1_m1_451200_499200 5.356235
R14980 n1_m1_451200_499200 n1_m1_452000_499200 0.892706
R14981 n1_m1_456000_499200 n1_m1_452000_499200 4.463529
R14982 n1_m1_456000_499200 n1_m1_460800_499200 5.356235
R14983 n1_m1_460800_499200 n1_m1_465600_499200 5.356235
R14984 n1_m1_465600_499200 n1_m1_470400_499200 5.356235
R14985 n1_m1_470400_499200 n1_m1_475200_499200 5.356235
R14986 n1_m1_475200_499200 n1_m1_480000_499200 5.356235
R14987 n1_m1_480000_499200 n1_m1_484800_499200 5.356235
R14988 n1_m1_484800_499200 n1_m1_489600_499200 5.356235
R14989 n1_m1_489600_499200 n1_m1_494400_499200 5.356235
R14990 n1_m1_494400_499200 n1_m1_499200_499200 5.356235
R14991 n1_m1_499200_499200 n1_m1_504000_499200 5.356235
R14992 n1_m1_504000_499200 n1_m1_508000_499200 4.463529
R14993 n1_m1_508800_499200 n1_m1_508000_499200 0.892706
R14994 n1_m1_508800_499200 n1_m1_513600_499200 5.356235
R14995 n1_m1_513600_499200 n1_m1_518400_499200 5.356235
R14996 n1_m1_518400_499200 n1_m1_523200_499200 5.356235
R14997 n1_m1_523200_499200 n1_m1_528000_499200 5.356235
R14998 n1_m1_528000_499200 n1_m1_532800_499200 5.356235
R14999 n1_m1_532800_499200 n1_m1_536000_499200 3.570824
R15000 n1_m1_537600_499200 n1_m1_536000_499200 1.785412
R15001 n1_m1_537600_499200 n1_m1_542400_499200 5.356235
R15002 n1_m1_542400_499200 n1_m1_547200_499200 5.356235
R15003 n1_m1_547200_499200 n1_m1_552000_499200 5.356235
R15004 n1_m1_552000_499200 n1_m1_556800_499200 5.356235
R15005 n1_m1_556800_499200 n1_m1_561600_499200 5.356235
R15006 n1_m1_561600_499200 n1_m1_564000_499200 2.678118
R15007 n1_m1_566400_499200 n1_m1_564000_499200 2.678118
R15008 n1_m1_566400_499200 n1_m1_571200_499200 5.356235
R15009 n1_m1_571200_499200 n1_m1_576000_499200 5.356235
R15010 n1_m1_576000_499200 n1_m1_580800_499200 5.356235
R15011 n1_m1_580800_499200 n1_m1_585600_499200 5.356235
R15012 n1_m1_585600_499200 n1_m1_590400_499200 5.356235
R15013 n1_m1_590400_499200 n1_m1_592000_499200 1.785412
R15014 n1_m1_595200_499200 n1_m1_592000_499200 3.570824
R15015 n1_m1_0_504000 n1_m1_4000_504000 4.463529
R15016 n1_m1_4800_504000 n1_m1_4000_504000 0.892706
R15017 n1_m1_4800_504000 n1_m1_9600_504000 5.356235
R15018 n1_m1_9600_504000 n1_m1_14400_504000 5.356235
R15019 n1_m1_14400_504000 n1_m1_19200_504000 5.356235
R15020 n1_m1_19200_504000 n1_m1_24000_504000 5.356235
R15021 n1_m1_24000_504000 n1_m1_28800_504000 5.356235
R15022 n1_m1_28800_504000 n1_m1_32000_504000 3.570824
R15023 n1_m1_33600_504000 n1_m1_32000_504000 1.785412
R15024 n1_m1_33600_504000 n1_m1_38400_504000 5.356235
R15025 n1_m1_38400_504000 n1_m1_43200_504000 5.356235
R15026 n1_m1_43200_504000 n1_m1_48000_504000 5.356235
R15027 n1_m1_48000_504000 n1_m1_52800_504000 5.356235
R15028 n1_m1_52800_504000 n1_m1_57600_504000 5.356235
R15029 n1_m1_57600_504000 n1_m1_60000_504000 2.678118
R15030 n1_m1_62400_504000 n1_m1_60000_504000 2.678118
R15031 n1_m1_62400_504000 n1_m1_67200_504000 5.356235
R15032 n1_m1_67200_504000 n1_m1_72000_504000 5.356235
R15033 n1_m1_72000_504000 n1_m1_76800_504000 5.356235
R15034 n1_m1_76800_504000 n1_m1_81600_504000 5.356235
R15035 n1_m1_81600_504000 n1_m1_86400_504000 5.356235
R15036 n1_m1_86400_504000 n1_m1_88000_504000 1.785412
R15037 n1_m1_91200_504000 n1_m1_88000_504000 3.570824
R15038 n1_m1_91200_504000 n1_m1_96000_504000 5.356235
R15039 n1_m1_96000_504000 n1_m1_100800_504000 5.356235
R15040 n1_m1_100800_504000 n1_m1_105600_504000 5.356235
R15041 n1_m1_105600_504000 n1_m1_110400_504000 5.356235
R15042 n1_m1_110400_504000 n1_m1_115200_504000 5.356235
R15043 n1_m1_115200_504000 n1_m1_116000_504000 0.892706
R15044 n1_m1_120000_504000 n1_m1_116000_504000 4.463529
R15045 n1_m1_120000_504000 n1_m1_124800_504000 5.356235
R15046 n1_m1_124800_504000 n1_m1_129600_504000 5.356235
R15047 n1_m1_129600_504000 n1_m1_134400_504000 5.356235
R15048 n1_m1_134400_504000 n1_m1_139200_504000 5.356235
R15049 n1_m1_139200_504000 n1_m1_144000_504000 5.356235
R15050 n1_m1_144000_504000 n1_m1_148800_504000 5.356235
R15051 n1_m1_148800_504000 n1_m1_153600_504000 5.356235
R15052 n1_m1_153600_504000 n1_m1_158400_504000 5.356235
R15053 n1_m1_158400_504000 n1_m1_163200_504000 5.356235
R15054 n1_m1_163200_504000 n1_m1_168000_504000 5.356235
R15055 n1_m1_168000_504000 n1_m1_172000_504000 4.463529
R15056 n1_m1_172800_504000 n1_m1_172000_504000 0.892706
R15057 n1_m1_172800_504000 n1_m1_177600_504000 5.356235
R15058 n1_m1_177600_504000 n1_m1_182400_504000 5.356235
R15059 n1_m1_182400_504000 n1_m1_187200_504000 5.356235
R15060 n1_m1_187200_504000 n1_m1_192000_504000 5.356235
R15061 n1_m1_192000_504000 n1_m1_196800_504000 5.356235
R15062 n1_m1_196800_504000 n1_m1_200000_504000 3.570824
R15063 n1_m1_201600_504000 n1_m1_200000_504000 1.785412
R15064 n1_m1_201600_504000 n1_m1_206400_504000 5.356235
R15065 n1_m1_206400_504000 n1_m1_211200_504000 5.356235
R15066 n1_m1_211200_504000 n1_m1_216000_504000 5.356235
R15067 n1_m1_216000_504000 n1_m1_220800_504000 5.356235
R15068 n1_m1_220800_504000 n1_m1_225600_504000 5.356235
R15069 n1_m1_225600_504000 n1_m1_228000_504000 2.678118
R15070 n1_m1_230400_504000 n1_m1_228000_504000 2.678118
R15071 n1_m1_230400_504000 n1_m1_235200_504000 5.356235
R15072 n1_m1_235200_504000 n1_m1_240000_504000 5.356235
R15073 n1_m1_240000_504000 n1_m1_244800_504000 5.356235
R15074 n1_m1_244800_504000 n1_m1_249600_504000 5.356235
R15075 n1_m1_249600_504000 n1_m1_254400_504000 5.356235
R15076 n1_m1_254400_504000 n1_m1_256000_504000 1.785412
R15077 n1_m1_259200_504000 n1_m1_256000_504000 3.570824
R15078 n1_m1_259200_504000 n1_m1_264000_504000 5.356235
R15079 n1_m1_264000_504000 n1_m1_268800_504000 5.356235
R15080 n1_m1_268800_504000 n1_m1_273600_504000 5.356235
R15081 n1_m1_273600_504000 n1_m1_278400_504000 5.356235
R15082 n1_m1_278400_504000 n1_m1_283200_504000 5.356235
R15083 n1_m1_283200_504000 n1_m1_284000_504000 0.892706
R15084 n1_m1_288000_504000 n1_m1_284000_504000 4.463529
R15085 n1_m1_288000_504000 n1_m1_292800_504000 5.356235
R15086 n1_m1_292800_504000 n1_m1_297600_504000 5.356235
R15087 n1_m1_297600_504000 n1_m1_302400_504000 5.356235
R15088 n1_m1_302400_504000 n1_m1_307200_504000 5.356235
R15089 n1_m1_307200_504000 n1_m1_312000_504000 5.356235
R15090 n1_m1_312000_504000 n1_m1_316800_504000 5.356235
R15091 n1_m1_316800_504000 n1_m1_321600_504000 5.356235
R15092 n1_m1_321600_504000 n1_m1_326400_504000 5.356235
R15093 n1_m1_326400_504000 n1_m1_331200_504000 5.356235
R15094 n1_m1_331200_504000 n1_m1_336000_504000 5.356235
R15095 n1_m1_336000_504000 n1_m1_340000_504000 4.463529
R15096 n1_m1_340800_504000 n1_m1_340000_504000 0.892706
R15097 n1_m1_340800_504000 n1_m1_345600_504000 5.356235
R15098 n1_m1_345600_504000 n1_m1_350400_504000 5.356235
R15099 n1_m1_350400_504000 n1_m1_355200_504000 5.356235
R15100 n1_m1_355200_504000 n1_m1_360000_504000 5.356235
R15101 n1_m1_360000_504000 n1_m1_364800_504000 5.356235
R15102 n1_m1_364800_504000 n1_m1_368000_504000 3.570824
R15103 n1_m1_369600_504000 n1_m1_368000_504000 1.785412
R15104 n1_m1_369600_504000 n1_m1_374400_504000 5.356235
R15105 n1_m1_374400_504000 n1_m1_379200_504000 5.356235
R15106 n1_m1_379200_504000 n1_m1_384000_504000 5.356235
R15107 n1_m1_384000_504000 n1_m1_388800_504000 5.356235
R15108 n1_m1_388800_504000 n1_m1_393600_504000 5.356235
R15109 n1_m1_393600_504000 n1_m1_396000_504000 2.678118
R15110 n1_m1_398400_504000 n1_m1_396000_504000 2.678118
R15111 n1_m1_398400_504000 n1_m1_403200_504000 5.356235
R15112 n1_m1_403200_504000 n1_m1_408000_504000 5.356235
R15113 n1_m1_408000_504000 n1_m1_412800_504000 5.356235
R15114 n1_m1_412800_504000 n1_m1_417600_504000 5.356235
R15115 n1_m1_417600_504000 n1_m1_422400_504000 5.356235
R15116 n1_m1_422400_504000 n1_m1_424000_504000 1.785412
R15117 n1_m1_427200_504000 n1_m1_424000_504000 3.570824
R15118 n1_m1_427200_504000 n1_m1_432000_504000 5.356235
R15119 n1_m1_432000_504000 n1_m1_436800_504000 5.356235
R15120 n1_m1_436800_504000 n1_m1_441600_504000 5.356235
R15121 n1_m1_441600_504000 n1_m1_446400_504000 5.356235
R15122 n1_m1_446400_504000 n1_m1_451200_504000 5.356235
R15123 n1_m1_451200_504000 n1_m1_452000_504000 0.892706
R15124 n1_m1_456000_504000 n1_m1_452000_504000 4.463529
R15125 n1_m1_456000_504000 n1_m1_460800_504000 5.356235
R15126 n1_m1_460800_504000 n1_m1_465600_504000 5.356235
R15127 n1_m1_465600_504000 n1_m1_470400_504000 5.356235
R15128 n1_m1_470400_504000 n1_m1_475200_504000 5.356235
R15129 n1_m1_475200_504000 n1_m1_480000_504000 5.356235
R15130 n1_m1_480000_504000 n1_m1_484800_504000 5.356235
R15131 n1_m1_484800_504000 n1_m1_489600_504000 5.356235
R15132 n1_m1_489600_504000 n1_m1_494400_504000 5.356235
R15133 n1_m1_494400_504000 n1_m1_499200_504000 5.356235
R15134 n1_m1_499200_504000 n1_m1_504000_504000 5.356235
R15135 n1_m1_504000_504000 n1_m1_508000_504000 4.463529
R15136 n1_m1_508800_504000 n1_m1_508000_504000 0.892706
R15137 n1_m1_508800_504000 n1_m1_513600_504000 5.356235
R15138 n1_m1_513600_504000 n1_m1_518400_504000 5.356235
R15139 n1_m1_518400_504000 n1_m1_523200_504000 5.356235
R15140 n1_m1_523200_504000 n1_m1_528000_504000 5.356235
R15141 n1_m1_528000_504000 n1_m1_532800_504000 5.356235
R15142 n1_m1_532800_504000 n1_m1_536000_504000 3.570824
R15143 n1_m1_537600_504000 n1_m1_536000_504000 1.785412
R15144 n1_m1_537600_504000 n1_m1_542400_504000 5.356235
R15145 n1_m1_542400_504000 n1_m1_547200_504000 5.356235
R15146 n1_m1_547200_504000 n1_m1_552000_504000 5.356235
R15147 n1_m1_552000_504000 n1_m1_556800_504000 5.356235
R15148 n1_m1_556800_504000 n1_m1_561600_504000 5.356235
R15149 n1_m1_561600_504000 n1_m1_564000_504000 2.678118
R15150 n1_m1_566400_504000 n1_m1_564000_504000 2.678118
R15151 n1_m1_566400_504000 n1_m1_571200_504000 5.356235
R15152 n1_m1_571200_504000 n1_m1_576000_504000 5.356235
R15153 n1_m1_576000_504000 n1_m1_580800_504000 5.356235
R15154 n1_m1_580800_504000 n1_m1_585600_504000 5.356235
R15155 n1_m1_585600_504000 n1_m1_590400_504000 5.356235
R15156 n1_m1_590400_504000 n1_m1_592000_504000 1.785412
R15157 n1_m1_595200_504000 n1_m1_592000_504000 3.570824
R15158 n1_m1_0_508800 n1_m1_4000_508800 4.463529
R15159 n1_m1_4800_508800 n1_m1_4000_508800 0.892706
R15160 n1_m1_4800_508800 n1_m1_9600_508800 5.356235
R15161 n1_m1_9600_508800 n1_m1_14400_508800 5.356235
R15162 n1_m1_14400_508800 n1_m1_19200_508800 5.356235
R15163 n1_m1_19200_508800 n1_m1_24000_508800 5.356235
R15164 n1_m1_24000_508800 n1_m1_28800_508800 5.356235
R15165 n1_m1_28800_508800 n1_m1_32000_508800 3.570824
R15166 n1_m1_33600_508800 n1_m1_32000_508800 1.785412
R15167 n1_m1_33600_508800 n1_m1_38400_508800 5.356235
R15168 n1_m1_38400_508800 n1_m1_43200_508800 5.356235
R15169 n1_m1_43200_508800 n1_m1_48000_508800 5.356235
R15170 n1_m1_48000_508800 n1_m1_52800_508800 5.356235
R15171 n1_m1_52800_508800 n1_m1_57600_508800 5.356235
R15172 n1_m1_57600_508800 n1_m1_60000_508800 2.678118
R15173 n1_m1_62400_508800 n1_m1_60000_508800 2.678118
R15174 n1_m1_62400_508800 n1_m1_67200_508800 5.356235
R15175 n1_m1_67200_508800 n1_m1_72000_508800 5.356235
R15176 n1_m1_72000_508800 n1_m1_76800_508800 5.356235
R15177 n1_m1_76800_508800 n1_m1_81600_508800 5.356235
R15178 n1_m1_81600_508800 n1_m1_86400_508800 5.356235
R15179 n1_m1_86400_508800 n1_m1_88000_508800 1.785412
R15180 n1_m1_91200_508800 n1_m1_88000_508800 3.570824
R15181 n1_m1_91200_508800 n1_m1_96000_508800 5.356235
R15182 n1_m1_96000_508800 n1_m1_100800_508800 5.356235
R15183 n1_m1_100800_508800 n1_m1_105600_508800 5.356235
R15184 n1_m1_105600_508800 n1_m1_110400_508800 5.356235
R15185 n1_m1_110400_508800 n1_m1_115200_508800 5.356235
R15186 n1_m1_115200_508800 n1_m1_116000_508800 0.892706
R15187 n1_m1_120000_508800 n1_m1_116000_508800 4.463529
R15188 n1_m1_120000_508800 n1_m1_124800_508800 5.356235
R15189 n1_m1_124800_508800 n1_m1_129600_508800 5.356235
R15190 n1_m1_129600_508800 n1_m1_134400_508800 5.356235
R15191 n1_m1_134400_508800 n1_m1_139200_508800 5.356235
R15192 n1_m1_139200_508800 n1_m1_144000_508800 5.356235
R15193 n1_m1_144000_508800 n1_m1_148800_508800 5.356235
R15194 n1_m1_148800_508800 n1_m1_153600_508800 5.356235
R15195 n1_m1_153600_508800 n1_m1_158400_508800 5.356235
R15196 n1_m1_158400_508800 n1_m1_163200_508800 5.356235
R15197 n1_m1_163200_508800 n1_m1_168000_508800 5.356235
R15198 n1_m1_168000_508800 n1_m1_172000_508800 4.463529
R15199 n1_m1_172800_508800 n1_m1_172000_508800 0.892706
R15200 n1_m1_172800_508800 n1_m1_177600_508800 5.356235
R15201 n1_m1_177600_508800 n1_m1_182400_508800 5.356235
R15202 n1_m1_182400_508800 n1_m1_187200_508800 5.356235
R15203 n1_m1_187200_508800 n1_m1_192000_508800 5.356235
R15204 n1_m1_192000_508800 n1_m1_196800_508800 5.356235
R15205 n1_m1_196800_508800 n1_m1_200000_508800 3.570824
R15206 n1_m1_201600_508800 n1_m1_200000_508800 1.785412
R15207 n1_m1_201600_508800 n1_m1_206400_508800 5.356235
R15208 n1_m1_206400_508800 n1_m1_211200_508800 5.356235
R15209 n1_m1_211200_508800 n1_m1_216000_508800 5.356235
R15210 n1_m1_216000_508800 n1_m1_220800_508800 5.356235
R15211 n1_m1_220800_508800 n1_m1_225600_508800 5.356235
R15212 n1_m1_225600_508800 n1_m1_228000_508800 2.678118
R15213 n1_m1_230400_508800 n1_m1_228000_508800 2.678118
R15214 n1_m1_230400_508800 n1_m1_235200_508800 5.356235
R15215 n1_m1_235200_508800 n1_m1_240000_508800 5.356235
R15216 n1_m1_240000_508800 n1_m1_244800_508800 5.356235
R15217 n1_m1_244800_508800 n1_m1_249600_508800 5.356235
R15218 n1_m1_249600_508800 n1_m1_254400_508800 5.356235
R15219 n1_m1_254400_508800 n1_m1_256000_508800 1.785412
R15220 n1_m1_259200_508800 n1_m1_256000_508800 3.570824
R15221 n1_m1_259200_508800 n1_m1_264000_508800 5.356235
R15222 n1_m1_264000_508800 n1_m1_268800_508800 5.356235
R15223 n1_m1_268800_508800 n1_m1_273600_508800 5.356235
R15224 n1_m1_273600_508800 n1_m1_278400_508800 5.356235
R15225 n1_m1_278400_508800 n1_m1_283200_508800 5.356235
R15226 n1_m1_283200_508800 n1_m1_284000_508800 0.892706
R15227 n1_m1_288000_508800 n1_m1_284000_508800 4.463529
R15228 n1_m1_288000_508800 n1_m1_292800_508800 5.356235
R15229 n1_m1_292800_508800 n1_m1_297600_508800 5.356235
R15230 n1_m1_297600_508800 n1_m1_302400_508800 5.356235
R15231 n1_m1_302400_508800 n1_m1_307200_508800 5.356235
R15232 n1_m1_307200_508800 n1_m1_312000_508800 5.356235
R15233 n1_m1_312000_508800 n1_m1_316800_508800 5.356235
R15234 n1_m1_316800_508800 n1_m1_321600_508800 5.356235
R15235 n1_m1_321600_508800 n1_m1_326400_508800 5.356235
R15236 n1_m1_326400_508800 n1_m1_331200_508800 5.356235
R15237 n1_m1_331200_508800 n1_m1_336000_508800 5.356235
R15238 n1_m1_336000_508800 n1_m1_340000_508800 4.463529
R15239 n1_m1_340800_508800 n1_m1_340000_508800 0.892706
R15240 n1_m1_340800_508800 n1_m1_345600_508800 5.356235
R15241 n1_m1_345600_508800 n1_m1_350400_508800 5.356235
R15242 n1_m1_350400_508800 n1_m1_355200_508800 5.356235
R15243 n1_m1_355200_508800 n1_m1_360000_508800 5.356235
R15244 n1_m1_360000_508800 n1_m1_364800_508800 5.356235
R15245 n1_m1_364800_508800 n1_m1_368000_508800 3.570824
R15246 n1_m1_369600_508800 n1_m1_368000_508800 1.785412
R15247 n1_m1_369600_508800 n1_m1_374400_508800 5.356235
R15248 n1_m1_374400_508800 n1_m1_379200_508800 5.356235
R15249 n1_m1_379200_508800 n1_m1_384000_508800 5.356235
R15250 n1_m1_384000_508800 n1_m1_388800_508800 5.356235
R15251 n1_m1_388800_508800 n1_m1_393600_508800 5.356235
R15252 n1_m1_393600_508800 n1_m1_396000_508800 2.678118
R15253 n1_m1_398400_508800 n1_m1_396000_508800 2.678118
R15254 n1_m1_398400_508800 n1_m1_403200_508800 5.356235
R15255 n1_m1_403200_508800 n1_m1_408000_508800 5.356235
R15256 n1_m1_408000_508800 n1_m1_412800_508800 5.356235
R15257 n1_m1_412800_508800 n1_m1_417600_508800 5.356235
R15258 n1_m1_417600_508800 n1_m1_422400_508800 5.356235
R15259 n1_m1_422400_508800 n1_m1_424000_508800 1.785412
R15260 n1_m1_427200_508800 n1_m1_424000_508800 3.570824
R15261 n1_m1_427200_508800 n1_m1_432000_508800 5.356235
R15262 n1_m1_432000_508800 n1_m1_436800_508800 5.356235
R15263 n1_m1_436800_508800 n1_m1_441600_508800 5.356235
R15264 n1_m1_441600_508800 n1_m1_446400_508800 5.356235
R15265 n1_m1_446400_508800 n1_m1_451200_508800 5.356235
R15266 n1_m1_451200_508800 n1_m1_452000_508800 0.892706
R15267 n1_m1_456000_508800 n1_m1_452000_508800 4.463529
R15268 n1_m1_456000_508800 n1_m1_460800_508800 5.356235
R15269 n1_m1_460800_508800 n1_m1_465600_508800 5.356235
R15270 n1_m1_465600_508800 n1_m1_470400_508800 5.356235
R15271 n1_m1_470400_508800 n1_m1_475200_508800 5.356235
R15272 n1_m1_475200_508800 n1_m1_480000_508800 5.356235
R15273 n1_m1_480000_508800 n1_m1_484800_508800 5.356235
R15274 n1_m1_484800_508800 n1_m1_489600_508800 5.356235
R15275 n1_m1_489600_508800 n1_m1_494400_508800 5.356235
R15276 n1_m1_494400_508800 n1_m1_499200_508800 5.356235
R15277 n1_m1_499200_508800 n1_m1_504000_508800 5.356235
R15278 n1_m1_504000_508800 n1_m1_508000_508800 4.463529
R15279 n1_m1_508800_508800 n1_m1_508000_508800 0.892706
R15280 n1_m1_508800_508800 n1_m1_513600_508800 5.356235
R15281 n1_m1_513600_508800 n1_m1_518400_508800 5.356235
R15282 n1_m1_518400_508800 n1_m1_523200_508800 5.356235
R15283 n1_m1_523200_508800 n1_m1_528000_508800 5.356235
R15284 n1_m1_528000_508800 n1_m1_532800_508800 5.356235
R15285 n1_m1_532800_508800 n1_m1_536000_508800 3.570824
R15286 n1_m1_537600_508800 n1_m1_536000_508800 1.785412
R15287 n1_m1_537600_508800 n1_m1_542400_508800 5.356235
R15288 n1_m1_542400_508800 n1_m1_547200_508800 5.356235
R15289 n1_m1_547200_508800 n1_m1_552000_508800 5.356235
R15290 n1_m1_552000_508800 n1_m1_556800_508800 5.356235
R15291 n1_m1_556800_508800 n1_m1_561600_508800 5.356235
R15292 n1_m1_561600_508800 n1_m1_564000_508800 2.678118
R15293 n1_m1_566400_508800 n1_m1_564000_508800 2.678118
R15294 n1_m1_566400_508800 n1_m1_571200_508800 5.356235
R15295 n1_m1_571200_508800 n1_m1_576000_508800 5.356235
R15296 n1_m1_576000_508800 n1_m1_580800_508800 5.356235
R15297 n1_m1_580800_508800 n1_m1_585600_508800 5.356235
R15298 n1_m1_585600_508800 n1_m1_590400_508800 5.356235
R15299 n1_m1_590400_508800 n1_m1_592000_508800 1.785412
R15300 n1_m1_595200_508800 n1_m1_592000_508800 3.570824
R15301 n1_m1_0_513600 n1_m1_4000_513600 4.463529
R15302 n1_m1_4800_513600 n1_m1_4000_513600 0.892706
R15303 n1_m1_4800_513600 n1_m1_9600_513600 5.356235
R15304 n1_m1_9600_513600 n1_m1_14400_513600 5.356235
R15305 n1_m1_14400_513600 n1_m1_19200_513600 5.356235
R15306 n1_m1_19200_513600 n1_m1_24000_513600 5.356235
R15307 n1_m1_24000_513600 n1_m1_28800_513600 5.356235
R15308 n1_m1_28800_513600 n1_m1_32000_513600 3.570824
R15309 n1_m1_33600_513600 n1_m1_32000_513600 1.785412
R15310 n1_m1_33600_513600 n1_m1_38400_513600 5.356235
R15311 n1_m1_38400_513600 n1_m1_43200_513600 5.356235
R15312 n1_m1_43200_513600 n1_m1_48000_513600 5.356235
R15313 n1_m1_48000_513600 n1_m1_52800_513600 5.356235
R15314 n1_m1_52800_513600 n1_m1_57600_513600 5.356235
R15315 n1_m1_57600_513600 n1_m1_60000_513600 2.678118
R15316 n1_m1_62400_513600 n1_m1_60000_513600 2.678118
R15317 n1_m1_62400_513600 n1_m1_67200_513600 5.356235
R15318 n1_m1_67200_513600 n1_m1_72000_513600 5.356235
R15319 n1_m1_72000_513600 n1_m1_76800_513600 5.356235
R15320 n1_m1_76800_513600 n1_m1_81600_513600 5.356235
R15321 n1_m1_81600_513600 n1_m1_86400_513600 5.356235
R15322 n1_m1_86400_513600 n1_m1_88000_513600 1.785412
R15323 n1_m1_91200_513600 n1_m1_88000_513600 3.570824
R15324 n1_m1_91200_513600 n1_m1_96000_513600 5.356235
R15325 n1_m1_96000_513600 n1_m1_100800_513600 5.356235
R15326 n1_m1_100800_513600 n1_m1_105600_513600 5.356235
R15327 n1_m1_105600_513600 n1_m1_110400_513600 5.356235
R15328 n1_m1_110400_513600 n1_m1_115200_513600 5.356235
R15329 n1_m1_115200_513600 n1_m1_116000_513600 0.892706
R15330 n1_m1_120000_513600 n1_m1_116000_513600 4.463529
R15331 n1_m1_120000_513600 n1_m1_124800_513600 5.356235
R15332 n1_m1_124800_513600 n1_m1_129600_513600 5.356235
R15333 n1_m1_129600_513600 n1_m1_134400_513600 5.356235
R15334 n1_m1_134400_513600 n1_m1_139200_513600 5.356235
R15335 n1_m1_139200_513600 n1_m1_144000_513600 5.356235
R15336 n1_m1_144000_513600 n1_m1_148800_513600 5.356235
R15337 n1_m1_148800_513600 n1_m1_153600_513600 5.356235
R15338 n1_m1_153600_513600 n1_m1_158400_513600 5.356235
R15339 n1_m1_158400_513600 n1_m1_163200_513600 5.356235
R15340 n1_m1_163200_513600 n1_m1_168000_513600 5.356235
R15341 n1_m1_168000_513600 n1_m1_172000_513600 4.463529
R15342 n1_m1_172800_513600 n1_m1_172000_513600 0.892706
R15343 n1_m1_172800_513600 n1_m1_177600_513600 5.356235
R15344 n1_m1_177600_513600 n1_m1_182400_513600 5.356235
R15345 n1_m1_182400_513600 n1_m1_187200_513600 5.356235
R15346 n1_m1_187200_513600 n1_m1_192000_513600 5.356235
R15347 n1_m1_192000_513600 n1_m1_196800_513600 5.356235
R15348 n1_m1_196800_513600 n1_m1_200000_513600 3.570824
R15349 n1_m1_201600_513600 n1_m1_200000_513600 1.785412
R15350 n1_m1_201600_513600 n1_m1_206400_513600 5.356235
R15351 n1_m1_206400_513600 n1_m1_211200_513600 5.356235
R15352 n1_m1_211200_513600 n1_m1_216000_513600 5.356235
R15353 n1_m1_216000_513600 n1_m1_220800_513600 5.356235
R15354 n1_m1_220800_513600 n1_m1_225600_513600 5.356235
R15355 n1_m1_225600_513600 n1_m1_228000_513600 2.678118
R15356 n1_m1_230400_513600 n1_m1_228000_513600 2.678118
R15357 n1_m1_230400_513600 n1_m1_235200_513600 5.356235
R15358 n1_m1_235200_513600 n1_m1_240000_513600 5.356235
R15359 n1_m1_240000_513600 n1_m1_244800_513600 5.356235
R15360 n1_m1_244800_513600 n1_m1_249600_513600 5.356235
R15361 n1_m1_249600_513600 n1_m1_254400_513600 5.356235
R15362 n1_m1_254400_513600 n1_m1_256000_513600 1.785412
R15363 n1_m1_259200_513600 n1_m1_256000_513600 3.570824
R15364 n1_m1_259200_513600 n1_m1_264000_513600 5.356235
R15365 n1_m1_264000_513600 n1_m1_268800_513600 5.356235
R15366 n1_m1_268800_513600 n1_m1_273600_513600 5.356235
R15367 n1_m1_273600_513600 n1_m1_278400_513600 5.356235
R15368 n1_m1_278400_513600 n1_m1_283200_513600 5.356235
R15369 n1_m1_283200_513600 n1_m1_284000_513600 0.892706
R15370 n1_m1_288000_513600 n1_m1_284000_513600 4.463529
R15371 n1_m1_288000_513600 n1_m1_292800_513600 5.356235
R15372 n1_m1_292800_513600 n1_m1_297600_513600 5.356235
R15373 n1_m1_297600_513600 n1_m1_302400_513600 5.356235
R15374 n1_m1_302400_513600 n1_m1_307200_513600 5.356235
R15375 n1_m1_307200_513600 n1_m1_312000_513600 5.356235
R15376 n1_m1_312000_513600 n1_m1_316800_513600 5.356235
R15377 n1_m1_316800_513600 n1_m1_321600_513600 5.356235
R15378 n1_m1_321600_513600 n1_m1_326400_513600 5.356235
R15379 n1_m1_326400_513600 n1_m1_331200_513600 5.356235
R15380 n1_m1_331200_513600 n1_m1_336000_513600 5.356235
R15381 n1_m1_336000_513600 n1_m1_340000_513600 4.463529
R15382 n1_m1_340800_513600 n1_m1_340000_513600 0.892706
R15383 n1_m1_340800_513600 n1_m1_345600_513600 5.356235
R15384 n1_m1_345600_513600 n1_m1_350400_513600 5.356235
R15385 n1_m1_350400_513600 n1_m1_355200_513600 5.356235
R15386 n1_m1_355200_513600 n1_m1_360000_513600 5.356235
R15387 n1_m1_360000_513600 n1_m1_364800_513600 5.356235
R15388 n1_m1_364800_513600 n1_m1_368000_513600 3.570824
R15389 n1_m1_369600_513600 n1_m1_368000_513600 1.785412
R15390 n1_m1_369600_513600 n1_m1_374400_513600 5.356235
R15391 n1_m1_374400_513600 n1_m1_379200_513600 5.356235
R15392 n1_m1_379200_513600 n1_m1_384000_513600 5.356235
R15393 n1_m1_384000_513600 n1_m1_388800_513600 5.356235
R15394 n1_m1_388800_513600 n1_m1_393600_513600 5.356235
R15395 n1_m1_393600_513600 n1_m1_396000_513600 2.678118
R15396 n1_m1_398400_513600 n1_m1_396000_513600 2.678118
R15397 n1_m1_398400_513600 n1_m1_403200_513600 5.356235
R15398 n1_m1_403200_513600 n1_m1_408000_513600 5.356235
R15399 n1_m1_408000_513600 n1_m1_412800_513600 5.356235
R15400 n1_m1_412800_513600 n1_m1_417600_513600 5.356235
R15401 n1_m1_417600_513600 n1_m1_422400_513600 5.356235
R15402 n1_m1_422400_513600 n1_m1_424000_513600 1.785412
R15403 n1_m1_427200_513600 n1_m1_424000_513600 3.570824
R15404 n1_m1_427200_513600 n1_m1_432000_513600 5.356235
R15405 n1_m1_432000_513600 n1_m1_436800_513600 5.356235
R15406 n1_m1_436800_513600 n1_m1_441600_513600 5.356235
R15407 n1_m1_441600_513600 n1_m1_446400_513600 5.356235
R15408 n1_m1_446400_513600 n1_m1_451200_513600 5.356235
R15409 n1_m1_451200_513600 n1_m1_452000_513600 0.892706
R15410 n1_m1_456000_513600 n1_m1_452000_513600 4.463529
R15411 n1_m1_456000_513600 n1_m1_460800_513600 5.356235
R15412 n1_m1_460800_513600 n1_m1_465600_513600 5.356235
R15413 n1_m1_465600_513600 n1_m1_470400_513600 5.356235
R15414 n1_m1_470400_513600 n1_m1_475200_513600 5.356235
R15415 n1_m1_475200_513600 n1_m1_480000_513600 5.356235
R15416 n1_m1_480000_513600 n1_m1_484800_513600 5.356235
R15417 n1_m1_484800_513600 n1_m1_489600_513600 5.356235
R15418 n1_m1_489600_513600 n1_m1_494400_513600 5.356235
R15419 n1_m1_494400_513600 n1_m1_499200_513600 5.356235
R15420 n1_m1_499200_513600 n1_m1_504000_513600 5.356235
R15421 n1_m1_504000_513600 n1_m1_508000_513600 4.463529
R15422 n1_m1_508800_513600 n1_m1_508000_513600 0.892706
R15423 n1_m1_508800_513600 n1_m1_513600_513600 5.356235
R15424 n1_m1_513600_513600 n1_m1_518400_513600 5.356235
R15425 n1_m1_518400_513600 n1_m1_523200_513600 5.356235
R15426 n1_m1_523200_513600 n1_m1_528000_513600 5.356235
R15427 n1_m1_528000_513600 n1_m1_532800_513600 5.356235
R15428 n1_m1_532800_513600 n1_m1_536000_513600 3.570824
R15429 n1_m1_537600_513600 n1_m1_536000_513600 1.785412
R15430 n1_m1_537600_513600 n1_m1_542400_513600 5.356235
R15431 n1_m1_542400_513600 n1_m1_547200_513600 5.356235
R15432 n1_m1_547200_513600 n1_m1_552000_513600 5.356235
R15433 n1_m1_552000_513600 n1_m1_556800_513600 5.356235
R15434 n1_m1_556800_513600 n1_m1_561600_513600 5.356235
R15435 n1_m1_561600_513600 n1_m1_564000_513600 2.678118
R15436 n1_m1_566400_513600 n1_m1_564000_513600 2.678118
R15437 n1_m1_566400_513600 n1_m1_571200_513600 5.356235
R15438 n1_m1_571200_513600 n1_m1_576000_513600 5.356235
R15439 n1_m1_576000_513600 n1_m1_580800_513600 5.356235
R15440 n1_m1_580800_513600 n1_m1_585600_513600 5.356235
R15441 n1_m1_585600_513600 n1_m1_590400_513600 5.356235
R15442 n1_m1_590400_513600 n1_m1_592000_513600 1.785412
R15443 n1_m1_595200_513600 n1_m1_592000_513600 3.570824
R15444 n1_m1_0_518400 n1_m1_4000_518400 4.463529
R15445 n1_m1_4800_518400 n1_m1_4000_518400 0.892706
R15446 n1_m1_4800_518400 n1_m1_9600_518400 5.356235
R15447 n1_m1_9600_518400 n1_m1_14400_518400 5.356235
R15448 n1_m1_14400_518400 n1_m1_19200_518400 5.356235
R15449 n1_m1_19200_518400 n1_m1_24000_518400 5.356235
R15450 n1_m1_24000_518400 n1_m1_28800_518400 5.356235
R15451 n1_m1_28800_518400 n1_m1_32000_518400 3.570824
R15452 n1_m1_33600_518400 n1_m1_32000_518400 1.785412
R15453 n1_m1_33600_518400 n1_m1_38400_518400 5.356235
R15454 n1_m1_38400_518400 n1_m1_43200_518400 5.356235
R15455 n1_m1_43200_518400 n1_m1_48000_518400 5.356235
R15456 n1_m1_48000_518400 n1_m1_52800_518400 5.356235
R15457 n1_m1_52800_518400 n1_m1_57600_518400 5.356235
R15458 n1_m1_57600_518400 n1_m1_60000_518400 2.678118
R15459 n1_m1_62400_518400 n1_m1_60000_518400 2.678118
R15460 n1_m1_62400_518400 n1_m1_67200_518400 5.356235
R15461 n1_m1_67200_518400 n1_m1_72000_518400 5.356235
R15462 n1_m1_72000_518400 n1_m1_76800_518400 5.356235
R15463 n1_m1_76800_518400 n1_m1_81600_518400 5.356235
R15464 n1_m1_81600_518400 n1_m1_86400_518400 5.356235
R15465 n1_m1_86400_518400 n1_m1_88000_518400 1.785412
R15466 n1_m1_91200_518400 n1_m1_88000_518400 3.570824
R15467 n1_m1_91200_518400 n1_m1_96000_518400 5.356235
R15468 n1_m1_96000_518400 n1_m1_100800_518400 5.356235
R15469 n1_m1_100800_518400 n1_m1_105600_518400 5.356235
R15470 n1_m1_105600_518400 n1_m1_110400_518400 5.356235
R15471 n1_m1_110400_518400 n1_m1_115200_518400 5.356235
R15472 n1_m1_115200_518400 n1_m1_116000_518400 0.892706
R15473 n1_m1_120000_518400 n1_m1_116000_518400 4.463529
R15474 n1_m1_120000_518400 n1_m1_124800_518400 5.356235
R15475 n1_m1_124800_518400 n1_m1_129600_518400 5.356235
R15476 n1_m1_129600_518400 n1_m1_134400_518400 5.356235
R15477 n1_m1_134400_518400 n1_m1_139200_518400 5.356235
R15478 n1_m1_139200_518400 n1_m1_144000_518400 5.356235
R15479 n1_m1_144000_518400 n1_m1_148800_518400 5.356235
R15480 n1_m1_148800_518400 n1_m1_153600_518400 5.356235
R15481 n1_m1_153600_518400 n1_m1_158400_518400 5.356235
R15482 n1_m1_158400_518400 n1_m1_163200_518400 5.356235
R15483 n1_m1_163200_518400 n1_m1_168000_518400 5.356235
R15484 n1_m1_168000_518400 n1_m1_172000_518400 4.463529
R15485 n1_m1_172800_518400 n1_m1_172000_518400 0.892706
R15486 n1_m1_172800_518400 n1_m1_177600_518400 5.356235
R15487 n1_m1_177600_518400 n1_m1_182400_518400 5.356235
R15488 n1_m1_182400_518400 n1_m1_187200_518400 5.356235
R15489 n1_m1_187200_518400 n1_m1_192000_518400 5.356235
R15490 n1_m1_192000_518400 n1_m1_196800_518400 5.356235
R15491 n1_m1_196800_518400 n1_m1_200000_518400 3.570824
R15492 n1_m1_201600_518400 n1_m1_200000_518400 1.785412
R15493 n1_m1_201600_518400 n1_m1_206400_518400 5.356235
R15494 n1_m1_206400_518400 n1_m1_211200_518400 5.356235
R15495 n1_m1_211200_518400 n1_m1_216000_518400 5.356235
R15496 n1_m1_216000_518400 n1_m1_220800_518400 5.356235
R15497 n1_m1_220800_518400 n1_m1_225600_518400 5.356235
R15498 n1_m1_225600_518400 n1_m1_228000_518400 2.678118
R15499 n1_m1_230400_518400 n1_m1_228000_518400 2.678118
R15500 n1_m1_230400_518400 n1_m1_235200_518400 5.356235
R15501 n1_m1_235200_518400 n1_m1_240000_518400 5.356235
R15502 n1_m1_240000_518400 n1_m1_244800_518400 5.356235
R15503 n1_m1_244800_518400 n1_m1_249600_518400 5.356235
R15504 n1_m1_249600_518400 n1_m1_254400_518400 5.356235
R15505 n1_m1_254400_518400 n1_m1_256000_518400 1.785412
R15506 n1_m1_259200_518400 n1_m1_256000_518400 3.570824
R15507 n1_m1_259200_518400 n1_m1_264000_518400 5.356235
R15508 n1_m1_264000_518400 n1_m1_268800_518400 5.356235
R15509 n1_m1_268800_518400 n1_m1_273600_518400 5.356235
R15510 n1_m1_273600_518400 n1_m1_278400_518400 5.356235
R15511 n1_m1_278400_518400 n1_m1_283200_518400 5.356235
R15512 n1_m1_283200_518400 n1_m1_284000_518400 0.892706
R15513 n1_m1_288000_518400 n1_m1_284000_518400 4.463529
R15514 n1_m1_288000_518400 n1_m1_292800_518400 5.356235
R15515 n1_m1_292800_518400 n1_m1_297600_518400 5.356235
R15516 n1_m1_297600_518400 n1_m1_302400_518400 5.356235
R15517 n1_m1_302400_518400 n1_m1_307200_518400 5.356235
R15518 n1_m1_307200_518400 n1_m1_312000_518400 5.356235
R15519 n1_m1_312000_518400 n1_m1_316800_518400 5.356235
R15520 n1_m1_316800_518400 n1_m1_321600_518400 5.356235
R15521 n1_m1_321600_518400 n1_m1_326400_518400 5.356235
R15522 n1_m1_326400_518400 n1_m1_331200_518400 5.356235
R15523 n1_m1_331200_518400 n1_m1_336000_518400 5.356235
R15524 n1_m1_336000_518400 n1_m1_340000_518400 4.463529
R15525 n1_m1_340800_518400 n1_m1_340000_518400 0.892706
R15526 n1_m1_340800_518400 n1_m1_345600_518400 5.356235
R15527 n1_m1_345600_518400 n1_m1_350400_518400 5.356235
R15528 n1_m1_350400_518400 n1_m1_355200_518400 5.356235
R15529 n1_m1_355200_518400 n1_m1_360000_518400 5.356235
R15530 n1_m1_360000_518400 n1_m1_364800_518400 5.356235
R15531 n1_m1_364800_518400 n1_m1_368000_518400 3.570824
R15532 n1_m1_369600_518400 n1_m1_368000_518400 1.785412
R15533 n1_m1_369600_518400 n1_m1_374400_518400 5.356235
R15534 n1_m1_374400_518400 n1_m1_379200_518400 5.356235
R15535 n1_m1_379200_518400 n1_m1_384000_518400 5.356235
R15536 n1_m1_384000_518400 n1_m1_388800_518400 5.356235
R15537 n1_m1_388800_518400 n1_m1_393600_518400 5.356235
R15538 n1_m1_393600_518400 n1_m1_396000_518400 2.678118
R15539 n1_m1_398400_518400 n1_m1_396000_518400 2.678118
R15540 n1_m1_398400_518400 n1_m1_403200_518400 5.356235
R15541 n1_m1_403200_518400 n1_m1_408000_518400 5.356235
R15542 n1_m1_408000_518400 n1_m1_412800_518400 5.356235
R15543 n1_m1_412800_518400 n1_m1_417600_518400 5.356235
R15544 n1_m1_417600_518400 n1_m1_422400_518400 5.356235
R15545 n1_m1_422400_518400 n1_m1_424000_518400 1.785412
R15546 n1_m1_427200_518400 n1_m1_424000_518400 3.570824
R15547 n1_m1_427200_518400 n1_m1_432000_518400 5.356235
R15548 n1_m1_432000_518400 n1_m1_436800_518400 5.356235
R15549 n1_m1_436800_518400 n1_m1_441600_518400 5.356235
R15550 n1_m1_441600_518400 n1_m1_446400_518400 5.356235
R15551 n1_m1_446400_518400 n1_m1_451200_518400 5.356235
R15552 n1_m1_451200_518400 n1_m1_452000_518400 0.892706
R15553 n1_m1_456000_518400 n1_m1_452000_518400 4.463529
R15554 n1_m1_456000_518400 n1_m1_460800_518400 5.356235
R15555 n1_m1_460800_518400 n1_m1_465600_518400 5.356235
R15556 n1_m1_465600_518400 n1_m1_470400_518400 5.356235
R15557 n1_m1_470400_518400 n1_m1_475200_518400 5.356235
R15558 n1_m1_475200_518400 n1_m1_480000_518400 5.356235
R15559 n1_m1_480000_518400 n1_m1_484800_518400 5.356235
R15560 n1_m1_484800_518400 n1_m1_489600_518400 5.356235
R15561 n1_m1_489600_518400 n1_m1_494400_518400 5.356235
R15562 n1_m1_494400_518400 n1_m1_499200_518400 5.356235
R15563 n1_m1_499200_518400 n1_m1_504000_518400 5.356235
R15564 n1_m1_504000_518400 n1_m1_508000_518400 4.463529
R15565 n1_m1_508800_518400 n1_m1_508000_518400 0.892706
R15566 n1_m1_508800_518400 n1_m1_513600_518400 5.356235
R15567 n1_m1_513600_518400 n1_m1_518400_518400 5.356235
R15568 n1_m1_518400_518400 n1_m1_523200_518400 5.356235
R15569 n1_m1_523200_518400 n1_m1_528000_518400 5.356235
R15570 n1_m1_528000_518400 n1_m1_532800_518400 5.356235
R15571 n1_m1_532800_518400 n1_m1_536000_518400 3.570824
R15572 n1_m1_537600_518400 n1_m1_536000_518400 1.785412
R15573 n1_m1_537600_518400 n1_m1_542400_518400 5.356235
R15574 n1_m1_542400_518400 n1_m1_547200_518400 5.356235
R15575 n1_m1_547200_518400 n1_m1_552000_518400 5.356235
R15576 n1_m1_552000_518400 n1_m1_556800_518400 5.356235
R15577 n1_m1_556800_518400 n1_m1_561600_518400 5.356235
R15578 n1_m1_561600_518400 n1_m1_564000_518400 2.678118
R15579 n1_m1_566400_518400 n1_m1_564000_518400 2.678118
R15580 n1_m1_566400_518400 n1_m1_571200_518400 5.356235
R15581 n1_m1_571200_518400 n1_m1_576000_518400 5.356235
R15582 n1_m1_576000_518400 n1_m1_580800_518400 5.356235
R15583 n1_m1_580800_518400 n1_m1_585600_518400 5.356235
R15584 n1_m1_585600_518400 n1_m1_590400_518400 5.356235
R15585 n1_m1_590400_518400 n1_m1_592000_518400 1.785412
R15586 n1_m1_595200_518400 n1_m1_592000_518400 3.570824
R15587 n1_m1_0_523200 n1_m1_4000_523200 4.463529
R15588 n1_m1_4800_523200 n1_m1_4000_523200 0.892706
R15589 n1_m1_4800_523200 n1_m1_9600_523200 5.356235
R15590 n1_m1_9600_523200 n1_m1_14400_523200 5.356235
R15591 n1_m1_14400_523200 n1_m1_19200_523200 5.356235
R15592 n1_m1_19200_523200 n1_m1_24000_523200 5.356235
R15593 n1_m1_24000_523200 n1_m1_28800_523200 5.356235
R15594 n1_m1_28800_523200 n1_m1_32000_523200 3.570824
R15595 n1_m1_33600_523200 n1_m1_32000_523200 1.785412
R15596 n1_m1_33600_523200 n1_m1_38400_523200 5.356235
R15597 n1_m1_38400_523200 n1_m1_43200_523200 5.356235
R15598 n1_m1_43200_523200 n1_m1_48000_523200 5.356235
R15599 n1_m1_48000_523200 n1_m1_52800_523200 5.356235
R15600 n1_m1_52800_523200 n1_m1_57600_523200 5.356235
R15601 n1_m1_57600_523200 n1_m1_60000_523200 2.678118
R15602 n1_m1_62400_523200 n1_m1_60000_523200 2.678118
R15603 n1_m1_62400_523200 n1_m1_67200_523200 5.356235
R15604 n1_m1_67200_523200 n1_m1_72000_523200 5.356235
R15605 n1_m1_72000_523200 n1_m1_76800_523200 5.356235
R15606 n1_m1_76800_523200 n1_m1_81600_523200 5.356235
R15607 n1_m1_81600_523200 n1_m1_86400_523200 5.356235
R15608 n1_m1_86400_523200 n1_m1_88000_523200 1.785412
R15609 n1_m1_91200_523200 n1_m1_88000_523200 3.570824
R15610 n1_m1_91200_523200 n1_m1_96000_523200 5.356235
R15611 n1_m1_96000_523200 n1_m1_100800_523200 5.356235
R15612 n1_m1_100800_523200 n1_m1_105600_523200 5.356235
R15613 n1_m1_105600_523200 n1_m1_110400_523200 5.356235
R15614 n1_m1_110400_523200 n1_m1_115200_523200 5.356235
R15615 n1_m1_115200_523200 n1_m1_116000_523200 0.892706
R15616 n1_m1_120000_523200 n1_m1_116000_523200 4.463529
R15617 n1_m1_120000_523200 n1_m1_124800_523200 5.356235
R15618 n1_m1_124800_523200 n1_m1_129600_523200 5.356235
R15619 n1_m1_129600_523200 n1_m1_134400_523200 5.356235
R15620 n1_m1_134400_523200 n1_m1_139200_523200 5.356235
R15621 n1_m1_139200_523200 n1_m1_144000_523200 5.356235
R15622 n1_m1_144000_523200 n1_m1_148800_523200 5.356235
R15623 n1_m1_148800_523200 n1_m1_153600_523200 5.356235
R15624 n1_m1_153600_523200 n1_m1_158400_523200 5.356235
R15625 n1_m1_158400_523200 n1_m1_163200_523200 5.356235
R15626 n1_m1_163200_523200 n1_m1_168000_523200 5.356235
R15627 n1_m1_168000_523200 n1_m1_172000_523200 4.463529
R15628 n1_m1_172800_523200 n1_m1_172000_523200 0.892706
R15629 n1_m1_172800_523200 n1_m1_177600_523200 5.356235
R15630 n1_m1_177600_523200 n1_m1_182400_523200 5.356235
R15631 n1_m1_182400_523200 n1_m1_187200_523200 5.356235
R15632 n1_m1_187200_523200 n1_m1_192000_523200 5.356235
R15633 n1_m1_192000_523200 n1_m1_196800_523200 5.356235
R15634 n1_m1_196800_523200 n1_m1_200000_523200 3.570824
R15635 n1_m1_201600_523200 n1_m1_200000_523200 1.785412
R15636 n1_m1_201600_523200 n1_m1_206400_523200 5.356235
R15637 n1_m1_206400_523200 n1_m1_211200_523200 5.356235
R15638 n1_m1_211200_523200 n1_m1_216000_523200 5.356235
R15639 n1_m1_216000_523200 n1_m1_220800_523200 5.356235
R15640 n1_m1_220800_523200 n1_m1_225600_523200 5.356235
R15641 n1_m1_225600_523200 n1_m1_228000_523200 2.678118
R15642 n1_m1_230400_523200 n1_m1_228000_523200 2.678118
R15643 n1_m1_230400_523200 n1_m1_235200_523200 5.356235
R15644 n1_m1_235200_523200 n1_m1_240000_523200 5.356235
R15645 n1_m1_240000_523200 n1_m1_244800_523200 5.356235
R15646 n1_m1_244800_523200 n1_m1_249600_523200 5.356235
R15647 n1_m1_249600_523200 n1_m1_254400_523200 5.356235
R15648 n1_m1_254400_523200 n1_m1_256000_523200 1.785412
R15649 n1_m1_259200_523200 n1_m1_256000_523200 3.570824
R15650 n1_m1_259200_523200 n1_m1_264000_523200 5.356235
R15651 n1_m1_264000_523200 n1_m1_268800_523200 5.356235
R15652 n1_m1_268800_523200 n1_m1_273600_523200 5.356235
R15653 n1_m1_273600_523200 n1_m1_278400_523200 5.356235
R15654 n1_m1_278400_523200 n1_m1_283200_523200 5.356235
R15655 n1_m1_283200_523200 n1_m1_284000_523200 0.892706
R15656 n1_m1_288000_523200 n1_m1_284000_523200 4.463529
R15657 n1_m1_288000_523200 n1_m1_292800_523200 5.356235
R15658 n1_m1_292800_523200 n1_m1_297600_523200 5.356235
R15659 n1_m1_297600_523200 n1_m1_302400_523200 5.356235
R15660 n1_m1_302400_523200 n1_m1_307200_523200 5.356235
R15661 n1_m1_307200_523200 n1_m1_312000_523200 5.356235
R15662 n1_m1_312000_523200 n1_m1_316800_523200 5.356235
R15663 n1_m1_316800_523200 n1_m1_321600_523200 5.356235
R15664 n1_m1_321600_523200 n1_m1_326400_523200 5.356235
R15665 n1_m1_326400_523200 n1_m1_331200_523200 5.356235
R15666 n1_m1_331200_523200 n1_m1_336000_523200 5.356235
R15667 n1_m1_336000_523200 n1_m1_340000_523200 4.463529
R15668 n1_m1_340800_523200 n1_m1_340000_523200 0.892706
R15669 n1_m1_340800_523200 n1_m1_345600_523200 5.356235
R15670 n1_m1_345600_523200 n1_m1_350400_523200 5.356235
R15671 n1_m1_350400_523200 n1_m1_355200_523200 5.356235
R15672 n1_m1_355200_523200 n1_m1_360000_523200 5.356235
R15673 n1_m1_360000_523200 n1_m1_364800_523200 5.356235
R15674 n1_m1_364800_523200 n1_m1_368000_523200 3.570824
R15675 n1_m1_369600_523200 n1_m1_368000_523200 1.785412
R15676 n1_m1_369600_523200 n1_m1_374400_523200 5.356235
R15677 n1_m1_374400_523200 n1_m1_379200_523200 5.356235
R15678 n1_m1_379200_523200 n1_m1_384000_523200 5.356235
R15679 n1_m1_384000_523200 n1_m1_388800_523200 5.356235
R15680 n1_m1_388800_523200 n1_m1_393600_523200 5.356235
R15681 n1_m1_393600_523200 n1_m1_396000_523200 2.678118
R15682 n1_m1_398400_523200 n1_m1_396000_523200 2.678118
R15683 n1_m1_398400_523200 n1_m1_403200_523200 5.356235
R15684 n1_m1_403200_523200 n1_m1_408000_523200 5.356235
R15685 n1_m1_408000_523200 n1_m1_412800_523200 5.356235
R15686 n1_m1_412800_523200 n1_m1_417600_523200 5.356235
R15687 n1_m1_417600_523200 n1_m1_422400_523200 5.356235
R15688 n1_m1_422400_523200 n1_m1_424000_523200 1.785412
R15689 n1_m1_427200_523200 n1_m1_424000_523200 3.570824
R15690 n1_m1_427200_523200 n1_m1_432000_523200 5.356235
R15691 n1_m1_432000_523200 n1_m1_436800_523200 5.356235
R15692 n1_m1_436800_523200 n1_m1_441600_523200 5.356235
R15693 n1_m1_441600_523200 n1_m1_446400_523200 5.356235
R15694 n1_m1_446400_523200 n1_m1_451200_523200 5.356235
R15695 n1_m1_451200_523200 n1_m1_452000_523200 0.892706
R15696 n1_m1_456000_523200 n1_m1_452000_523200 4.463529
R15697 n1_m1_456000_523200 n1_m1_460800_523200 5.356235
R15698 n1_m1_460800_523200 n1_m1_465600_523200 5.356235
R15699 n1_m1_465600_523200 n1_m1_470400_523200 5.356235
R15700 n1_m1_470400_523200 n1_m1_475200_523200 5.356235
R15701 n1_m1_475200_523200 n1_m1_480000_523200 5.356235
R15702 n1_m1_480000_523200 n1_m1_484800_523200 5.356235
R15703 n1_m1_484800_523200 n1_m1_489600_523200 5.356235
R15704 n1_m1_489600_523200 n1_m1_494400_523200 5.356235
R15705 n1_m1_494400_523200 n1_m1_499200_523200 5.356235
R15706 n1_m1_499200_523200 n1_m1_504000_523200 5.356235
R15707 n1_m1_504000_523200 n1_m1_508000_523200 4.463529
R15708 n1_m1_508800_523200 n1_m1_508000_523200 0.892706
R15709 n1_m1_508800_523200 n1_m1_513600_523200 5.356235
R15710 n1_m1_513600_523200 n1_m1_518400_523200 5.356235
R15711 n1_m1_518400_523200 n1_m1_523200_523200 5.356235
R15712 n1_m1_523200_523200 n1_m1_528000_523200 5.356235
R15713 n1_m1_528000_523200 n1_m1_532800_523200 5.356235
R15714 n1_m1_532800_523200 n1_m1_536000_523200 3.570824
R15715 n1_m1_537600_523200 n1_m1_536000_523200 1.785412
R15716 n1_m1_537600_523200 n1_m1_542400_523200 5.356235
R15717 n1_m1_542400_523200 n1_m1_547200_523200 5.356235
R15718 n1_m1_547200_523200 n1_m1_552000_523200 5.356235
R15719 n1_m1_552000_523200 n1_m1_556800_523200 5.356235
R15720 n1_m1_556800_523200 n1_m1_561600_523200 5.356235
R15721 n1_m1_561600_523200 n1_m1_564000_523200 2.678118
R15722 n1_m1_566400_523200 n1_m1_564000_523200 2.678118
R15723 n1_m1_566400_523200 n1_m1_571200_523200 5.356235
R15724 n1_m1_571200_523200 n1_m1_576000_523200 5.356235
R15725 n1_m1_576000_523200 n1_m1_580800_523200 5.356235
R15726 n1_m1_580800_523200 n1_m1_585600_523200 5.356235
R15727 n1_m1_585600_523200 n1_m1_590400_523200 5.356235
R15728 n1_m1_590400_523200 n1_m1_592000_523200 1.785412
R15729 n1_m1_595200_523200 n1_m1_592000_523200 3.570824
R15730 n1_m1_0_528000 n1_m1_4000_528000 4.463529
R15731 n1_m1_4800_528000 n1_m1_4000_528000 0.892706
R15732 n1_m1_4800_528000 n1_m1_9600_528000 5.356235
R15733 n1_m1_9600_528000 n1_m1_14400_528000 5.356235
R15734 n1_m1_14400_528000 n1_m1_19200_528000 5.356235
R15735 n1_m1_19200_528000 n1_m1_24000_528000 5.356235
R15736 n1_m1_24000_528000 n1_m1_28800_528000 5.356235
R15737 n1_m1_28800_528000 n1_m1_32000_528000 3.570824
R15738 n1_m1_33600_528000 n1_m1_32000_528000 1.785412
R15739 n1_m1_33600_528000 n1_m1_38400_528000 5.356235
R15740 n1_m1_38400_528000 n1_m1_43200_528000 5.356235
R15741 n1_m1_43200_528000 n1_m1_48000_528000 5.356235
R15742 n1_m1_48000_528000 n1_m1_52800_528000 5.356235
R15743 n1_m1_52800_528000 n1_m1_57600_528000 5.356235
R15744 n1_m1_57600_528000 n1_m1_60000_528000 2.678118
R15745 n1_m1_62400_528000 n1_m1_60000_528000 2.678118
R15746 n1_m1_62400_528000 n1_m1_67200_528000 5.356235
R15747 n1_m1_67200_528000 n1_m1_72000_528000 5.356235
R15748 n1_m1_72000_528000 n1_m1_76800_528000 5.356235
R15749 n1_m1_76800_528000 n1_m1_81600_528000 5.356235
R15750 n1_m1_81600_528000 n1_m1_86400_528000 5.356235
R15751 n1_m1_86400_528000 n1_m1_88000_528000 1.785412
R15752 n1_m1_91200_528000 n1_m1_88000_528000 3.570824
R15753 n1_m1_91200_528000 n1_m1_96000_528000 5.356235
R15754 n1_m1_96000_528000 n1_m1_100800_528000 5.356235
R15755 n1_m1_100800_528000 n1_m1_105600_528000 5.356235
R15756 n1_m1_105600_528000 n1_m1_110400_528000 5.356235
R15757 n1_m1_110400_528000 n1_m1_115200_528000 5.356235
R15758 n1_m1_115200_528000 n1_m1_116000_528000 0.892706
R15759 n1_m1_120000_528000 n1_m1_116000_528000 4.463529
R15760 n1_m1_120000_528000 n1_m1_124800_528000 5.356235
R15761 n1_m1_124800_528000 n1_m1_129600_528000 5.356235
R15762 n1_m1_129600_528000 n1_m1_134400_528000 5.356235
R15763 n1_m1_134400_528000 n1_m1_139200_528000 5.356235
R15764 n1_m1_139200_528000 n1_m1_144000_528000 5.356235
R15765 n1_m1_144000_528000 n1_m1_148800_528000 5.356235
R15766 n1_m1_148800_528000 n1_m1_153600_528000 5.356235
R15767 n1_m1_153600_528000 n1_m1_158400_528000 5.356235
R15768 n1_m1_158400_528000 n1_m1_163200_528000 5.356235
R15769 n1_m1_163200_528000 n1_m1_168000_528000 5.356235
R15770 n1_m1_168000_528000 n1_m1_172000_528000 4.463529
R15771 n1_m1_172800_528000 n1_m1_172000_528000 0.892706
R15772 n1_m1_172800_528000 n1_m1_177600_528000 5.356235
R15773 n1_m1_177600_528000 n1_m1_182400_528000 5.356235
R15774 n1_m1_182400_528000 n1_m1_187200_528000 5.356235
R15775 n1_m1_187200_528000 n1_m1_192000_528000 5.356235
R15776 n1_m1_192000_528000 n1_m1_196800_528000 5.356235
R15777 n1_m1_196800_528000 n1_m1_200000_528000 3.570824
R15778 n1_m1_201600_528000 n1_m1_200000_528000 1.785412
R15779 n1_m1_201600_528000 n1_m1_206400_528000 5.356235
R15780 n1_m1_206400_528000 n1_m1_211200_528000 5.356235
R15781 n1_m1_211200_528000 n1_m1_216000_528000 5.356235
R15782 n1_m1_216000_528000 n1_m1_220800_528000 5.356235
R15783 n1_m1_220800_528000 n1_m1_225600_528000 5.356235
R15784 n1_m1_225600_528000 n1_m1_228000_528000 2.678118
R15785 n1_m1_230400_528000 n1_m1_228000_528000 2.678118
R15786 n1_m1_230400_528000 n1_m1_235200_528000 5.356235
R15787 n1_m1_235200_528000 n1_m1_240000_528000 5.356235
R15788 n1_m1_240000_528000 n1_m1_244800_528000 5.356235
R15789 n1_m1_244800_528000 n1_m1_249600_528000 5.356235
R15790 n1_m1_249600_528000 n1_m1_254400_528000 5.356235
R15791 n1_m1_254400_528000 n1_m1_256000_528000 1.785412
R15792 n1_m1_259200_528000 n1_m1_256000_528000 3.570824
R15793 n1_m1_259200_528000 n1_m1_264000_528000 5.356235
R15794 n1_m1_264000_528000 n1_m1_268800_528000 5.356235
R15795 n1_m1_268800_528000 n1_m1_273600_528000 5.356235
R15796 n1_m1_273600_528000 n1_m1_278400_528000 5.356235
R15797 n1_m1_278400_528000 n1_m1_283200_528000 5.356235
R15798 n1_m1_283200_528000 n1_m1_284000_528000 0.892706
R15799 n1_m1_288000_528000 n1_m1_284000_528000 4.463529
R15800 n1_m1_288000_528000 n1_m1_292800_528000 5.356235
R15801 n1_m1_292800_528000 n1_m1_297600_528000 5.356235
R15802 n1_m1_297600_528000 n1_m1_302400_528000 5.356235
R15803 n1_m1_302400_528000 n1_m1_307200_528000 5.356235
R15804 n1_m1_307200_528000 n1_m1_312000_528000 5.356235
R15805 n1_m1_312000_528000 n1_m1_316800_528000 5.356235
R15806 n1_m1_316800_528000 n1_m1_321600_528000 5.356235
R15807 n1_m1_321600_528000 n1_m1_326400_528000 5.356235
R15808 n1_m1_326400_528000 n1_m1_331200_528000 5.356235
R15809 n1_m1_331200_528000 n1_m1_336000_528000 5.356235
R15810 n1_m1_336000_528000 n1_m1_340000_528000 4.463529
R15811 n1_m1_340800_528000 n1_m1_340000_528000 0.892706
R15812 n1_m1_340800_528000 n1_m1_345600_528000 5.356235
R15813 n1_m1_345600_528000 n1_m1_350400_528000 5.356235
R15814 n1_m1_350400_528000 n1_m1_355200_528000 5.356235
R15815 n1_m1_355200_528000 n1_m1_360000_528000 5.356235
R15816 n1_m1_360000_528000 n1_m1_364800_528000 5.356235
R15817 n1_m1_364800_528000 n1_m1_368000_528000 3.570824
R15818 n1_m1_369600_528000 n1_m1_368000_528000 1.785412
R15819 n1_m1_369600_528000 n1_m1_374400_528000 5.356235
R15820 n1_m1_374400_528000 n1_m1_379200_528000 5.356235
R15821 n1_m1_379200_528000 n1_m1_384000_528000 5.356235
R15822 n1_m1_384000_528000 n1_m1_388800_528000 5.356235
R15823 n1_m1_388800_528000 n1_m1_393600_528000 5.356235
R15824 n1_m1_393600_528000 n1_m1_396000_528000 2.678118
R15825 n1_m1_398400_528000 n1_m1_396000_528000 2.678118
R15826 n1_m1_398400_528000 n1_m1_403200_528000 5.356235
R15827 n1_m1_403200_528000 n1_m1_408000_528000 5.356235
R15828 n1_m1_408000_528000 n1_m1_412800_528000 5.356235
R15829 n1_m1_412800_528000 n1_m1_417600_528000 5.356235
R15830 n1_m1_417600_528000 n1_m1_422400_528000 5.356235
R15831 n1_m1_422400_528000 n1_m1_424000_528000 1.785412
R15832 n1_m1_427200_528000 n1_m1_424000_528000 3.570824
R15833 n1_m1_427200_528000 n1_m1_432000_528000 5.356235
R15834 n1_m1_432000_528000 n1_m1_436800_528000 5.356235
R15835 n1_m1_436800_528000 n1_m1_441600_528000 5.356235
R15836 n1_m1_441600_528000 n1_m1_446400_528000 5.356235
R15837 n1_m1_446400_528000 n1_m1_451200_528000 5.356235
R15838 n1_m1_451200_528000 n1_m1_452000_528000 0.892706
R15839 n1_m1_456000_528000 n1_m1_452000_528000 4.463529
R15840 n1_m1_456000_528000 n1_m1_460800_528000 5.356235
R15841 n1_m1_460800_528000 n1_m1_465600_528000 5.356235
R15842 n1_m1_465600_528000 n1_m1_470400_528000 5.356235
R15843 n1_m1_470400_528000 n1_m1_475200_528000 5.356235
R15844 n1_m1_475200_528000 n1_m1_480000_528000 5.356235
R15845 n1_m1_480000_528000 n1_m1_484800_528000 5.356235
R15846 n1_m1_484800_528000 n1_m1_489600_528000 5.356235
R15847 n1_m1_489600_528000 n1_m1_494400_528000 5.356235
R15848 n1_m1_494400_528000 n1_m1_499200_528000 5.356235
R15849 n1_m1_499200_528000 n1_m1_504000_528000 5.356235
R15850 n1_m1_504000_528000 n1_m1_508000_528000 4.463529
R15851 n1_m1_508800_528000 n1_m1_508000_528000 0.892706
R15852 n1_m1_508800_528000 n1_m1_513600_528000 5.356235
R15853 n1_m1_513600_528000 n1_m1_518400_528000 5.356235
R15854 n1_m1_518400_528000 n1_m1_523200_528000 5.356235
R15855 n1_m1_523200_528000 n1_m1_528000_528000 5.356235
R15856 n1_m1_528000_528000 n1_m1_532800_528000 5.356235
R15857 n1_m1_532800_528000 n1_m1_536000_528000 3.570824
R15858 n1_m1_537600_528000 n1_m1_536000_528000 1.785412
R15859 n1_m1_537600_528000 n1_m1_542400_528000 5.356235
R15860 n1_m1_542400_528000 n1_m1_547200_528000 5.356235
R15861 n1_m1_547200_528000 n1_m1_552000_528000 5.356235
R15862 n1_m1_552000_528000 n1_m1_556800_528000 5.356235
R15863 n1_m1_556800_528000 n1_m1_561600_528000 5.356235
R15864 n1_m1_561600_528000 n1_m1_564000_528000 2.678118
R15865 n1_m1_566400_528000 n1_m1_564000_528000 2.678118
R15866 n1_m1_566400_528000 n1_m1_571200_528000 5.356235
R15867 n1_m1_571200_528000 n1_m1_576000_528000 5.356235
R15868 n1_m1_576000_528000 n1_m1_580800_528000 5.356235
R15869 n1_m1_580800_528000 n1_m1_585600_528000 5.356235
R15870 n1_m1_585600_528000 n1_m1_590400_528000 5.356235
R15871 n1_m1_590400_528000 n1_m1_592000_528000 1.785412
R15872 n1_m1_595200_528000 n1_m1_592000_528000 3.570824
R15873 n1_m1_0_532800 n1_m1_4000_532800 4.463529
R15874 n1_m1_4800_532800 n1_m1_4000_532800 0.892706
R15875 n1_m1_4800_532800 n1_m1_9600_532800 5.356235
R15876 n1_m1_9600_532800 n1_m1_14400_532800 5.356235
R15877 n1_m1_14400_532800 n1_m1_19200_532800 5.356235
R15878 n1_m1_19200_532800 n1_m1_24000_532800 5.356235
R15879 n1_m1_24000_532800 n1_m1_28800_532800 5.356235
R15880 n1_m1_28800_532800 n1_m1_32000_532800 3.570824
R15881 n1_m1_33600_532800 n1_m1_32000_532800 1.785412
R15882 n1_m1_33600_532800 n1_m1_38400_532800 5.356235
R15883 n1_m1_38400_532800 n1_m1_43200_532800 5.356235
R15884 n1_m1_43200_532800 n1_m1_48000_532800 5.356235
R15885 n1_m1_48000_532800 n1_m1_52800_532800 5.356235
R15886 n1_m1_52800_532800 n1_m1_57600_532800 5.356235
R15887 n1_m1_57600_532800 n1_m1_60000_532800 2.678118
R15888 n1_m1_62400_532800 n1_m1_60000_532800 2.678118
R15889 n1_m1_62400_532800 n1_m1_67200_532800 5.356235
R15890 n1_m1_67200_532800 n1_m1_72000_532800 5.356235
R15891 n1_m1_72000_532800 n1_m1_76800_532800 5.356235
R15892 n1_m1_76800_532800 n1_m1_81600_532800 5.356235
R15893 n1_m1_81600_532800 n1_m1_86400_532800 5.356235
R15894 n1_m1_86400_532800 n1_m1_88000_532800 1.785412
R15895 n1_m1_91200_532800 n1_m1_88000_532800 3.570824
R15896 n1_m1_91200_532800 n1_m1_96000_532800 5.356235
R15897 n1_m1_96000_532800 n1_m1_100800_532800 5.356235
R15898 n1_m1_100800_532800 n1_m1_105600_532800 5.356235
R15899 n1_m1_105600_532800 n1_m1_110400_532800 5.356235
R15900 n1_m1_110400_532800 n1_m1_115200_532800 5.356235
R15901 n1_m1_115200_532800 n1_m1_116000_532800 0.892706
R15902 n1_m1_120000_532800 n1_m1_116000_532800 4.463529
R15903 n1_m1_120000_532800 n1_m1_124800_532800 5.356235
R15904 n1_m1_124800_532800 n1_m1_129600_532800 5.356235
R15905 n1_m1_129600_532800 n1_m1_134400_532800 5.356235
R15906 n1_m1_134400_532800 n1_m1_139200_532800 5.356235
R15907 n1_m1_139200_532800 n1_m1_144000_532800 5.356235
R15908 n1_m1_144000_532800 n1_m1_148800_532800 5.356235
R15909 n1_m1_148800_532800 n1_m1_153600_532800 5.356235
R15910 n1_m1_153600_532800 n1_m1_158400_532800 5.356235
R15911 n1_m1_158400_532800 n1_m1_163200_532800 5.356235
R15912 n1_m1_163200_532800 n1_m1_168000_532800 5.356235
R15913 n1_m1_168000_532800 n1_m1_172000_532800 4.463529
R15914 n1_m1_172800_532800 n1_m1_172000_532800 0.892706
R15915 n1_m1_172800_532800 n1_m1_177600_532800 5.356235
R15916 n1_m1_177600_532800 n1_m1_182400_532800 5.356235
R15917 n1_m1_182400_532800 n1_m1_187200_532800 5.356235
R15918 n1_m1_187200_532800 n1_m1_192000_532800 5.356235
R15919 n1_m1_192000_532800 n1_m1_196800_532800 5.356235
R15920 n1_m1_196800_532800 n1_m1_200000_532800 3.570824
R15921 n1_m1_201600_532800 n1_m1_200000_532800 1.785412
R15922 n1_m1_201600_532800 n1_m1_206400_532800 5.356235
R15923 n1_m1_206400_532800 n1_m1_211200_532800 5.356235
R15924 n1_m1_211200_532800 n1_m1_216000_532800 5.356235
R15925 n1_m1_216000_532800 n1_m1_220800_532800 5.356235
R15926 n1_m1_220800_532800 n1_m1_225600_532800 5.356235
R15927 n1_m1_225600_532800 n1_m1_228000_532800 2.678118
R15928 n1_m1_230400_532800 n1_m1_228000_532800 2.678118
R15929 n1_m1_230400_532800 n1_m1_235200_532800 5.356235
R15930 n1_m1_235200_532800 n1_m1_240000_532800 5.356235
R15931 n1_m1_240000_532800 n1_m1_244800_532800 5.356235
R15932 n1_m1_244800_532800 n1_m1_249600_532800 5.356235
R15933 n1_m1_249600_532800 n1_m1_254400_532800 5.356235
R15934 n1_m1_254400_532800 n1_m1_256000_532800 1.785412
R15935 n1_m1_259200_532800 n1_m1_256000_532800 3.570824
R15936 n1_m1_259200_532800 n1_m1_264000_532800 5.356235
R15937 n1_m1_264000_532800 n1_m1_268800_532800 5.356235
R15938 n1_m1_268800_532800 n1_m1_273600_532800 5.356235
R15939 n1_m1_273600_532800 n1_m1_278400_532800 5.356235
R15940 n1_m1_278400_532800 n1_m1_283200_532800 5.356235
R15941 n1_m1_283200_532800 n1_m1_284000_532800 0.892706
R15942 n1_m1_288000_532800 n1_m1_284000_532800 4.463529
R15943 n1_m1_288000_532800 n1_m1_292800_532800 5.356235
R15944 n1_m1_292800_532800 n1_m1_297600_532800 5.356235
R15945 n1_m1_297600_532800 n1_m1_302400_532800 5.356235
R15946 n1_m1_302400_532800 n1_m1_307200_532800 5.356235
R15947 n1_m1_307200_532800 n1_m1_312000_532800 5.356235
R15948 n1_m1_312000_532800 n1_m1_316800_532800 5.356235
R15949 n1_m1_316800_532800 n1_m1_321600_532800 5.356235
R15950 n1_m1_321600_532800 n1_m1_326400_532800 5.356235
R15951 n1_m1_326400_532800 n1_m1_331200_532800 5.356235
R15952 n1_m1_331200_532800 n1_m1_336000_532800 5.356235
R15953 n1_m1_336000_532800 n1_m1_340000_532800 4.463529
R15954 n1_m1_340800_532800 n1_m1_340000_532800 0.892706
R15955 n1_m1_340800_532800 n1_m1_345600_532800 5.356235
R15956 n1_m1_345600_532800 n1_m1_350400_532800 5.356235
R15957 n1_m1_350400_532800 n1_m1_355200_532800 5.356235
R15958 n1_m1_355200_532800 n1_m1_360000_532800 5.356235
R15959 n1_m1_360000_532800 n1_m1_364800_532800 5.356235
R15960 n1_m1_364800_532800 n1_m1_368000_532800 3.570824
R15961 n1_m1_369600_532800 n1_m1_368000_532800 1.785412
R15962 n1_m1_369600_532800 n1_m1_374400_532800 5.356235
R15963 n1_m1_374400_532800 n1_m1_379200_532800 5.356235
R15964 n1_m1_379200_532800 n1_m1_384000_532800 5.356235
R15965 n1_m1_384000_532800 n1_m1_388800_532800 5.356235
R15966 n1_m1_388800_532800 n1_m1_393600_532800 5.356235
R15967 n1_m1_393600_532800 n1_m1_396000_532800 2.678118
R15968 n1_m1_398400_532800 n1_m1_396000_532800 2.678118
R15969 n1_m1_398400_532800 n1_m1_403200_532800 5.356235
R15970 n1_m1_403200_532800 n1_m1_408000_532800 5.356235
R15971 n1_m1_408000_532800 n1_m1_412800_532800 5.356235
R15972 n1_m1_412800_532800 n1_m1_417600_532800 5.356235
R15973 n1_m1_417600_532800 n1_m1_422400_532800 5.356235
R15974 n1_m1_422400_532800 n1_m1_424000_532800 1.785412
R15975 n1_m1_427200_532800 n1_m1_424000_532800 3.570824
R15976 n1_m1_427200_532800 n1_m1_432000_532800 5.356235
R15977 n1_m1_432000_532800 n1_m1_436800_532800 5.356235
R15978 n1_m1_436800_532800 n1_m1_441600_532800 5.356235
R15979 n1_m1_441600_532800 n1_m1_446400_532800 5.356235
R15980 n1_m1_446400_532800 n1_m1_451200_532800 5.356235
R15981 n1_m1_451200_532800 n1_m1_452000_532800 0.892706
R15982 n1_m1_456000_532800 n1_m1_452000_532800 4.463529
R15983 n1_m1_456000_532800 n1_m1_460800_532800 5.356235
R15984 n1_m1_460800_532800 n1_m1_465600_532800 5.356235
R15985 n1_m1_465600_532800 n1_m1_470400_532800 5.356235
R15986 n1_m1_470400_532800 n1_m1_475200_532800 5.356235
R15987 n1_m1_475200_532800 n1_m1_480000_532800 5.356235
R15988 n1_m1_480000_532800 n1_m1_484800_532800 5.356235
R15989 n1_m1_484800_532800 n1_m1_489600_532800 5.356235
R15990 n1_m1_489600_532800 n1_m1_494400_532800 5.356235
R15991 n1_m1_494400_532800 n1_m1_499200_532800 5.356235
R15992 n1_m1_499200_532800 n1_m1_504000_532800 5.356235
R15993 n1_m1_504000_532800 n1_m1_508000_532800 4.463529
R15994 n1_m1_508800_532800 n1_m1_508000_532800 0.892706
R15995 n1_m1_508800_532800 n1_m1_513600_532800 5.356235
R15996 n1_m1_513600_532800 n1_m1_518400_532800 5.356235
R15997 n1_m1_518400_532800 n1_m1_523200_532800 5.356235
R15998 n1_m1_523200_532800 n1_m1_528000_532800 5.356235
R15999 n1_m1_528000_532800 n1_m1_532800_532800 5.356235
R16000 n1_m1_532800_532800 n1_m1_536000_532800 3.570824
R16001 n1_m1_537600_532800 n1_m1_536000_532800 1.785412
R16002 n1_m1_537600_532800 n1_m1_542400_532800 5.356235
R16003 n1_m1_542400_532800 n1_m1_547200_532800 5.356235
R16004 n1_m1_547200_532800 n1_m1_552000_532800 5.356235
R16005 n1_m1_552000_532800 n1_m1_556800_532800 5.356235
R16006 n1_m1_556800_532800 n1_m1_561600_532800 5.356235
R16007 n1_m1_561600_532800 n1_m1_564000_532800 2.678118
R16008 n1_m1_566400_532800 n1_m1_564000_532800 2.678118
R16009 n1_m1_566400_532800 n1_m1_571200_532800 5.356235
R16010 n1_m1_571200_532800 n1_m1_576000_532800 5.356235
R16011 n1_m1_576000_532800 n1_m1_580800_532800 5.356235
R16012 n1_m1_580800_532800 n1_m1_585600_532800 5.356235
R16013 n1_m1_585600_532800 n1_m1_590400_532800 5.356235
R16014 n1_m1_590400_532800 n1_m1_592000_532800 1.785412
R16015 n1_m1_595200_532800 n1_m1_592000_532800 3.570824
R16016 n1_m1_0_537600 n1_m1_4000_537600 4.463529
R16017 n1_m1_4800_537600 n1_m1_4000_537600 0.892706
R16018 n1_m1_4800_537600 n1_m1_9600_537600 5.356235
R16019 n1_m1_9600_537600 n1_m1_14400_537600 5.356235
R16020 n1_m1_14400_537600 n1_m1_19200_537600 5.356235
R16021 n1_m1_19200_537600 n1_m1_24000_537600 5.356235
R16022 n1_m1_24000_537600 n1_m1_28800_537600 5.356235
R16023 n1_m1_28800_537600 n1_m1_32000_537600 3.570824
R16024 n1_m1_33600_537600 n1_m1_32000_537600 1.785412
R16025 n1_m1_33600_537600 n1_m1_38400_537600 5.356235
R16026 n1_m1_38400_537600 n1_m1_43200_537600 5.356235
R16027 n1_m1_43200_537600 n1_m1_48000_537600 5.356235
R16028 n1_m1_48000_537600 n1_m1_52800_537600 5.356235
R16029 n1_m1_52800_537600 n1_m1_57600_537600 5.356235
R16030 n1_m1_57600_537600 n1_m1_60000_537600 2.678118
R16031 n1_m1_62400_537600 n1_m1_60000_537600 2.678118
R16032 n1_m1_62400_537600 n1_m1_67200_537600 5.356235
R16033 n1_m1_67200_537600 n1_m1_72000_537600 5.356235
R16034 n1_m1_72000_537600 n1_m1_76800_537600 5.356235
R16035 n1_m1_76800_537600 n1_m1_81600_537600 5.356235
R16036 n1_m1_81600_537600 n1_m1_86400_537600 5.356235
R16037 n1_m1_86400_537600 n1_m1_88000_537600 1.785412
R16038 n1_m1_91200_537600 n1_m1_88000_537600 3.570824
R16039 n1_m1_91200_537600 n1_m1_96000_537600 5.356235
R16040 n1_m1_96000_537600 n1_m1_100800_537600 5.356235
R16041 n1_m1_100800_537600 n1_m1_105600_537600 5.356235
R16042 n1_m1_105600_537600 n1_m1_110400_537600 5.356235
R16043 n1_m1_110400_537600 n1_m1_115200_537600 5.356235
R16044 n1_m1_115200_537600 n1_m1_116000_537600 0.892706
R16045 n1_m1_120000_537600 n1_m1_116000_537600 4.463529
R16046 n1_m1_120000_537600 n1_m1_124800_537600 5.356235
R16047 n1_m1_124800_537600 n1_m1_129600_537600 5.356235
R16048 n1_m1_129600_537600 n1_m1_134400_537600 5.356235
R16049 n1_m1_134400_537600 n1_m1_139200_537600 5.356235
R16050 n1_m1_139200_537600 n1_m1_144000_537600 5.356235
R16051 n1_m1_144000_537600 n1_m1_148800_537600 5.356235
R16052 n1_m1_148800_537600 n1_m1_153600_537600 5.356235
R16053 n1_m1_153600_537600 n1_m1_158400_537600 5.356235
R16054 n1_m1_158400_537600 n1_m1_163200_537600 5.356235
R16055 n1_m1_163200_537600 n1_m1_168000_537600 5.356235
R16056 n1_m1_168000_537600 n1_m1_172000_537600 4.463529
R16057 n1_m1_172800_537600 n1_m1_172000_537600 0.892706
R16058 n1_m1_172800_537600 n1_m1_177600_537600 5.356235
R16059 n1_m1_177600_537600 n1_m1_182400_537600 5.356235
R16060 n1_m1_182400_537600 n1_m1_187200_537600 5.356235
R16061 n1_m1_187200_537600 n1_m1_192000_537600 5.356235
R16062 n1_m1_192000_537600 n1_m1_196800_537600 5.356235
R16063 n1_m1_196800_537600 n1_m1_200000_537600 3.570824
R16064 n1_m1_201600_537600 n1_m1_200000_537600 1.785412
R16065 n1_m1_201600_537600 n1_m1_206400_537600 5.356235
R16066 n1_m1_206400_537600 n1_m1_211200_537600 5.356235
R16067 n1_m1_211200_537600 n1_m1_216000_537600 5.356235
R16068 n1_m1_216000_537600 n1_m1_220800_537600 5.356235
R16069 n1_m1_220800_537600 n1_m1_225600_537600 5.356235
R16070 n1_m1_225600_537600 n1_m1_228000_537600 2.678118
R16071 n1_m1_230400_537600 n1_m1_228000_537600 2.678118
R16072 n1_m1_230400_537600 n1_m1_235200_537600 5.356235
R16073 n1_m1_235200_537600 n1_m1_240000_537600 5.356235
R16074 n1_m1_240000_537600 n1_m1_244800_537600 5.356235
R16075 n1_m1_244800_537600 n1_m1_249600_537600 5.356235
R16076 n1_m1_249600_537600 n1_m1_254400_537600 5.356235
R16077 n1_m1_254400_537600 n1_m1_256000_537600 1.785412
R16078 n1_m1_259200_537600 n1_m1_256000_537600 3.570824
R16079 n1_m1_259200_537600 n1_m1_264000_537600 5.356235
R16080 n1_m1_264000_537600 n1_m1_268800_537600 5.356235
R16081 n1_m1_268800_537600 n1_m1_273600_537600 5.356235
R16082 n1_m1_273600_537600 n1_m1_278400_537600 5.356235
R16083 n1_m1_278400_537600 n1_m1_283200_537600 5.356235
R16084 n1_m1_283200_537600 n1_m1_284000_537600 0.892706
R16085 n1_m1_288000_537600 n1_m1_284000_537600 4.463529
R16086 n1_m1_288000_537600 n1_m1_292800_537600 5.356235
R16087 n1_m1_292800_537600 n1_m1_297600_537600 5.356235
R16088 n1_m1_297600_537600 n1_m1_302400_537600 5.356235
R16089 n1_m1_302400_537600 n1_m1_307200_537600 5.356235
R16090 n1_m1_307200_537600 n1_m1_312000_537600 5.356235
R16091 n1_m1_312000_537600 n1_m1_316800_537600 5.356235
R16092 n1_m1_316800_537600 n1_m1_321600_537600 5.356235
R16093 n1_m1_321600_537600 n1_m1_326400_537600 5.356235
R16094 n1_m1_326400_537600 n1_m1_331200_537600 5.356235
R16095 n1_m1_331200_537600 n1_m1_336000_537600 5.356235
R16096 n1_m1_336000_537600 n1_m1_340000_537600 4.463529
R16097 n1_m1_340800_537600 n1_m1_340000_537600 0.892706
R16098 n1_m1_340800_537600 n1_m1_345600_537600 5.356235
R16099 n1_m1_345600_537600 n1_m1_350400_537600 5.356235
R16100 n1_m1_350400_537600 n1_m1_355200_537600 5.356235
R16101 n1_m1_355200_537600 n1_m1_360000_537600 5.356235
R16102 n1_m1_360000_537600 n1_m1_364800_537600 5.356235
R16103 n1_m1_364800_537600 n1_m1_368000_537600 3.570824
R16104 n1_m1_369600_537600 n1_m1_368000_537600 1.785412
R16105 n1_m1_369600_537600 n1_m1_374400_537600 5.356235
R16106 n1_m1_374400_537600 n1_m1_379200_537600 5.356235
R16107 n1_m1_379200_537600 n1_m1_384000_537600 5.356235
R16108 n1_m1_384000_537600 n1_m1_388800_537600 5.356235
R16109 n1_m1_388800_537600 n1_m1_393600_537600 5.356235
R16110 n1_m1_393600_537600 n1_m1_396000_537600 2.678118
R16111 n1_m1_398400_537600 n1_m1_396000_537600 2.678118
R16112 n1_m1_398400_537600 n1_m1_403200_537600 5.356235
R16113 n1_m1_403200_537600 n1_m1_408000_537600 5.356235
R16114 n1_m1_408000_537600 n1_m1_412800_537600 5.356235
R16115 n1_m1_412800_537600 n1_m1_417600_537600 5.356235
R16116 n1_m1_417600_537600 n1_m1_422400_537600 5.356235
R16117 n1_m1_422400_537600 n1_m1_424000_537600 1.785412
R16118 n1_m1_427200_537600 n1_m1_424000_537600 3.570824
R16119 n1_m1_427200_537600 n1_m1_432000_537600 5.356235
R16120 n1_m1_432000_537600 n1_m1_436800_537600 5.356235
R16121 n1_m1_436800_537600 n1_m1_441600_537600 5.356235
R16122 n1_m1_441600_537600 n1_m1_446400_537600 5.356235
R16123 n1_m1_446400_537600 n1_m1_451200_537600 5.356235
R16124 n1_m1_451200_537600 n1_m1_452000_537600 0.892706
R16125 n1_m1_456000_537600 n1_m1_452000_537600 4.463529
R16126 n1_m1_456000_537600 n1_m1_460800_537600 5.356235
R16127 n1_m1_460800_537600 n1_m1_465600_537600 5.356235
R16128 n1_m1_465600_537600 n1_m1_470400_537600 5.356235
R16129 n1_m1_470400_537600 n1_m1_475200_537600 5.356235
R16130 n1_m1_475200_537600 n1_m1_480000_537600 5.356235
R16131 n1_m1_480000_537600 n1_m1_484800_537600 5.356235
R16132 n1_m1_484800_537600 n1_m1_489600_537600 5.356235
R16133 n1_m1_489600_537600 n1_m1_494400_537600 5.356235
R16134 n1_m1_494400_537600 n1_m1_499200_537600 5.356235
R16135 n1_m1_499200_537600 n1_m1_504000_537600 5.356235
R16136 n1_m1_504000_537600 n1_m1_508000_537600 4.463529
R16137 n1_m1_508800_537600 n1_m1_508000_537600 0.892706
R16138 n1_m1_508800_537600 n1_m1_513600_537600 5.356235
R16139 n1_m1_513600_537600 n1_m1_518400_537600 5.356235
R16140 n1_m1_518400_537600 n1_m1_523200_537600 5.356235
R16141 n1_m1_523200_537600 n1_m1_528000_537600 5.356235
R16142 n1_m1_528000_537600 n1_m1_532800_537600 5.356235
R16143 n1_m1_532800_537600 n1_m1_536000_537600 3.570824
R16144 n1_m1_537600_537600 n1_m1_536000_537600 1.785412
R16145 n1_m1_537600_537600 n1_m1_542400_537600 5.356235
R16146 n1_m1_542400_537600 n1_m1_547200_537600 5.356235
R16147 n1_m1_547200_537600 n1_m1_552000_537600 5.356235
R16148 n1_m1_552000_537600 n1_m1_556800_537600 5.356235
R16149 n1_m1_556800_537600 n1_m1_561600_537600 5.356235
R16150 n1_m1_561600_537600 n1_m1_564000_537600 2.678118
R16151 n1_m1_566400_537600 n1_m1_564000_537600 2.678118
R16152 n1_m1_566400_537600 n1_m1_571200_537600 5.356235
R16153 n1_m1_571200_537600 n1_m1_576000_537600 5.356235
R16154 n1_m1_576000_537600 n1_m1_580800_537600 5.356235
R16155 n1_m1_580800_537600 n1_m1_585600_537600 5.356235
R16156 n1_m1_585600_537600 n1_m1_590400_537600 5.356235
R16157 n1_m1_590400_537600 n1_m1_592000_537600 1.785412
R16158 n1_m1_595200_537600 n1_m1_592000_537600 3.570824
R16159 n1_m1_0_542400 n1_m1_4000_542400 4.463529
R16160 n1_m1_4800_542400 n1_m1_4000_542400 0.892706
R16161 n1_m1_4800_542400 n1_m1_9600_542400 5.356235
R16162 n1_m1_9600_542400 n1_m1_14400_542400 5.356235
R16163 n1_m1_14400_542400 n1_m1_19200_542400 5.356235
R16164 n1_m1_19200_542400 n1_m1_24000_542400 5.356235
R16165 n1_m1_24000_542400 n1_m1_28800_542400 5.356235
R16166 n1_m1_28800_542400 n1_m1_32000_542400 3.570824
R16167 n1_m1_33600_542400 n1_m1_32000_542400 1.785412
R16168 n1_m1_33600_542400 n1_m1_38400_542400 5.356235
R16169 n1_m1_38400_542400 n1_m1_43200_542400 5.356235
R16170 n1_m1_43200_542400 n1_m1_48000_542400 5.356235
R16171 n1_m1_48000_542400 n1_m1_52800_542400 5.356235
R16172 n1_m1_52800_542400 n1_m1_57600_542400 5.356235
R16173 n1_m1_57600_542400 n1_m1_60000_542400 2.678118
R16174 n1_m1_62400_542400 n1_m1_60000_542400 2.678118
R16175 n1_m1_62400_542400 n1_m1_67200_542400 5.356235
R16176 n1_m1_67200_542400 n1_m1_72000_542400 5.356235
R16177 n1_m1_72000_542400 n1_m1_76800_542400 5.356235
R16178 n1_m1_76800_542400 n1_m1_81600_542400 5.356235
R16179 n1_m1_81600_542400 n1_m1_86400_542400 5.356235
R16180 n1_m1_86400_542400 n1_m1_88000_542400 1.785412
R16181 n1_m1_91200_542400 n1_m1_88000_542400 3.570824
R16182 n1_m1_91200_542400 n1_m1_96000_542400 5.356235
R16183 n1_m1_96000_542400 n1_m1_100800_542400 5.356235
R16184 n1_m1_100800_542400 n1_m1_105600_542400 5.356235
R16185 n1_m1_105600_542400 n1_m1_110400_542400 5.356235
R16186 n1_m1_110400_542400 n1_m1_115200_542400 5.356235
R16187 n1_m1_115200_542400 n1_m1_116000_542400 0.892706
R16188 n1_m1_120000_542400 n1_m1_116000_542400 4.463529
R16189 n1_m1_120000_542400 n1_m1_124800_542400 5.356235
R16190 n1_m1_124800_542400 n1_m1_129600_542400 5.356235
R16191 n1_m1_129600_542400 n1_m1_134400_542400 5.356235
R16192 n1_m1_134400_542400 n1_m1_139200_542400 5.356235
R16193 n1_m1_139200_542400 n1_m1_144000_542400 5.356235
R16194 n1_m1_144000_542400 n1_m1_148800_542400 5.356235
R16195 n1_m1_148800_542400 n1_m1_153600_542400 5.356235
R16196 n1_m1_153600_542400 n1_m1_158400_542400 5.356235
R16197 n1_m1_158400_542400 n1_m1_163200_542400 5.356235
R16198 n1_m1_163200_542400 n1_m1_168000_542400 5.356235
R16199 n1_m1_168000_542400 n1_m1_172000_542400 4.463529
R16200 n1_m1_172800_542400 n1_m1_172000_542400 0.892706
R16201 n1_m1_172800_542400 n1_m1_177600_542400 5.356235
R16202 n1_m1_177600_542400 n1_m1_182400_542400 5.356235
R16203 n1_m1_182400_542400 n1_m1_187200_542400 5.356235
R16204 n1_m1_187200_542400 n1_m1_192000_542400 5.356235
R16205 n1_m1_192000_542400 n1_m1_196800_542400 5.356235
R16206 n1_m1_196800_542400 n1_m1_200000_542400 3.570824
R16207 n1_m1_201600_542400 n1_m1_200000_542400 1.785412
R16208 n1_m1_201600_542400 n1_m1_206400_542400 5.356235
R16209 n1_m1_206400_542400 n1_m1_211200_542400 5.356235
R16210 n1_m1_211200_542400 n1_m1_216000_542400 5.356235
R16211 n1_m1_216000_542400 n1_m1_220800_542400 5.356235
R16212 n1_m1_220800_542400 n1_m1_225600_542400 5.356235
R16213 n1_m1_225600_542400 n1_m1_228000_542400 2.678118
R16214 n1_m1_230400_542400 n1_m1_228000_542400 2.678118
R16215 n1_m1_230400_542400 n1_m1_235200_542400 5.356235
R16216 n1_m1_235200_542400 n1_m1_240000_542400 5.356235
R16217 n1_m1_240000_542400 n1_m1_244800_542400 5.356235
R16218 n1_m1_244800_542400 n1_m1_249600_542400 5.356235
R16219 n1_m1_249600_542400 n1_m1_254400_542400 5.356235
R16220 n1_m1_254400_542400 n1_m1_256000_542400 1.785412
R16221 n1_m1_259200_542400 n1_m1_256000_542400 3.570824
R16222 n1_m1_259200_542400 n1_m1_264000_542400 5.356235
R16223 n1_m1_264000_542400 n1_m1_268800_542400 5.356235
R16224 n1_m1_268800_542400 n1_m1_273600_542400 5.356235
R16225 n1_m1_273600_542400 n1_m1_278400_542400 5.356235
R16226 n1_m1_278400_542400 n1_m1_283200_542400 5.356235
R16227 n1_m1_283200_542400 n1_m1_284000_542400 0.892706
R16228 n1_m1_288000_542400 n1_m1_284000_542400 4.463529
R16229 n1_m1_288000_542400 n1_m1_292800_542400 5.356235
R16230 n1_m1_292800_542400 n1_m1_297600_542400 5.356235
R16231 n1_m1_297600_542400 n1_m1_302400_542400 5.356235
R16232 n1_m1_302400_542400 n1_m1_307200_542400 5.356235
R16233 n1_m1_307200_542400 n1_m1_312000_542400 5.356235
R16234 n1_m1_312000_542400 n1_m1_316800_542400 5.356235
R16235 n1_m1_316800_542400 n1_m1_321600_542400 5.356235
R16236 n1_m1_321600_542400 n1_m1_326400_542400 5.356235
R16237 n1_m1_326400_542400 n1_m1_331200_542400 5.356235
R16238 n1_m1_331200_542400 n1_m1_336000_542400 5.356235
R16239 n1_m1_336000_542400 n1_m1_340000_542400 4.463529
R16240 n1_m1_340800_542400 n1_m1_340000_542400 0.892706
R16241 n1_m1_340800_542400 n1_m1_345600_542400 5.356235
R16242 n1_m1_345600_542400 n1_m1_350400_542400 5.356235
R16243 n1_m1_350400_542400 n1_m1_355200_542400 5.356235
R16244 n1_m1_355200_542400 n1_m1_360000_542400 5.356235
R16245 n1_m1_360000_542400 n1_m1_364800_542400 5.356235
R16246 n1_m1_364800_542400 n1_m1_368000_542400 3.570824
R16247 n1_m1_369600_542400 n1_m1_368000_542400 1.785412
R16248 n1_m1_369600_542400 n1_m1_374400_542400 5.356235
R16249 n1_m1_374400_542400 n1_m1_379200_542400 5.356235
R16250 n1_m1_379200_542400 n1_m1_384000_542400 5.356235
R16251 n1_m1_384000_542400 n1_m1_388800_542400 5.356235
R16252 n1_m1_388800_542400 n1_m1_393600_542400 5.356235
R16253 n1_m1_393600_542400 n1_m1_396000_542400 2.678118
R16254 n1_m1_398400_542400 n1_m1_396000_542400 2.678118
R16255 n1_m1_398400_542400 n1_m1_403200_542400 5.356235
R16256 n1_m1_403200_542400 n1_m1_408000_542400 5.356235
R16257 n1_m1_408000_542400 n1_m1_412800_542400 5.356235
R16258 n1_m1_412800_542400 n1_m1_417600_542400 5.356235
R16259 n1_m1_417600_542400 n1_m1_422400_542400 5.356235
R16260 n1_m1_422400_542400 n1_m1_424000_542400 1.785412
R16261 n1_m1_427200_542400 n1_m1_424000_542400 3.570824
R16262 n1_m1_427200_542400 n1_m1_432000_542400 5.356235
R16263 n1_m1_432000_542400 n1_m1_436800_542400 5.356235
R16264 n1_m1_436800_542400 n1_m1_441600_542400 5.356235
R16265 n1_m1_441600_542400 n1_m1_446400_542400 5.356235
R16266 n1_m1_446400_542400 n1_m1_451200_542400 5.356235
R16267 n1_m1_451200_542400 n1_m1_452000_542400 0.892706
R16268 n1_m1_456000_542400 n1_m1_452000_542400 4.463529
R16269 n1_m1_456000_542400 n1_m1_460800_542400 5.356235
R16270 n1_m1_460800_542400 n1_m1_465600_542400 5.356235
R16271 n1_m1_465600_542400 n1_m1_470400_542400 5.356235
R16272 n1_m1_470400_542400 n1_m1_475200_542400 5.356235
R16273 n1_m1_475200_542400 n1_m1_480000_542400 5.356235
R16274 n1_m1_480000_542400 n1_m1_484800_542400 5.356235
R16275 n1_m1_484800_542400 n1_m1_489600_542400 5.356235
R16276 n1_m1_489600_542400 n1_m1_494400_542400 5.356235
R16277 n1_m1_494400_542400 n1_m1_499200_542400 5.356235
R16278 n1_m1_499200_542400 n1_m1_504000_542400 5.356235
R16279 n1_m1_504000_542400 n1_m1_508000_542400 4.463529
R16280 n1_m1_508800_542400 n1_m1_508000_542400 0.892706
R16281 n1_m1_508800_542400 n1_m1_513600_542400 5.356235
R16282 n1_m1_513600_542400 n1_m1_518400_542400 5.356235
R16283 n1_m1_518400_542400 n1_m1_523200_542400 5.356235
R16284 n1_m1_523200_542400 n1_m1_528000_542400 5.356235
R16285 n1_m1_528000_542400 n1_m1_532800_542400 5.356235
R16286 n1_m1_532800_542400 n1_m1_536000_542400 3.570824
R16287 n1_m1_537600_542400 n1_m1_536000_542400 1.785412
R16288 n1_m1_537600_542400 n1_m1_542400_542400 5.356235
R16289 n1_m1_542400_542400 n1_m1_547200_542400 5.356235
R16290 n1_m1_547200_542400 n1_m1_552000_542400 5.356235
R16291 n1_m1_552000_542400 n1_m1_556800_542400 5.356235
R16292 n1_m1_556800_542400 n1_m1_561600_542400 5.356235
R16293 n1_m1_561600_542400 n1_m1_564000_542400 2.678118
R16294 n1_m1_566400_542400 n1_m1_564000_542400 2.678118
R16295 n1_m1_566400_542400 n1_m1_571200_542400 5.356235
R16296 n1_m1_571200_542400 n1_m1_576000_542400 5.356235
R16297 n1_m1_576000_542400 n1_m1_580800_542400 5.356235
R16298 n1_m1_580800_542400 n1_m1_585600_542400 5.356235
R16299 n1_m1_585600_542400 n1_m1_590400_542400 5.356235
R16300 n1_m1_590400_542400 n1_m1_592000_542400 1.785412
R16301 n1_m1_595200_542400 n1_m1_592000_542400 3.570824
R16302 n1_m1_0_547200 n1_m1_4000_547200 4.463529
R16303 n1_m1_4800_547200 n1_m1_4000_547200 0.892706
R16304 n1_m1_4800_547200 n1_m1_9600_547200 5.356235
R16305 n1_m1_9600_547200 n1_m1_14400_547200 5.356235
R16306 n1_m1_14400_547200 n1_m1_19200_547200 5.356235
R16307 n1_m1_19200_547200 n1_m1_24000_547200 5.356235
R16308 n1_m1_24000_547200 n1_m1_28800_547200 5.356235
R16309 n1_m1_28800_547200 n1_m1_32000_547200 3.570824
R16310 n1_m1_33600_547200 n1_m1_32000_547200 1.785412
R16311 n1_m1_33600_547200 n1_m1_38400_547200 5.356235
R16312 n1_m1_38400_547200 n1_m1_43200_547200 5.356235
R16313 n1_m1_43200_547200 n1_m1_48000_547200 5.356235
R16314 n1_m1_48000_547200 n1_m1_52800_547200 5.356235
R16315 n1_m1_52800_547200 n1_m1_57600_547200 5.356235
R16316 n1_m1_57600_547200 n1_m1_60000_547200 2.678118
R16317 n1_m1_62400_547200 n1_m1_60000_547200 2.678118
R16318 n1_m1_62400_547200 n1_m1_67200_547200 5.356235
R16319 n1_m1_67200_547200 n1_m1_72000_547200 5.356235
R16320 n1_m1_72000_547200 n1_m1_76800_547200 5.356235
R16321 n1_m1_76800_547200 n1_m1_81600_547200 5.356235
R16322 n1_m1_81600_547200 n1_m1_86400_547200 5.356235
R16323 n1_m1_86400_547200 n1_m1_88000_547200 1.785412
R16324 n1_m1_91200_547200 n1_m1_88000_547200 3.570824
R16325 n1_m1_91200_547200 n1_m1_96000_547200 5.356235
R16326 n1_m1_96000_547200 n1_m1_100800_547200 5.356235
R16327 n1_m1_100800_547200 n1_m1_105600_547200 5.356235
R16328 n1_m1_105600_547200 n1_m1_110400_547200 5.356235
R16329 n1_m1_110400_547200 n1_m1_115200_547200 5.356235
R16330 n1_m1_115200_547200 n1_m1_116000_547200 0.892706
R16331 n1_m1_120000_547200 n1_m1_116000_547200 4.463529
R16332 n1_m1_120000_547200 n1_m1_124800_547200 5.356235
R16333 n1_m1_124800_547200 n1_m1_129600_547200 5.356235
R16334 n1_m1_129600_547200 n1_m1_134400_547200 5.356235
R16335 n1_m1_134400_547200 n1_m1_139200_547200 5.356235
R16336 n1_m1_139200_547200 n1_m1_144000_547200 5.356235
R16337 n1_m1_144000_547200 n1_m1_148800_547200 5.356235
R16338 n1_m1_148800_547200 n1_m1_153600_547200 5.356235
R16339 n1_m1_153600_547200 n1_m1_158400_547200 5.356235
R16340 n1_m1_158400_547200 n1_m1_163200_547200 5.356235
R16341 n1_m1_163200_547200 n1_m1_168000_547200 5.356235
R16342 n1_m1_168000_547200 n1_m1_172000_547200 4.463529
R16343 n1_m1_172800_547200 n1_m1_172000_547200 0.892706
R16344 n1_m1_172800_547200 n1_m1_177600_547200 5.356235
R16345 n1_m1_177600_547200 n1_m1_182400_547200 5.356235
R16346 n1_m1_182400_547200 n1_m1_187200_547200 5.356235
R16347 n1_m1_187200_547200 n1_m1_192000_547200 5.356235
R16348 n1_m1_192000_547200 n1_m1_196800_547200 5.356235
R16349 n1_m1_196800_547200 n1_m1_200000_547200 3.570824
R16350 n1_m1_201600_547200 n1_m1_200000_547200 1.785412
R16351 n1_m1_201600_547200 n1_m1_206400_547200 5.356235
R16352 n1_m1_206400_547200 n1_m1_211200_547200 5.356235
R16353 n1_m1_211200_547200 n1_m1_216000_547200 5.356235
R16354 n1_m1_216000_547200 n1_m1_220800_547200 5.356235
R16355 n1_m1_220800_547200 n1_m1_225600_547200 5.356235
R16356 n1_m1_225600_547200 n1_m1_228000_547200 2.678118
R16357 n1_m1_230400_547200 n1_m1_228000_547200 2.678118
R16358 n1_m1_230400_547200 n1_m1_235200_547200 5.356235
R16359 n1_m1_235200_547200 n1_m1_240000_547200 5.356235
R16360 n1_m1_240000_547200 n1_m1_244800_547200 5.356235
R16361 n1_m1_244800_547200 n1_m1_249600_547200 5.356235
R16362 n1_m1_249600_547200 n1_m1_254400_547200 5.356235
R16363 n1_m1_254400_547200 n1_m1_256000_547200 1.785412
R16364 n1_m1_259200_547200 n1_m1_256000_547200 3.570824
R16365 n1_m1_259200_547200 n1_m1_264000_547200 5.356235
R16366 n1_m1_264000_547200 n1_m1_268800_547200 5.356235
R16367 n1_m1_268800_547200 n1_m1_273600_547200 5.356235
R16368 n1_m1_273600_547200 n1_m1_278400_547200 5.356235
R16369 n1_m1_278400_547200 n1_m1_283200_547200 5.356235
R16370 n1_m1_283200_547200 n1_m1_284000_547200 0.892706
R16371 n1_m1_288000_547200 n1_m1_284000_547200 4.463529
R16372 n1_m1_288000_547200 n1_m1_292800_547200 5.356235
R16373 n1_m1_292800_547200 n1_m1_297600_547200 5.356235
R16374 n1_m1_297600_547200 n1_m1_302400_547200 5.356235
R16375 n1_m1_302400_547200 n1_m1_307200_547200 5.356235
R16376 n1_m1_307200_547200 n1_m1_312000_547200 5.356235
R16377 n1_m1_312000_547200 n1_m1_316800_547200 5.356235
R16378 n1_m1_316800_547200 n1_m1_321600_547200 5.356235
R16379 n1_m1_321600_547200 n1_m1_326400_547200 5.356235
R16380 n1_m1_326400_547200 n1_m1_331200_547200 5.356235
R16381 n1_m1_331200_547200 n1_m1_336000_547200 5.356235
R16382 n1_m1_336000_547200 n1_m1_340000_547200 4.463529
R16383 n1_m1_340800_547200 n1_m1_340000_547200 0.892706
R16384 n1_m1_340800_547200 n1_m1_345600_547200 5.356235
R16385 n1_m1_345600_547200 n1_m1_350400_547200 5.356235
R16386 n1_m1_350400_547200 n1_m1_355200_547200 5.356235
R16387 n1_m1_355200_547200 n1_m1_360000_547200 5.356235
R16388 n1_m1_360000_547200 n1_m1_364800_547200 5.356235
R16389 n1_m1_364800_547200 n1_m1_368000_547200 3.570824
R16390 n1_m1_369600_547200 n1_m1_368000_547200 1.785412
R16391 n1_m1_369600_547200 n1_m1_374400_547200 5.356235
R16392 n1_m1_374400_547200 n1_m1_379200_547200 5.356235
R16393 n1_m1_379200_547200 n1_m1_384000_547200 5.356235
R16394 n1_m1_384000_547200 n1_m1_388800_547200 5.356235
R16395 n1_m1_388800_547200 n1_m1_393600_547200 5.356235
R16396 n1_m1_393600_547200 n1_m1_396000_547200 2.678118
R16397 n1_m1_398400_547200 n1_m1_396000_547200 2.678118
R16398 n1_m1_398400_547200 n1_m1_403200_547200 5.356235
R16399 n1_m1_403200_547200 n1_m1_408000_547200 5.356235
R16400 n1_m1_408000_547200 n1_m1_412800_547200 5.356235
R16401 n1_m1_412800_547200 n1_m1_417600_547200 5.356235
R16402 n1_m1_417600_547200 n1_m1_422400_547200 5.356235
R16403 n1_m1_422400_547200 n1_m1_424000_547200 1.785412
R16404 n1_m1_427200_547200 n1_m1_424000_547200 3.570824
R16405 n1_m1_427200_547200 n1_m1_432000_547200 5.356235
R16406 n1_m1_432000_547200 n1_m1_436800_547200 5.356235
R16407 n1_m1_436800_547200 n1_m1_441600_547200 5.356235
R16408 n1_m1_441600_547200 n1_m1_446400_547200 5.356235
R16409 n1_m1_446400_547200 n1_m1_451200_547200 5.356235
R16410 n1_m1_451200_547200 n1_m1_452000_547200 0.892706
R16411 n1_m1_456000_547200 n1_m1_452000_547200 4.463529
R16412 n1_m1_456000_547200 n1_m1_460800_547200 5.356235
R16413 n1_m1_460800_547200 n1_m1_465600_547200 5.356235
R16414 n1_m1_465600_547200 n1_m1_470400_547200 5.356235
R16415 n1_m1_470400_547200 n1_m1_475200_547200 5.356235
R16416 n1_m1_475200_547200 n1_m1_480000_547200 5.356235
R16417 n1_m1_480000_547200 n1_m1_484800_547200 5.356235
R16418 n1_m1_484800_547200 n1_m1_489600_547200 5.356235
R16419 n1_m1_489600_547200 n1_m1_494400_547200 5.356235
R16420 n1_m1_494400_547200 n1_m1_499200_547200 5.356235
R16421 n1_m1_499200_547200 n1_m1_504000_547200 5.356235
R16422 n1_m1_504000_547200 n1_m1_508000_547200 4.463529
R16423 n1_m1_508800_547200 n1_m1_508000_547200 0.892706
R16424 n1_m1_508800_547200 n1_m1_513600_547200 5.356235
R16425 n1_m1_513600_547200 n1_m1_518400_547200 5.356235
R16426 n1_m1_518400_547200 n1_m1_523200_547200 5.356235
R16427 n1_m1_523200_547200 n1_m1_528000_547200 5.356235
R16428 n1_m1_528000_547200 n1_m1_532800_547200 5.356235
R16429 n1_m1_532800_547200 n1_m1_536000_547200 3.570824
R16430 n1_m1_537600_547200 n1_m1_536000_547200 1.785412
R16431 n1_m1_537600_547200 n1_m1_542400_547200 5.356235
R16432 n1_m1_542400_547200 n1_m1_547200_547200 5.356235
R16433 n1_m1_547200_547200 n1_m1_552000_547200 5.356235
R16434 n1_m1_552000_547200 n1_m1_556800_547200 5.356235
R16435 n1_m1_556800_547200 n1_m1_561600_547200 5.356235
R16436 n1_m1_561600_547200 n1_m1_564000_547200 2.678118
R16437 n1_m1_566400_547200 n1_m1_564000_547200 2.678118
R16438 n1_m1_566400_547200 n1_m1_571200_547200 5.356235
R16439 n1_m1_571200_547200 n1_m1_576000_547200 5.356235
R16440 n1_m1_576000_547200 n1_m1_580800_547200 5.356235
R16441 n1_m1_580800_547200 n1_m1_585600_547200 5.356235
R16442 n1_m1_585600_547200 n1_m1_590400_547200 5.356235
R16443 n1_m1_590400_547200 n1_m1_592000_547200 1.785412
R16444 n1_m1_595200_547200 n1_m1_592000_547200 3.570824
R16445 n1_m1_0_552000 n1_m1_4000_552000 4.463529
R16446 n1_m1_4800_552000 n1_m1_4000_552000 0.892706
R16447 n1_m1_4800_552000 n1_m1_9600_552000 5.356235
R16448 n1_m1_9600_552000 n1_m1_14400_552000 5.356235
R16449 n1_m1_14400_552000 n1_m1_19200_552000 5.356235
R16450 n1_m1_19200_552000 n1_m1_24000_552000 5.356235
R16451 n1_m1_24000_552000 n1_m1_28800_552000 5.356235
R16452 n1_m1_28800_552000 n1_m1_32000_552000 3.570824
R16453 n1_m1_33600_552000 n1_m1_32000_552000 1.785412
R16454 n1_m1_33600_552000 n1_m1_38400_552000 5.356235
R16455 n1_m1_38400_552000 n1_m1_43200_552000 5.356235
R16456 n1_m1_43200_552000 n1_m1_48000_552000 5.356235
R16457 n1_m1_48000_552000 n1_m1_52800_552000 5.356235
R16458 n1_m1_52800_552000 n1_m1_57600_552000 5.356235
R16459 n1_m1_57600_552000 n1_m1_60000_552000 2.678118
R16460 n1_m1_62400_552000 n1_m1_60000_552000 2.678118
R16461 n1_m1_62400_552000 n1_m1_67200_552000 5.356235
R16462 n1_m1_67200_552000 n1_m1_72000_552000 5.356235
R16463 n1_m1_72000_552000 n1_m1_76800_552000 5.356235
R16464 n1_m1_76800_552000 n1_m1_81600_552000 5.356235
R16465 n1_m1_81600_552000 n1_m1_86400_552000 5.356235
R16466 n1_m1_86400_552000 n1_m1_88000_552000 1.785412
R16467 n1_m1_91200_552000 n1_m1_88000_552000 3.570824
R16468 n1_m1_91200_552000 n1_m1_96000_552000 5.356235
R16469 n1_m1_96000_552000 n1_m1_100800_552000 5.356235
R16470 n1_m1_100800_552000 n1_m1_105600_552000 5.356235
R16471 n1_m1_105600_552000 n1_m1_110400_552000 5.356235
R16472 n1_m1_110400_552000 n1_m1_115200_552000 5.356235
R16473 n1_m1_115200_552000 n1_m1_116000_552000 0.892706
R16474 n1_m1_120000_552000 n1_m1_116000_552000 4.463529
R16475 n1_m1_120000_552000 n1_m1_124800_552000 5.356235
R16476 n1_m1_124800_552000 n1_m1_129600_552000 5.356235
R16477 n1_m1_129600_552000 n1_m1_134400_552000 5.356235
R16478 n1_m1_134400_552000 n1_m1_139200_552000 5.356235
R16479 n1_m1_139200_552000 n1_m1_144000_552000 5.356235
R16480 n1_m1_144000_552000 n1_m1_148800_552000 5.356235
R16481 n1_m1_148800_552000 n1_m1_153600_552000 5.356235
R16482 n1_m1_153600_552000 n1_m1_158400_552000 5.356235
R16483 n1_m1_158400_552000 n1_m1_163200_552000 5.356235
R16484 n1_m1_163200_552000 n1_m1_168000_552000 5.356235
R16485 n1_m1_168000_552000 n1_m1_172000_552000 4.463529
R16486 n1_m1_172800_552000 n1_m1_172000_552000 0.892706
R16487 n1_m1_172800_552000 n1_m1_177600_552000 5.356235
R16488 n1_m1_177600_552000 n1_m1_182400_552000 5.356235
R16489 n1_m1_182400_552000 n1_m1_187200_552000 5.356235
R16490 n1_m1_187200_552000 n1_m1_192000_552000 5.356235
R16491 n1_m1_192000_552000 n1_m1_196800_552000 5.356235
R16492 n1_m1_196800_552000 n1_m1_200000_552000 3.570824
R16493 n1_m1_201600_552000 n1_m1_200000_552000 1.785412
R16494 n1_m1_201600_552000 n1_m1_206400_552000 5.356235
R16495 n1_m1_206400_552000 n1_m1_211200_552000 5.356235
R16496 n1_m1_211200_552000 n1_m1_216000_552000 5.356235
R16497 n1_m1_216000_552000 n1_m1_220800_552000 5.356235
R16498 n1_m1_220800_552000 n1_m1_225600_552000 5.356235
R16499 n1_m1_225600_552000 n1_m1_228000_552000 2.678118
R16500 n1_m1_230400_552000 n1_m1_228000_552000 2.678118
R16501 n1_m1_230400_552000 n1_m1_235200_552000 5.356235
R16502 n1_m1_235200_552000 n1_m1_240000_552000 5.356235
R16503 n1_m1_240000_552000 n1_m1_244800_552000 5.356235
R16504 n1_m1_244800_552000 n1_m1_249600_552000 5.356235
R16505 n1_m1_249600_552000 n1_m1_254400_552000 5.356235
R16506 n1_m1_254400_552000 n1_m1_256000_552000 1.785412
R16507 n1_m1_259200_552000 n1_m1_256000_552000 3.570824
R16508 n1_m1_259200_552000 n1_m1_264000_552000 5.356235
R16509 n1_m1_264000_552000 n1_m1_268800_552000 5.356235
R16510 n1_m1_268800_552000 n1_m1_273600_552000 5.356235
R16511 n1_m1_273600_552000 n1_m1_278400_552000 5.356235
R16512 n1_m1_278400_552000 n1_m1_283200_552000 5.356235
R16513 n1_m1_283200_552000 n1_m1_284000_552000 0.892706
R16514 n1_m1_288000_552000 n1_m1_284000_552000 4.463529
R16515 n1_m1_288000_552000 n1_m1_292800_552000 5.356235
R16516 n1_m1_292800_552000 n1_m1_297600_552000 5.356235
R16517 n1_m1_297600_552000 n1_m1_302400_552000 5.356235
R16518 n1_m1_302400_552000 n1_m1_307200_552000 5.356235
R16519 n1_m1_307200_552000 n1_m1_312000_552000 5.356235
R16520 n1_m1_312000_552000 n1_m1_316800_552000 5.356235
R16521 n1_m1_316800_552000 n1_m1_321600_552000 5.356235
R16522 n1_m1_321600_552000 n1_m1_326400_552000 5.356235
R16523 n1_m1_326400_552000 n1_m1_331200_552000 5.356235
R16524 n1_m1_331200_552000 n1_m1_336000_552000 5.356235
R16525 n1_m1_336000_552000 n1_m1_340000_552000 4.463529
R16526 n1_m1_340800_552000 n1_m1_340000_552000 0.892706
R16527 n1_m1_340800_552000 n1_m1_345600_552000 5.356235
R16528 n1_m1_345600_552000 n1_m1_350400_552000 5.356235
R16529 n1_m1_350400_552000 n1_m1_355200_552000 5.356235
R16530 n1_m1_355200_552000 n1_m1_360000_552000 5.356235
R16531 n1_m1_360000_552000 n1_m1_364800_552000 5.356235
R16532 n1_m1_364800_552000 n1_m1_368000_552000 3.570824
R16533 n1_m1_369600_552000 n1_m1_368000_552000 1.785412
R16534 n1_m1_369600_552000 n1_m1_374400_552000 5.356235
R16535 n1_m1_374400_552000 n1_m1_379200_552000 5.356235
R16536 n1_m1_379200_552000 n1_m1_384000_552000 5.356235
R16537 n1_m1_384000_552000 n1_m1_388800_552000 5.356235
R16538 n1_m1_388800_552000 n1_m1_393600_552000 5.356235
R16539 n1_m1_393600_552000 n1_m1_396000_552000 2.678118
R16540 n1_m1_398400_552000 n1_m1_396000_552000 2.678118
R16541 n1_m1_398400_552000 n1_m1_403200_552000 5.356235
R16542 n1_m1_403200_552000 n1_m1_408000_552000 5.356235
R16543 n1_m1_408000_552000 n1_m1_412800_552000 5.356235
R16544 n1_m1_412800_552000 n1_m1_417600_552000 5.356235
R16545 n1_m1_417600_552000 n1_m1_422400_552000 5.356235
R16546 n1_m1_422400_552000 n1_m1_424000_552000 1.785412
R16547 n1_m1_427200_552000 n1_m1_424000_552000 3.570824
R16548 n1_m1_427200_552000 n1_m1_432000_552000 5.356235
R16549 n1_m1_432000_552000 n1_m1_436800_552000 5.356235
R16550 n1_m1_436800_552000 n1_m1_441600_552000 5.356235
R16551 n1_m1_441600_552000 n1_m1_446400_552000 5.356235
R16552 n1_m1_446400_552000 n1_m1_451200_552000 5.356235
R16553 n1_m1_451200_552000 n1_m1_452000_552000 0.892706
R16554 n1_m1_456000_552000 n1_m1_452000_552000 4.463529
R16555 n1_m1_456000_552000 n1_m1_460800_552000 5.356235
R16556 n1_m1_460800_552000 n1_m1_465600_552000 5.356235
R16557 n1_m1_465600_552000 n1_m1_470400_552000 5.356235
R16558 n1_m1_470400_552000 n1_m1_475200_552000 5.356235
R16559 n1_m1_475200_552000 n1_m1_480000_552000 5.356235
R16560 n1_m1_480000_552000 n1_m1_484800_552000 5.356235
R16561 n1_m1_484800_552000 n1_m1_489600_552000 5.356235
R16562 n1_m1_489600_552000 n1_m1_494400_552000 5.356235
R16563 n1_m1_494400_552000 n1_m1_499200_552000 5.356235
R16564 n1_m1_499200_552000 n1_m1_504000_552000 5.356235
R16565 n1_m1_504000_552000 n1_m1_508000_552000 4.463529
R16566 n1_m1_508800_552000 n1_m1_508000_552000 0.892706
R16567 n1_m1_508800_552000 n1_m1_513600_552000 5.356235
R16568 n1_m1_513600_552000 n1_m1_518400_552000 5.356235
R16569 n1_m1_518400_552000 n1_m1_523200_552000 5.356235
R16570 n1_m1_523200_552000 n1_m1_528000_552000 5.356235
R16571 n1_m1_528000_552000 n1_m1_532800_552000 5.356235
R16572 n1_m1_532800_552000 n1_m1_536000_552000 3.570824
R16573 n1_m1_537600_552000 n1_m1_536000_552000 1.785412
R16574 n1_m1_537600_552000 n1_m1_542400_552000 5.356235
R16575 n1_m1_542400_552000 n1_m1_547200_552000 5.356235
R16576 n1_m1_547200_552000 n1_m1_552000_552000 5.356235
R16577 n1_m1_552000_552000 n1_m1_556800_552000 5.356235
R16578 n1_m1_556800_552000 n1_m1_561600_552000 5.356235
R16579 n1_m1_561600_552000 n1_m1_564000_552000 2.678118
R16580 n1_m1_566400_552000 n1_m1_564000_552000 2.678118
R16581 n1_m1_566400_552000 n1_m1_571200_552000 5.356235
R16582 n1_m1_571200_552000 n1_m1_576000_552000 5.356235
R16583 n1_m1_576000_552000 n1_m1_580800_552000 5.356235
R16584 n1_m1_580800_552000 n1_m1_585600_552000 5.356235
R16585 n1_m1_585600_552000 n1_m1_590400_552000 5.356235
R16586 n1_m1_590400_552000 n1_m1_592000_552000 1.785412
R16587 n1_m1_595200_552000 n1_m1_592000_552000 3.570824
R16588 n1_m1_0_556800 n1_m1_4000_556800 4.463529
R16589 n1_m1_4800_556800 n1_m1_4000_556800 0.892706
R16590 n1_m1_4800_556800 n1_m1_9600_556800 5.356235
R16591 n1_m1_9600_556800 n1_m1_14400_556800 5.356235
R16592 n1_m1_14400_556800 n1_m1_19200_556800 5.356235
R16593 n1_m1_19200_556800 n1_m1_24000_556800 5.356235
R16594 n1_m1_24000_556800 n1_m1_28800_556800 5.356235
R16595 n1_m1_28800_556800 n1_m1_32000_556800 3.570824
R16596 n1_m1_33600_556800 n1_m1_32000_556800 1.785412
R16597 n1_m1_33600_556800 n1_m1_38400_556800 5.356235
R16598 n1_m1_38400_556800 n1_m1_43200_556800 5.356235
R16599 n1_m1_43200_556800 n1_m1_48000_556800 5.356235
R16600 n1_m1_48000_556800 n1_m1_52800_556800 5.356235
R16601 n1_m1_52800_556800 n1_m1_57600_556800 5.356235
R16602 n1_m1_57600_556800 n1_m1_60000_556800 2.678118
R16603 n1_m1_62400_556800 n1_m1_60000_556800 2.678118
R16604 n1_m1_62400_556800 n1_m1_67200_556800 5.356235
R16605 n1_m1_67200_556800 n1_m1_72000_556800 5.356235
R16606 n1_m1_72000_556800 n1_m1_76800_556800 5.356235
R16607 n1_m1_76800_556800 n1_m1_81600_556800 5.356235
R16608 n1_m1_81600_556800 n1_m1_86400_556800 5.356235
R16609 n1_m1_86400_556800 n1_m1_88000_556800 1.785412
R16610 n1_m1_91200_556800 n1_m1_88000_556800 3.570824
R16611 n1_m1_91200_556800 n1_m1_96000_556800 5.356235
R16612 n1_m1_96000_556800 n1_m1_100800_556800 5.356235
R16613 n1_m1_100800_556800 n1_m1_105600_556800 5.356235
R16614 n1_m1_105600_556800 n1_m1_110400_556800 5.356235
R16615 n1_m1_110400_556800 n1_m1_115200_556800 5.356235
R16616 n1_m1_115200_556800 n1_m1_116000_556800 0.892706
R16617 n1_m1_120000_556800 n1_m1_116000_556800 4.463529
R16618 n1_m1_120000_556800 n1_m1_124800_556800 5.356235
R16619 n1_m1_124800_556800 n1_m1_129600_556800 5.356235
R16620 n1_m1_129600_556800 n1_m1_134400_556800 5.356235
R16621 n1_m1_134400_556800 n1_m1_139200_556800 5.356235
R16622 n1_m1_139200_556800 n1_m1_144000_556800 5.356235
R16623 n1_m1_144000_556800 n1_m1_148800_556800 5.356235
R16624 n1_m1_148800_556800 n1_m1_153600_556800 5.356235
R16625 n1_m1_153600_556800 n1_m1_158400_556800 5.356235
R16626 n1_m1_158400_556800 n1_m1_163200_556800 5.356235
R16627 n1_m1_163200_556800 n1_m1_168000_556800 5.356235
R16628 n1_m1_168000_556800 n1_m1_172000_556800 4.463529
R16629 n1_m1_172800_556800 n1_m1_172000_556800 0.892706
R16630 n1_m1_172800_556800 n1_m1_177600_556800 5.356235
R16631 n1_m1_177600_556800 n1_m1_182400_556800 5.356235
R16632 n1_m1_182400_556800 n1_m1_187200_556800 5.356235
R16633 n1_m1_187200_556800 n1_m1_192000_556800 5.356235
R16634 n1_m1_192000_556800 n1_m1_196800_556800 5.356235
R16635 n1_m1_196800_556800 n1_m1_200000_556800 3.570824
R16636 n1_m1_201600_556800 n1_m1_200000_556800 1.785412
R16637 n1_m1_201600_556800 n1_m1_206400_556800 5.356235
R16638 n1_m1_206400_556800 n1_m1_211200_556800 5.356235
R16639 n1_m1_211200_556800 n1_m1_216000_556800 5.356235
R16640 n1_m1_216000_556800 n1_m1_220800_556800 5.356235
R16641 n1_m1_220800_556800 n1_m1_225600_556800 5.356235
R16642 n1_m1_225600_556800 n1_m1_228000_556800 2.678118
R16643 n1_m1_230400_556800 n1_m1_228000_556800 2.678118
R16644 n1_m1_230400_556800 n1_m1_235200_556800 5.356235
R16645 n1_m1_235200_556800 n1_m1_240000_556800 5.356235
R16646 n1_m1_240000_556800 n1_m1_244800_556800 5.356235
R16647 n1_m1_244800_556800 n1_m1_249600_556800 5.356235
R16648 n1_m1_249600_556800 n1_m1_254400_556800 5.356235
R16649 n1_m1_254400_556800 n1_m1_256000_556800 1.785412
R16650 n1_m1_259200_556800 n1_m1_256000_556800 3.570824
R16651 n1_m1_259200_556800 n1_m1_264000_556800 5.356235
R16652 n1_m1_264000_556800 n1_m1_268800_556800 5.356235
R16653 n1_m1_268800_556800 n1_m1_273600_556800 5.356235
R16654 n1_m1_273600_556800 n1_m1_278400_556800 5.356235
R16655 n1_m1_278400_556800 n1_m1_283200_556800 5.356235
R16656 n1_m1_283200_556800 n1_m1_284000_556800 0.892706
R16657 n1_m1_288000_556800 n1_m1_284000_556800 4.463529
R16658 n1_m1_288000_556800 n1_m1_292800_556800 5.356235
R16659 n1_m1_292800_556800 n1_m1_297600_556800 5.356235
R16660 n1_m1_297600_556800 n1_m1_302400_556800 5.356235
R16661 n1_m1_302400_556800 n1_m1_307200_556800 5.356235
R16662 n1_m1_307200_556800 n1_m1_312000_556800 5.356235
R16663 n1_m1_312000_556800 n1_m1_316800_556800 5.356235
R16664 n1_m1_316800_556800 n1_m1_321600_556800 5.356235
R16665 n1_m1_321600_556800 n1_m1_326400_556800 5.356235
R16666 n1_m1_326400_556800 n1_m1_331200_556800 5.356235
R16667 n1_m1_331200_556800 n1_m1_336000_556800 5.356235
R16668 n1_m1_336000_556800 n1_m1_340000_556800 4.463529
R16669 n1_m1_340800_556800 n1_m1_340000_556800 0.892706
R16670 n1_m1_340800_556800 n1_m1_345600_556800 5.356235
R16671 n1_m1_345600_556800 n1_m1_350400_556800 5.356235
R16672 n1_m1_350400_556800 n1_m1_355200_556800 5.356235
R16673 n1_m1_355200_556800 n1_m1_360000_556800 5.356235
R16674 n1_m1_360000_556800 n1_m1_364800_556800 5.356235
R16675 n1_m1_364800_556800 n1_m1_368000_556800 3.570824
R16676 n1_m1_369600_556800 n1_m1_368000_556800 1.785412
R16677 n1_m1_369600_556800 n1_m1_374400_556800 5.356235
R16678 n1_m1_374400_556800 n1_m1_379200_556800 5.356235
R16679 n1_m1_379200_556800 n1_m1_384000_556800 5.356235
R16680 n1_m1_384000_556800 n1_m1_388800_556800 5.356235
R16681 n1_m1_388800_556800 n1_m1_393600_556800 5.356235
R16682 n1_m1_393600_556800 n1_m1_396000_556800 2.678118
R16683 n1_m1_398400_556800 n1_m1_396000_556800 2.678118
R16684 n1_m1_398400_556800 n1_m1_403200_556800 5.356235
R16685 n1_m1_403200_556800 n1_m1_408000_556800 5.356235
R16686 n1_m1_408000_556800 n1_m1_412800_556800 5.356235
R16687 n1_m1_412800_556800 n1_m1_417600_556800 5.356235
R16688 n1_m1_417600_556800 n1_m1_422400_556800 5.356235
R16689 n1_m1_422400_556800 n1_m1_424000_556800 1.785412
R16690 n1_m1_427200_556800 n1_m1_424000_556800 3.570824
R16691 n1_m1_427200_556800 n1_m1_432000_556800 5.356235
R16692 n1_m1_432000_556800 n1_m1_436800_556800 5.356235
R16693 n1_m1_436800_556800 n1_m1_441600_556800 5.356235
R16694 n1_m1_441600_556800 n1_m1_446400_556800 5.356235
R16695 n1_m1_446400_556800 n1_m1_451200_556800 5.356235
R16696 n1_m1_451200_556800 n1_m1_452000_556800 0.892706
R16697 n1_m1_456000_556800 n1_m1_452000_556800 4.463529
R16698 n1_m1_456000_556800 n1_m1_460800_556800 5.356235
R16699 n1_m1_460800_556800 n1_m1_465600_556800 5.356235
R16700 n1_m1_465600_556800 n1_m1_470400_556800 5.356235
R16701 n1_m1_470400_556800 n1_m1_475200_556800 5.356235
R16702 n1_m1_475200_556800 n1_m1_480000_556800 5.356235
R16703 n1_m1_480000_556800 n1_m1_484800_556800 5.356235
R16704 n1_m1_484800_556800 n1_m1_489600_556800 5.356235
R16705 n1_m1_489600_556800 n1_m1_494400_556800 5.356235
R16706 n1_m1_494400_556800 n1_m1_499200_556800 5.356235
R16707 n1_m1_499200_556800 n1_m1_504000_556800 5.356235
R16708 n1_m1_504000_556800 n1_m1_508000_556800 4.463529
R16709 n1_m1_508800_556800 n1_m1_508000_556800 0.892706
R16710 n1_m1_508800_556800 n1_m1_513600_556800 5.356235
R16711 n1_m1_513600_556800 n1_m1_518400_556800 5.356235
R16712 n1_m1_518400_556800 n1_m1_523200_556800 5.356235
R16713 n1_m1_523200_556800 n1_m1_528000_556800 5.356235
R16714 n1_m1_528000_556800 n1_m1_532800_556800 5.356235
R16715 n1_m1_532800_556800 n1_m1_536000_556800 3.570824
R16716 n1_m1_537600_556800 n1_m1_536000_556800 1.785412
R16717 n1_m1_537600_556800 n1_m1_542400_556800 5.356235
R16718 n1_m1_542400_556800 n1_m1_547200_556800 5.356235
R16719 n1_m1_547200_556800 n1_m1_552000_556800 5.356235
R16720 n1_m1_552000_556800 n1_m1_556800_556800 5.356235
R16721 n1_m1_556800_556800 n1_m1_561600_556800 5.356235
R16722 n1_m1_561600_556800 n1_m1_564000_556800 2.678118
R16723 n1_m1_566400_556800 n1_m1_564000_556800 2.678118
R16724 n1_m1_566400_556800 n1_m1_571200_556800 5.356235
R16725 n1_m1_571200_556800 n1_m1_576000_556800 5.356235
R16726 n1_m1_576000_556800 n1_m1_580800_556800 5.356235
R16727 n1_m1_580800_556800 n1_m1_585600_556800 5.356235
R16728 n1_m1_585600_556800 n1_m1_590400_556800 5.356235
R16729 n1_m1_590400_556800 n1_m1_592000_556800 1.785412
R16730 n1_m1_595200_556800 n1_m1_592000_556800 3.570824
R16731 n1_m1_0_561600 n1_m1_4000_561600 4.463529
R16732 n1_m1_4800_561600 n1_m1_4000_561600 0.892706
R16733 n1_m1_4800_561600 n1_m1_9600_561600 5.356235
R16734 n1_m1_9600_561600 n1_m1_14400_561600 5.356235
R16735 n1_m1_14400_561600 n1_m1_19200_561600 5.356235
R16736 n1_m1_19200_561600 n1_m1_24000_561600 5.356235
R16737 n1_m1_24000_561600 n1_m1_28800_561600 5.356235
R16738 n1_m1_28800_561600 n1_m1_32000_561600 3.570824
R16739 n1_m1_33600_561600 n1_m1_32000_561600 1.785412
R16740 n1_m1_33600_561600 n1_m1_38400_561600 5.356235
R16741 n1_m1_38400_561600 n1_m1_43200_561600 5.356235
R16742 n1_m1_43200_561600 n1_m1_48000_561600 5.356235
R16743 n1_m1_48000_561600 n1_m1_52800_561600 5.356235
R16744 n1_m1_52800_561600 n1_m1_57600_561600 5.356235
R16745 n1_m1_57600_561600 n1_m1_60000_561600 2.678118
R16746 n1_m1_62400_561600 n1_m1_60000_561600 2.678118
R16747 n1_m1_62400_561600 n1_m1_67200_561600 5.356235
R16748 n1_m1_67200_561600 n1_m1_72000_561600 5.356235
R16749 n1_m1_72000_561600 n1_m1_76800_561600 5.356235
R16750 n1_m1_76800_561600 n1_m1_81600_561600 5.356235
R16751 n1_m1_81600_561600 n1_m1_86400_561600 5.356235
R16752 n1_m1_86400_561600 n1_m1_88000_561600 1.785412
R16753 n1_m1_91200_561600 n1_m1_88000_561600 3.570824
R16754 n1_m1_91200_561600 n1_m1_96000_561600 5.356235
R16755 n1_m1_96000_561600 n1_m1_100800_561600 5.356235
R16756 n1_m1_100800_561600 n1_m1_105600_561600 5.356235
R16757 n1_m1_105600_561600 n1_m1_110400_561600 5.356235
R16758 n1_m1_110400_561600 n1_m1_115200_561600 5.356235
R16759 n1_m1_115200_561600 n1_m1_116000_561600 0.892706
R16760 n1_m1_120000_561600 n1_m1_116000_561600 4.463529
R16761 n1_m1_120000_561600 n1_m1_124800_561600 5.356235
R16762 n1_m1_124800_561600 n1_m1_129600_561600 5.356235
R16763 n1_m1_129600_561600 n1_m1_134400_561600 5.356235
R16764 n1_m1_134400_561600 n1_m1_139200_561600 5.356235
R16765 n1_m1_139200_561600 n1_m1_144000_561600 5.356235
R16766 n1_m1_144000_561600 n1_m1_148800_561600 5.356235
R16767 n1_m1_148800_561600 n1_m1_153600_561600 5.356235
R16768 n1_m1_153600_561600 n1_m1_158400_561600 5.356235
R16769 n1_m1_158400_561600 n1_m1_163200_561600 5.356235
R16770 n1_m1_163200_561600 n1_m1_168000_561600 5.356235
R16771 n1_m1_168000_561600 n1_m1_172000_561600 4.463529
R16772 n1_m1_172800_561600 n1_m1_172000_561600 0.892706
R16773 n1_m1_172800_561600 n1_m1_177600_561600 5.356235
R16774 n1_m1_177600_561600 n1_m1_182400_561600 5.356235
R16775 n1_m1_182400_561600 n1_m1_187200_561600 5.356235
R16776 n1_m1_187200_561600 n1_m1_192000_561600 5.356235
R16777 n1_m1_192000_561600 n1_m1_196800_561600 5.356235
R16778 n1_m1_196800_561600 n1_m1_200000_561600 3.570824
R16779 n1_m1_201600_561600 n1_m1_200000_561600 1.785412
R16780 n1_m1_201600_561600 n1_m1_206400_561600 5.356235
R16781 n1_m1_206400_561600 n1_m1_211200_561600 5.356235
R16782 n1_m1_211200_561600 n1_m1_216000_561600 5.356235
R16783 n1_m1_216000_561600 n1_m1_220800_561600 5.356235
R16784 n1_m1_220800_561600 n1_m1_225600_561600 5.356235
R16785 n1_m1_225600_561600 n1_m1_228000_561600 2.678118
R16786 n1_m1_230400_561600 n1_m1_228000_561600 2.678118
R16787 n1_m1_230400_561600 n1_m1_235200_561600 5.356235
R16788 n1_m1_235200_561600 n1_m1_240000_561600 5.356235
R16789 n1_m1_240000_561600 n1_m1_244800_561600 5.356235
R16790 n1_m1_244800_561600 n1_m1_249600_561600 5.356235
R16791 n1_m1_249600_561600 n1_m1_254400_561600 5.356235
R16792 n1_m1_254400_561600 n1_m1_256000_561600 1.785412
R16793 n1_m1_259200_561600 n1_m1_256000_561600 3.570824
R16794 n1_m1_259200_561600 n1_m1_264000_561600 5.356235
R16795 n1_m1_264000_561600 n1_m1_268800_561600 5.356235
R16796 n1_m1_268800_561600 n1_m1_273600_561600 5.356235
R16797 n1_m1_273600_561600 n1_m1_278400_561600 5.356235
R16798 n1_m1_278400_561600 n1_m1_283200_561600 5.356235
R16799 n1_m1_283200_561600 n1_m1_284000_561600 0.892706
R16800 n1_m1_288000_561600 n1_m1_284000_561600 4.463529
R16801 n1_m1_288000_561600 n1_m1_292800_561600 5.356235
R16802 n1_m1_292800_561600 n1_m1_297600_561600 5.356235
R16803 n1_m1_297600_561600 n1_m1_302400_561600 5.356235
R16804 n1_m1_302400_561600 n1_m1_307200_561600 5.356235
R16805 n1_m1_307200_561600 n1_m1_312000_561600 5.356235
R16806 n1_m1_312000_561600 n1_m1_316800_561600 5.356235
R16807 n1_m1_316800_561600 n1_m1_321600_561600 5.356235
R16808 n1_m1_321600_561600 n1_m1_326400_561600 5.356235
R16809 n1_m1_326400_561600 n1_m1_331200_561600 5.356235
R16810 n1_m1_331200_561600 n1_m1_336000_561600 5.356235
R16811 n1_m1_336000_561600 n1_m1_340000_561600 4.463529
R16812 n1_m1_340800_561600 n1_m1_340000_561600 0.892706
R16813 n1_m1_340800_561600 n1_m1_345600_561600 5.356235
R16814 n1_m1_345600_561600 n1_m1_350400_561600 5.356235
R16815 n1_m1_350400_561600 n1_m1_355200_561600 5.356235
R16816 n1_m1_355200_561600 n1_m1_360000_561600 5.356235
R16817 n1_m1_360000_561600 n1_m1_364800_561600 5.356235
R16818 n1_m1_364800_561600 n1_m1_368000_561600 3.570824
R16819 n1_m1_369600_561600 n1_m1_368000_561600 1.785412
R16820 n1_m1_369600_561600 n1_m1_374400_561600 5.356235
R16821 n1_m1_374400_561600 n1_m1_379200_561600 5.356235
R16822 n1_m1_379200_561600 n1_m1_384000_561600 5.356235
R16823 n1_m1_384000_561600 n1_m1_388800_561600 5.356235
R16824 n1_m1_388800_561600 n1_m1_393600_561600 5.356235
R16825 n1_m1_393600_561600 n1_m1_396000_561600 2.678118
R16826 n1_m1_398400_561600 n1_m1_396000_561600 2.678118
R16827 n1_m1_398400_561600 n1_m1_403200_561600 5.356235
R16828 n1_m1_403200_561600 n1_m1_408000_561600 5.356235
R16829 n1_m1_408000_561600 n1_m1_412800_561600 5.356235
R16830 n1_m1_412800_561600 n1_m1_417600_561600 5.356235
R16831 n1_m1_417600_561600 n1_m1_422400_561600 5.356235
R16832 n1_m1_422400_561600 n1_m1_424000_561600 1.785412
R16833 n1_m1_427200_561600 n1_m1_424000_561600 3.570824
R16834 n1_m1_427200_561600 n1_m1_432000_561600 5.356235
R16835 n1_m1_432000_561600 n1_m1_436800_561600 5.356235
R16836 n1_m1_436800_561600 n1_m1_441600_561600 5.356235
R16837 n1_m1_441600_561600 n1_m1_446400_561600 5.356235
R16838 n1_m1_446400_561600 n1_m1_451200_561600 5.356235
R16839 n1_m1_451200_561600 n1_m1_452000_561600 0.892706
R16840 n1_m1_456000_561600 n1_m1_452000_561600 4.463529
R16841 n1_m1_456000_561600 n1_m1_460800_561600 5.356235
R16842 n1_m1_460800_561600 n1_m1_465600_561600 5.356235
R16843 n1_m1_465600_561600 n1_m1_470400_561600 5.356235
R16844 n1_m1_470400_561600 n1_m1_475200_561600 5.356235
R16845 n1_m1_475200_561600 n1_m1_480000_561600 5.356235
R16846 n1_m1_480000_561600 n1_m1_484800_561600 5.356235
R16847 n1_m1_484800_561600 n1_m1_489600_561600 5.356235
R16848 n1_m1_489600_561600 n1_m1_494400_561600 5.356235
R16849 n1_m1_494400_561600 n1_m1_499200_561600 5.356235
R16850 n1_m1_499200_561600 n1_m1_504000_561600 5.356235
R16851 n1_m1_504000_561600 n1_m1_508000_561600 4.463529
R16852 n1_m1_508800_561600 n1_m1_508000_561600 0.892706
R16853 n1_m1_508800_561600 n1_m1_513600_561600 5.356235
R16854 n1_m1_513600_561600 n1_m1_518400_561600 5.356235
R16855 n1_m1_518400_561600 n1_m1_523200_561600 5.356235
R16856 n1_m1_523200_561600 n1_m1_528000_561600 5.356235
R16857 n1_m1_528000_561600 n1_m1_532800_561600 5.356235
R16858 n1_m1_532800_561600 n1_m1_536000_561600 3.570824
R16859 n1_m1_537600_561600 n1_m1_536000_561600 1.785412
R16860 n1_m1_537600_561600 n1_m1_542400_561600 5.356235
R16861 n1_m1_542400_561600 n1_m1_547200_561600 5.356235
R16862 n1_m1_547200_561600 n1_m1_552000_561600 5.356235
R16863 n1_m1_552000_561600 n1_m1_556800_561600 5.356235
R16864 n1_m1_556800_561600 n1_m1_561600_561600 5.356235
R16865 n1_m1_561600_561600 n1_m1_564000_561600 2.678118
R16866 n1_m1_566400_561600 n1_m1_564000_561600 2.678118
R16867 n1_m1_566400_561600 n1_m1_571200_561600 5.356235
R16868 n1_m1_571200_561600 n1_m1_576000_561600 5.356235
R16869 n1_m1_576000_561600 n1_m1_580800_561600 5.356235
R16870 n1_m1_580800_561600 n1_m1_585600_561600 5.356235
R16871 n1_m1_585600_561600 n1_m1_590400_561600 5.356235
R16872 n1_m1_590400_561600 n1_m1_592000_561600 1.785412
R16873 n1_m1_595200_561600 n1_m1_592000_561600 3.570824
R16874 n1_m1_0_566400 n1_m1_4000_566400 4.463529
R16875 n1_m1_4800_566400 n1_m1_4000_566400 0.892706
R16876 n1_m1_4800_566400 n1_m1_9600_566400 5.356235
R16877 n1_m1_9600_566400 n1_m1_14400_566400 5.356235
R16878 n1_m1_14400_566400 n1_m1_19200_566400 5.356235
R16879 n1_m1_19200_566400 n1_m1_24000_566400 5.356235
R16880 n1_m1_24000_566400 n1_m1_28800_566400 5.356235
R16881 n1_m1_28800_566400 n1_m1_32000_566400 3.570824
R16882 n1_m1_33600_566400 n1_m1_32000_566400 1.785412
R16883 n1_m1_33600_566400 n1_m1_38400_566400 5.356235
R16884 n1_m1_38400_566400 n1_m1_43200_566400 5.356235
R16885 n1_m1_43200_566400 n1_m1_48000_566400 5.356235
R16886 n1_m1_48000_566400 n1_m1_52800_566400 5.356235
R16887 n1_m1_52800_566400 n1_m1_57600_566400 5.356235
R16888 n1_m1_57600_566400 n1_m1_60000_566400 2.678118
R16889 n1_m1_62400_566400 n1_m1_60000_566400 2.678118
R16890 n1_m1_62400_566400 n1_m1_67200_566400 5.356235
R16891 n1_m1_67200_566400 n1_m1_72000_566400 5.356235
R16892 n1_m1_72000_566400 n1_m1_76800_566400 5.356235
R16893 n1_m1_76800_566400 n1_m1_81600_566400 5.356235
R16894 n1_m1_81600_566400 n1_m1_86400_566400 5.356235
R16895 n1_m1_86400_566400 n1_m1_88000_566400 1.785412
R16896 n1_m1_91200_566400 n1_m1_88000_566400 3.570824
R16897 n1_m1_91200_566400 n1_m1_96000_566400 5.356235
R16898 n1_m1_96000_566400 n1_m1_100800_566400 5.356235
R16899 n1_m1_100800_566400 n1_m1_105600_566400 5.356235
R16900 n1_m1_105600_566400 n1_m1_110400_566400 5.356235
R16901 n1_m1_110400_566400 n1_m1_115200_566400 5.356235
R16902 n1_m1_115200_566400 n1_m1_116000_566400 0.892706
R16903 n1_m1_120000_566400 n1_m1_116000_566400 4.463529
R16904 n1_m1_120000_566400 n1_m1_124800_566400 5.356235
R16905 n1_m1_124800_566400 n1_m1_129600_566400 5.356235
R16906 n1_m1_129600_566400 n1_m1_134400_566400 5.356235
R16907 n1_m1_134400_566400 n1_m1_139200_566400 5.356235
R16908 n1_m1_139200_566400 n1_m1_144000_566400 5.356235
R16909 n1_m1_144000_566400 n1_m1_148800_566400 5.356235
R16910 n1_m1_148800_566400 n1_m1_153600_566400 5.356235
R16911 n1_m1_153600_566400 n1_m1_158400_566400 5.356235
R16912 n1_m1_158400_566400 n1_m1_163200_566400 5.356235
R16913 n1_m1_163200_566400 n1_m1_168000_566400 5.356235
R16914 n1_m1_168000_566400 n1_m1_172000_566400 4.463529
R16915 n1_m1_172800_566400 n1_m1_172000_566400 0.892706
R16916 n1_m1_172800_566400 n1_m1_177600_566400 5.356235
R16917 n1_m1_177600_566400 n1_m1_182400_566400 5.356235
R16918 n1_m1_182400_566400 n1_m1_187200_566400 5.356235
R16919 n1_m1_187200_566400 n1_m1_192000_566400 5.356235
R16920 n1_m1_192000_566400 n1_m1_196800_566400 5.356235
R16921 n1_m1_196800_566400 n1_m1_200000_566400 3.570824
R16922 n1_m1_201600_566400 n1_m1_200000_566400 1.785412
R16923 n1_m1_201600_566400 n1_m1_206400_566400 5.356235
R16924 n1_m1_206400_566400 n1_m1_211200_566400 5.356235
R16925 n1_m1_211200_566400 n1_m1_216000_566400 5.356235
R16926 n1_m1_216000_566400 n1_m1_220800_566400 5.356235
R16927 n1_m1_220800_566400 n1_m1_225600_566400 5.356235
R16928 n1_m1_225600_566400 n1_m1_228000_566400 2.678118
R16929 n1_m1_230400_566400 n1_m1_228000_566400 2.678118
R16930 n1_m1_230400_566400 n1_m1_235200_566400 5.356235
R16931 n1_m1_235200_566400 n1_m1_240000_566400 5.356235
R16932 n1_m1_240000_566400 n1_m1_244800_566400 5.356235
R16933 n1_m1_244800_566400 n1_m1_249600_566400 5.356235
R16934 n1_m1_249600_566400 n1_m1_254400_566400 5.356235
R16935 n1_m1_254400_566400 n1_m1_256000_566400 1.785412
R16936 n1_m1_259200_566400 n1_m1_256000_566400 3.570824
R16937 n1_m1_259200_566400 n1_m1_264000_566400 5.356235
R16938 n1_m1_264000_566400 n1_m1_268800_566400 5.356235
R16939 n1_m1_268800_566400 n1_m1_273600_566400 5.356235
R16940 n1_m1_273600_566400 n1_m1_278400_566400 5.356235
R16941 n1_m1_278400_566400 n1_m1_283200_566400 5.356235
R16942 n1_m1_283200_566400 n1_m1_284000_566400 0.892706
R16943 n1_m1_288000_566400 n1_m1_284000_566400 4.463529
R16944 n1_m1_288000_566400 n1_m1_292800_566400 5.356235
R16945 n1_m1_292800_566400 n1_m1_297600_566400 5.356235
R16946 n1_m1_297600_566400 n1_m1_302400_566400 5.356235
R16947 n1_m1_302400_566400 n1_m1_307200_566400 5.356235
R16948 n1_m1_307200_566400 n1_m1_312000_566400 5.356235
R16949 n1_m1_312000_566400 n1_m1_316800_566400 5.356235
R16950 n1_m1_316800_566400 n1_m1_321600_566400 5.356235
R16951 n1_m1_321600_566400 n1_m1_326400_566400 5.356235
R16952 n1_m1_326400_566400 n1_m1_331200_566400 5.356235
R16953 n1_m1_331200_566400 n1_m1_336000_566400 5.356235
R16954 n1_m1_336000_566400 n1_m1_340000_566400 4.463529
R16955 n1_m1_340800_566400 n1_m1_340000_566400 0.892706
R16956 n1_m1_340800_566400 n1_m1_345600_566400 5.356235
R16957 n1_m1_345600_566400 n1_m1_350400_566400 5.356235
R16958 n1_m1_350400_566400 n1_m1_355200_566400 5.356235
R16959 n1_m1_355200_566400 n1_m1_360000_566400 5.356235
R16960 n1_m1_360000_566400 n1_m1_364800_566400 5.356235
R16961 n1_m1_364800_566400 n1_m1_368000_566400 3.570824
R16962 n1_m1_369600_566400 n1_m1_368000_566400 1.785412
R16963 n1_m1_369600_566400 n1_m1_374400_566400 5.356235
R16964 n1_m1_374400_566400 n1_m1_379200_566400 5.356235
R16965 n1_m1_379200_566400 n1_m1_384000_566400 5.356235
R16966 n1_m1_384000_566400 n1_m1_388800_566400 5.356235
R16967 n1_m1_388800_566400 n1_m1_393600_566400 5.356235
R16968 n1_m1_393600_566400 n1_m1_396000_566400 2.678118
R16969 n1_m1_398400_566400 n1_m1_396000_566400 2.678118
R16970 n1_m1_398400_566400 n1_m1_403200_566400 5.356235
R16971 n1_m1_403200_566400 n1_m1_408000_566400 5.356235
R16972 n1_m1_408000_566400 n1_m1_412800_566400 5.356235
R16973 n1_m1_412800_566400 n1_m1_417600_566400 5.356235
R16974 n1_m1_417600_566400 n1_m1_422400_566400 5.356235
R16975 n1_m1_422400_566400 n1_m1_424000_566400 1.785412
R16976 n1_m1_427200_566400 n1_m1_424000_566400 3.570824
R16977 n1_m1_427200_566400 n1_m1_432000_566400 5.356235
R16978 n1_m1_432000_566400 n1_m1_436800_566400 5.356235
R16979 n1_m1_436800_566400 n1_m1_441600_566400 5.356235
R16980 n1_m1_441600_566400 n1_m1_446400_566400 5.356235
R16981 n1_m1_446400_566400 n1_m1_451200_566400 5.356235
R16982 n1_m1_451200_566400 n1_m1_452000_566400 0.892706
R16983 n1_m1_456000_566400 n1_m1_452000_566400 4.463529
R16984 n1_m1_456000_566400 n1_m1_460800_566400 5.356235
R16985 n1_m1_460800_566400 n1_m1_465600_566400 5.356235
R16986 n1_m1_465600_566400 n1_m1_470400_566400 5.356235
R16987 n1_m1_470400_566400 n1_m1_475200_566400 5.356235
R16988 n1_m1_475200_566400 n1_m1_480000_566400 5.356235
R16989 n1_m1_480000_566400 n1_m1_484800_566400 5.356235
R16990 n1_m1_484800_566400 n1_m1_489600_566400 5.356235
R16991 n1_m1_489600_566400 n1_m1_494400_566400 5.356235
R16992 n1_m1_494400_566400 n1_m1_499200_566400 5.356235
R16993 n1_m1_499200_566400 n1_m1_504000_566400 5.356235
R16994 n1_m1_504000_566400 n1_m1_508000_566400 4.463529
R16995 n1_m1_508800_566400 n1_m1_508000_566400 0.892706
R16996 n1_m1_508800_566400 n1_m1_513600_566400 5.356235
R16997 n1_m1_513600_566400 n1_m1_518400_566400 5.356235
R16998 n1_m1_518400_566400 n1_m1_523200_566400 5.356235
R16999 n1_m1_523200_566400 n1_m1_528000_566400 5.356235
R17000 n1_m1_528000_566400 n1_m1_532800_566400 5.356235
R17001 n1_m1_532800_566400 n1_m1_536000_566400 3.570824
R17002 n1_m1_537600_566400 n1_m1_536000_566400 1.785412
R17003 n1_m1_537600_566400 n1_m1_542400_566400 5.356235
R17004 n1_m1_542400_566400 n1_m1_547200_566400 5.356235
R17005 n1_m1_547200_566400 n1_m1_552000_566400 5.356235
R17006 n1_m1_552000_566400 n1_m1_556800_566400 5.356235
R17007 n1_m1_556800_566400 n1_m1_561600_566400 5.356235
R17008 n1_m1_561600_566400 n1_m1_564000_566400 2.678118
R17009 n1_m1_566400_566400 n1_m1_564000_566400 2.678118
R17010 n1_m1_566400_566400 n1_m1_571200_566400 5.356235
R17011 n1_m1_571200_566400 n1_m1_576000_566400 5.356235
R17012 n1_m1_576000_566400 n1_m1_580800_566400 5.356235
R17013 n1_m1_580800_566400 n1_m1_585600_566400 5.356235
R17014 n1_m1_585600_566400 n1_m1_590400_566400 5.356235
R17015 n1_m1_590400_566400 n1_m1_592000_566400 1.785412
R17016 n1_m1_595200_566400 n1_m1_592000_566400 3.570824
R17017 n1_m1_0_571200 n1_m1_4000_571200 4.463529
R17018 n1_m1_4800_571200 n1_m1_4000_571200 0.892706
R17019 n1_m1_4800_571200 n1_m1_9600_571200 5.356235
R17020 n1_m1_9600_571200 n1_m1_14400_571200 5.356235
R17021 n1_m1_14400_571200 n1_m1_19200_571200 5.356235
R17022 n1_m1_19200_571200 n1_m1_24000_571200 5.356235
R17023 n1_m1_24000_571200 n1_m1_28800_571200 5.356235
R17024 n1_m1_28800_571200 n1_m1_32000_571200 3.570824
R17025 n1_m1_33600_571200 n1_m1_32000_571200 1.785412
R17026 n1_m1_33600_571200 n1_m1_38400_571200 5.356235
R17027 n1_m1_38400_571200 n1_m1_43200_571200 5.356235
R17028 n1_m1_43200_571200 n1_m1_48000_571200 5.356235
R17029 n1_m1_48000_571200 n1_m1_52800_571200 5.356235
R17030 n1_m1_52800_571200 n1_m1_57600_571200 5.356235
R17031 n1_m1_57600_571200 n1_m1_60000_571200 2.678118
R17032 n1_m1_62400_571200 n1_m1_60000_571200 2.678118
R17033 n1_m1_62400_571200 n1_m1_67200_571200 5.356235
R17034 n1_m1_67200_571200 n1_m1_72000_571200 5.356235
R17035 n1_m1_72000_571200 n1_m1_76800_571200 5.356235
R17036 n1_m1_76800_571200 n1_m1_81600_571200 5.356235
R17037 n1_m1_81600_571200 n1_m1_86400_571200 5.356235
R17038 n1_m1_86400_571200 n1_m1_88000_571200 1.785412
R17039 n1_m1_91200_571200 n1_m1_88000_571200 3.570824
R17040 n1_m1_91200_571200 n1_m1_96000_571200 5.356235
R17041 n1_m1_96000_571200 n1_m1_100800_571200 5.356235
R17042 n1_m1_100800_571200 n1_m1_105600_571200 5.356235
R17043 n1_m1_105600_571200 n1_m1_110400_571200 5.356235
R17044 n1_m1_110400_571200 n1_m1_115200_571200 5.356235
R17045 n1_m1_115200_571200 n1_m1_116000_571200 0.892706
R17046 n1_m1_120000_571200 n1_m1_116000_571200 4.463529
R17047 n1_m1_120000_571200 n1_m1_124800_571200 5.356235
R17048 n1_m1_124800_571200 n1_m1_129600_571200 5.356235
R17049 n1_m1_129600_571200 n1_m1_134400_571200 5.356235
R17050 n1_m1_134400_571200 n1_m1_139200_571200 5.356235
R17051 n1_m1_139200_571200 n1_m1_144000_571200 5.356235
R17052 n1_m1_144000_571200 n1_m1_148800_571200 5.356235
R17053 n1_m1_148800_571200 n1_m1_153600_571200 5.356235
R17054 n1_m1_153600_571200 n1_m1_158400_571200 5.356235
R17055 n1_m1_158400_571200 n1_m1_163200_571200 5.356235
R17056 n1_m1_163200_571200 n1_m1_168000_571200 5.356235
R17057 n1_m1_168000_571200 n1_m1_172000_571200 4.463529
R17058 n1_m1_172800_571200 n1_m1_172000_571200 0.892706
R17059 n1_m1_172800_571200 n1_m1_177600_571200 5.356235
R17060 n1_m1_177600_571200 n1_m1_182400_571200 5.356235
R17061 n1_m1_182400_571200 n1_m1_187200_571200 5.356235
R17062 n1_m1_187200_571200 n1_m1_192000_571200 5.356235
R17063 n1_m1_192000_571200 n1_m1_196800_571200 5.356235
R17064 n1_m1_196800_571200 n1_m1_200000_571200 3.570824
R17065 n1_m1_201600_571200 n1_m1_200000_571200 1.785412
R17066 n1_m1_201600_571200 n1_m1_206400_571200 5.356235
R17067 n1_m1_206400_571200 n1_m1_211200_571200 5.356235
R17068 n1_m1_211200_571200 n1_m1_216000_571200 5.356235
R17069 n1_m1_216000_571200 n1_m1_220800_571200 5.356235
R17070 n1_m1_220800_571200 n1_m1_225600_571200 5.356235
R17071 n1_m1_225600_571200 n1_m1_228000_571200 2.678118
R17072 n1_m1_230400_571200 n1_m1_228000_571200 2.678118
R17073 n1_m1_230400_571200 n1_m1_235200_571200 5.356235
R17074 n1_m1_235200_571200 n1_m1_240000_571200 5.356235
R17075 n1_m1_240000_571200 n1_m1_244800_571200 5.356235
R17076 n1_m1_244800_571200 n1_m1_249600_571200 5.356235
R17077 n1_m1_249600_571200 n1_m1_254400_571200 5.356235
R17078 n1_m1_254400_571200 n1_m1_256000_571200 1.785412
R17079 n1_m1_259200_571200 n1_m1_256000_571200 3.570824
R17080 n1_m1_259200_571200 n1_m1_264000_571200 5.356235
R17081 n1_m1_264000_571200 n1_m1_268800_571200 5.356235
R17082 n1_m1_268800_571200 n1_m1_273600_571200 5.356235
R17083 n1_m1_273600_571200 n1_m1_278400_571200 5.356235
R17084 n1_m1_278400_571200 n1_m1_283200_571200 5.356235
R17085 n1_m1_283200_571200 n1_m1_284000_571200 0.892706
R17086 n1_m1_288000_571200 n1_m1_284000_571200 4.463529
R17087 n1_m1_288000_571200 n1_m1_292800_571200 5.356235
R17088 n1_m1_292800_571200 n1_m1_297600_571200 5.356235
R17089 n1_m1_297600_571200 n1_m1_302400_571200 5.356235
R17090 n1_m1_302400_571200 n1_m1_307200_571200 5.356235
R17091 n1_m1_307200_571200 n1_m1_312000_571200 5.356235
R17092 n1_m1_312000_571200 n1_m1_316800_571200 5.356235
R17093 n1_m1_316800_571200 n1_m1_321600_571200 5.356235
R17094 n1_m1_321600_571200 n1_m1_326400_571200 5.356235
R17095 n1_m1_326400_571200 n1_m1_331200_571200 5.356235
R17096 n1_m1_331200_571200 n1_m1_336000_571200 5.356235
R17097 n1_m1_336000_571200 n1_m1_340000_571200 4.463529
R17098 n1_m1_340800_571200 n1_m1_340000_571200 0.892706
R17099 n1_m1_340800_571200 n1_m1_345600_571200 5.356235
R17100 n1_m1_345600_571200 n1_m1_350400_571200 5.356235
R17101 n1_m1_350400_571200 n1_m1_355200_571200 5.356235
R17102 n1_m1_355200_571200 n1_m1_360000_571200 5.356235
R17103 n1_m1_360000_571200 n1_m1_364800_571200 5.356235
R17104 n1_m1_364800_571200 n1_m1_368000_571200 3.570824
R17105 n1_m1_369600_571200 n1_m1_368000_571200 1.785412
R17106 n1_m1_369600_571200 n1_m1_374400_571200 5.356235
R17107 n1_m1_374400_571200 n1_m1_379200_571200 5.356235
R17108 n1_m1_379200_571200 n1_m1_384000_571200 5.356235
R17109 n1_m1_384000_571200 n1_m1_388800_571200 5.356235
R17110 n1_m1_388800_571200 n1_m1_393600_571200 5.356235
R17111 n1_m1_393600_571200 n1_m1_396000_571200 2.678118
R17112 n1_m1_398400_571200 n1_m1_396000_571200 2.678118
R17113 n1_m1_398400_571200 n1_m1_403200_571200 5.356235
R17114 n1_m1_403200_571200 n1_m1_408000_571200 5.356235
R17115 n1_m1_408000_571200 n1_m1_412800_571200 5.356235
R17116 n1_m1_412800_571200 n1_m1_417600_571200 5.356235
R17117 n1_m1_417600_571200 n1_m1_422400_571200 5.356235
R17118 n1_m1_422400_571200 n1_m1_424000_571200 1.785412
R17119 n1_m1_427200_571200 n1_m1_424000_571200 3.570824
R17120 n1_m1_427200_571200 n1_m1_432000_571200 5.356235
R17121 n1_m1_432000_571200 n1_m1_436800_571200 5.356235
R17122 n1_m1_436800_571200 n1_m1_441600_571200 5.356235
R17123 n1_m1_441600_571200 n1_m1_446400_571200 5.356235
R17124 n1_m1_446400_571200 n1_m1_451200_571200 5.356235
R17125 n1_m1_451200_571200 n1_m1_452000_571200 0.892706
R17126 n1_m1_456000_571200 n1_m1_452000_571200 4.463529
R17127 n1_m1_456000_571200 n1_m1_460800_571200 5.356235
R17128 n1_m1_460800_571200 n1_m1_465600_571200 5.356235
R17129 n1_m1_465600_571200 n1_m1_470400_571200 5.356235
R17130 n1_m1_470400_571200 n1_m1_475200_571200 5.356235
R17131 n1_m1_475200_571200 n1_m1_480000_571200 5.356235
R17132 n1_m1_480000_571200 n1_m1_484800_571200 5.356235
R17133 n1_m1_484800_571200 n1_m1_489600_571200 5.356235
R17134 n1_m1_489600_571200 n1_m1_494400_571200 5.356235
R17135 n1_m1_494400_571200 n1_m1_499200_571200 5.356235
R17136 n1_m1_499200_571200 n1_m1_504000_571200 5.356235
R17137 n1_m1_504000_571200 n1_m1_508000_571200 4.463529
R17138 n1_m1_508800_571200 n1_m1_508000_571200 0.892706
R17139 n1_m1_508800_571200 n1_m1_513600_571200 5.356235
R17140 n1_m1_513600_571200 n1_m1_518400_571200 5.356235
R17141 n1_m1_518400_571200 n1_m1_523200_571200 5.356235
R17142 n1_m1_523200_571200 n1_m1_528000_571200 5.356235
R17143 n1_m1_528000_571200 n1_m1_532800_571200 5.356235
R17144 n1_m1_532800_571200 n1_m1_536000_571200 3.570824
R17145 n1_m1_537600_571200 n1_m1_536000_571200 1.785412
R17146 n1_m1_537600_571200 n1_m1_542400_571200 5.356235
R17147 n1_m1_542400_571200 n1_m1_547200_571200 5.356235
R17148 n1_m1_547200_571200 n1_m1_552000_571200 5.356235
R17149 n1_m1_552000_571200 n1_m1_556800_571200 5.356235
R17150 n1_m1_556800_571200 n1_m1_561600_571200 5.356235
R17151 n1_m1_561600_571200 n1_m1_564000_571200 2.678118
R17152 n1_m1_566400_571200 n1_m1_564000_571200 2.678118
R17153 n1_m1_566400_571200 n1_m1_571200_571200 5.356235
R17154 n1_m1_571200_571200 n1_m1_576000_571200 5.356235
R17155 n1_m1_576000_571200 n1_m1_580800_571200 5.356235
R17156 n1_m1_580800_571200 n1_m1_585600_571200 5.356235
R17157 n1_m1_585600_571200 n1_m1_590400_571200 5.356235
R17158 n1_m1_590400_571200 n1_m1_592000_571200 1.785412
R17159 n1_m1_595200_571200 n1_m1_592000_571200 3.570824
R17160 n1_m1_0_576000 n1_m1_4000_576000 4.463529
R17161 n1_m1_4800_576000 n1_m1_4000_576000 0.892706
R17162 n1_m1_4800_576000 n1_m1_9600_576000 5.356235
R17163 n1_m1_9600_576000 n1_m1_14400_576000 5.356235
R17164 n1_m1_14400_576000 n1_m1_19200_576000 5.356235
R17165 n1_m1_19200_576000 n1_m1_24000_576000 5.356235
R17166 n1_m1_24000_576000 n1_m1_28800_576000 5.356235
R17167 n1_m1_28800_576000 n1_m1_32000_576000 3.570824
R17168 n1_m1_33600_576000 n1_m1_32000_576000 1.785412
R17169 n1_m1_33600_576000 n1_m1_38400_576000 5.356235
R17170 n1_m1_38400_576000 n1_m1_43200_576000 5.356235
R17171 n1_m1_43200_576000 n1_m1_48000_576000 5.356235
R17172 n1_m1_48000_576000 n1_m1_52800_576000 5.356235
R17173 n1_m1_52800_576000 n1_m1_57600_576000 5.356235
R17174 n1_m1_57600_576000 n1_m1_60000_576000 2.678118
R17175 n1_m1_62400_576000 n1_m1_60000_576000 2.678118
R17176 n1_m1_62400_576000 n1_m1_67200_576000 5.356235
R17177 n1_m1_67200_576000 n1_m1_72000_576000 5.356235
R17178 n1_m1_72000_576000 n1_m1_76800_576000 5.356235
R17179 n1_m1_76800_576000 n1_m1_81600_576000 5.356235
R17180 n1_m1_81600_576000 n1_m1_86400_576000 5.356235
R17181 n1_m1_86400_576000 n1_m1_88000_576000 1.785412
R17182 n1_m1_91200_576000 n1_m1_88000_576000 3.570824
R17183 n1_m1_91200_576000 n1_m1_96000_576000 5.356235
R17184 n1_m1_96000_576000 n1_m1_100800_576000 5.356235
R17185 n1_m1_100800_576000 n1_m1_105600_576000 5.356235
R17186 n1_m1_105600_576000 n1_m1_110400_576000 5.356235
R17187 n1_m1_110400_576000 n1_m1_115200_576000 5.356235
R17188 n1_m1_115200_576000 n1_m1_116000_576000 0.892706
R17189 n1_m1_120000_576000 n1_m1_116000_576000 4.463529
R17190 n1_m1_120000_576000 n1_m1_124800_576000 5.356235
R17191 n1_m1_124800_576000 n1_m1_129600_576000 5.356235
R17192 n1_m1_129600_576000 n1_m1_134400_576000 5.356235
R17193 n1_m1_134400_576000 n1_m1_139200_576000 5.356235
R17194 n1_m1_139200_576000 n1_m1_144000_576000 5.356235
R17195 n1_m1_144000_576000 n1_m1_148800_576000 5.356235
R17196 n1_m1_148800_576000 n1_m1_153600_576000 5.356235
R17197 n1_m1_153600_576000 n1_m1_158400_576000 5.356235
R17198 n1_m1_158400_576000 n1_m1_163200_576000 5.356235
R17199 n1_m1_163200_576000 n1_m1_168000_576000 5.356235
R17200 n1_m1_168000_576000 n1_m1_172000_576000 4.463529
R17201 n1_m1_172800_576000 n1_m1_172000_576000 0.892706
R17202 n1_m1_172800_576000 n1_m1_177600_576000 5.356235
R17203 n1_m1_177600_576000 n1_m1_182400_576000 5.356235
R17204 n1_m1_182400_576000 n1_m1_187200_576000 5.356235
R17205 n1_m1_187200_576000 n1_m1_192000_576000 5.356235
R17206 n1_m1_192000_576000 n1_m1_196800_576000 5.356235
R17207 n1_m1_196800_576000 n1_m1_200000_576000 3.570824
R17208 n1_m1_201600_576000 n1_m1_200000_576000 1.785412
R17209 n1_m1_201600_576000 n1_m1_206400_576000 5.356235
R17210 n1_m1_206400_576000 n1_m1_211200_576000 5.356235
R17211 n1_m1_211200_576000 n1_m1_216000_576000 5.356235
R17212 n1_m1_216000_576000 n1_m1_220800_576000 5.356235
R17213 n1_m1_220800_576000 n1_m1_225600_576000 5.356235
R17214 n1_m1_225600_576000 n1_m1_228000_576000 2.678118
R17215 n1_m1_230400_576000 n1_m1_228000_576000 2.678118
R17216 n1_m1_230400_576000 n1_m1_235200_576000 5.356235
R17217 n1_m1_235200_576000 n1_m1_240000_576000 5.356235
R17218 n1_m1_240000_576000 n1_m1_244800_576000 5.356235
R17219 n1_m1_244800_576000 n1_m1_249600_576000 5.356235
R17220 n1_m1_249600_576000 n1_m1_254400_576000 5.356235
R17221 n1_m1_254400_576000 n1_m1_256000_576000 1.785412
R17222 n1_m1_259200_576000 n1_m1_256000_576000 3.570824
R17223 n1_m1_259200_576000 n1_m1_264000_576000 5.356235
R17224 n1_m1_264000_576000 n1_m1_268800_576000 5.356235
R17225 n1_m1_268800_576000 n1_m1_273600_576000 5.356235
R17226 n1_m1_273600_576000 n1_m1_278400_576000 5.356235
R17227 n1_m1_278400_576000 n1_m1_283200_576000 5.356235
R17228 n1_m1_283200_576000 n1_m1_284000_576000 0.892706
R17229 n1_m1_288000_576000 n1_m1_284000_576000 4.463529
R17230 n1_m1_288000_576000 n1_m1_292800_576000 5.356235
R17231 n1_m1_292800_576000 n1_m1_297600_576000 5.356235
R17232 n1_m1_297600_576000 n1_m1_302400_576000 5.356235
R17233 n1_m1_302400_576000 n1_m1_307200_576000 5.356235
R17234 n1_m1_307200_576000 n1_m1_312000_576000 5.356235
R17235 n1_m1_312000_576000 n1_m1_316800_576000 5.356235
R17236 n1_m1_316800_576000 n1_m1_321600_576000 5.356235
R17237 n1_m1_321600_576000 n1_m1_326400_576000 5.356235
R17238 n1_m1_326400_576000 n1_m1_331200_576000 5.356235
R17239 n1_m1_331200_576000 n1_m1_336000_576000 5.356235
R17240 n1_m1_336000_576000 n1_m1_340000_576000 4.463529
R17241 n1_m1_340800_576000 n1_m1_340000_576000 0.892706
R17242 n1_m1_340800_576000 n1_m1_345600_576000 5.356235
R17243 n1_m1_345600_576000 n1_m1_350400_576000 5.356235
R17244 n1_m1_350400_576000 n1_m1_355200_576000 5.356235
R17245 n1_m1_355200_576000 n1_m1_360000_576000 5.356235
R17246 n1_m1_360000_576000 n1_m1_364800_576000 5.356235
R17247 n1_m1_364800_576000 n1_m1_368000_576000 3.570824
R17248 n1_m1_369600_576000 n1_m1_368000_576000 1.785412
R17249 n1_m1_369600_576000 n1_m1_374400_576000 5.356235
R17250 n1_m1_374400_576000 n1_m1_379200_576000 5.356235
R17251 n1_m1_379200_576000 n1_m1_384000_576000 5.356235
R17252 n1_m1_384000_576000 n1_m1_388800_576000 5.356235
R17253 n1_m1_388800_576000 n1_m1_393600_576000 5.356235
R17254 n1_m1_393600_576000 n1_m1_396000_576000 2.678118
R17255 n1_m1_398400_576000 n1_m1_396000_576000 2.678118
R17256 n1_m1_398400_576000 n1_m1_403200_576000 5.356235
R17257 n1_m1_403200_576000 n1_m1_408000_576000 5.356235
R17258 n1_m1_408000_576000 n1_m1_412800_576000 5.356235
R17259 n1_m1_412800_576000 n1_m1_417600_576000 5.356235
R17260 n1_m1_417600_576000 n1_m1_422400_576000 5.356235
R17261 n1_m1_422400_576000 n1_m1_424000_576000 1.785412
R17262 n1_m1_427200_576000 n1_m1_424000_576000 3.570824
R17263 n1_m1_427200_576000 n1_m1_432000_576000 5.356235
R17264 n1_m1_432000_576000 n1_m1_436800_576000 5.356235
R17265 n1_m1_436800_576000 n1_m1_441600_576000 5.356235
R17266 n1_m1_441600_576000 n1_m1_446400_576000 5.356235
R17267 n1_m1_446400_576000 n1_m1_451200_576000 5.356235
R17268 n1_m1_451200_576000 n1_m1_452000_576000 0.892706
R17269 n1_m1_456000_576000 n1_m1_452000_576000 4.463529
R17270 n1_m1_456000_576000 n1_m1_460800_576000 5.356235
R17271 n1_m1_460800_576000 n1_m1_465600_576000 5.356235
R17272 n1_m1_465600_576000 n1_m1_470400_576000 5.356235
R17273 n1_m1_470400_576000 n1_m1_475200_576000 5.356235
R17274 n1_m1_475200_576000 n1_m1_480000_576000 5.356235
R17275 n1_m1_480000_576000 n1_m1_484800_576000 5.356235
R17276 n1_m1_484800_576000 n1_m1_489600_576000 5.356235
R17277 n1_m1_489600_576000 n1_m1_494400_576000 5.356235
R17278 n1_m1_494400_576000 n1_m1_499200_576000 5.356235
R17279 n1_m1_499200_576000 n1_m1_504000_576000 5.356235
R17280 n1_m1_504000_576000 n1_m1_508000_576000 4.463529
R17281 n1_m1_508800_576000 n1_m1_508000_576000 0.892706
R17282 n1_m1_508800_576000 n1_m1_513600_576000 5.356235
R17283 n1_m1_513600_576000 n1_m1_518400_576000 5.356235
R17284 n1_m1_518400_576000 n1_m1_523200_576000 5.356235
R17285 n1_m1_523200_576000 n1_m1_528000_576000 5.356235
R17286 n1_m1_528000_576000 n1_m1_532800_576000 5.356235
R17287 n1_m1_532800_576000 n1_m1_536000_576000 3.570824
R17288 n1_m1_537600_576000 n1_m1_536000_576000 1.785412
R17289 n1_m1_537600_576000 n1_m1_542400_576000 5.356235
R17290 n1_m1_542400_576000 n1_m1_547200_576000 5.356235
R17291 n1_m1_547200_576000 n1_m1_552000_576000 5.356235
R17292 n1_m1_552000_576000 n1_m1_556800_576000 5.356235
R17293 n1_m1_556800_576000 n1_m1_561600_576000 5.356235
R17294 n1_m1_561600_576000 n1_m1_564000_576000 2.678118
R17295 n1_m1_566400_576000 n1_m1_564000_576000 2.678118
R17296 n1_m1_566400_576000 n1_m1_571200_576000 5.356235
R17297 n1_m1_571200_576000 n1_m1_576000_576000 5.356235
R17298 n1_m1_576000_576000 n1_m1_580800_576000 5.356235
R17299 n1_m1_580800_576000 n1_m1_585600_576000 5.356235
R17300 n1_m1_585600_576000 n1_m1_590400_576000 5.356235
R17301 n1_m1_590400_576000 n1_m1_592000_576000 1.785412
R17302 n1_m1_595200_576000 n1_m1_592000_576000 3.570824
R17303 n1_m1_0_580800 n1_m1_4000_580800 4.463529
R17304 n1_m1_4800_580800 n1_m1_4000_580800 0.892706
R17305 n1_m1_4800_580800 n1_m1_9600_580800 5.356235
R17306 n1_m1_9600_580800 n1_m1_14400_580800 5.356235
R17307 n1_m1_14400_580800 n1_m1_19200_580800 5.356235
R17308 n1_m1_19200_580800 n1_m1_24000_580800 5.356235
R17309 n1_m1_24000_580800 n1_m1_28800_580800 5.356235
R17310 n1_m1_28800_580800 n1_m1_32000_580800 3.570824
R17311 n1_m1_33600_580800 n1_m1_32000_580800 1.785412
R17312 n1_m1_33600_580800 n1_m1_38400_580800 5.356235
R17313 n1_m1_38400_580800 n1_m1_43200_580800 5.356235
R17314 n1_m1_43200_580800 n1_m1_48000_580800 5.356235
R17315 n1_m1_48000_580800 n1_m1_52800_580800 5.356235
R17316 n1_m1_52800_580800 n1_m1_57600_580800 5.356235
R17317 n1_m1_57600_580800 n1_m1_60000_580800 2.678118
R17318 n1_m1_62400_580800 n1_m1_60000_580800 2.678118
R17319 n1_m1_62400_580800 n1_m1_67200_580800 5.356235
R17320 n1_m1_67200_580800 n1_m1_72000_580800 5.356235
R17321 n1_m1_72000_580800 n1_m1_76800_580800 5.356235
R17322 n1_m1_76800_580800 n1_m1_81600_580800 5.356235
R17323 n1_m1_81600_580800 n1_m1_86400_580800 5.356235
R17324 n1_m1_86400_580800 n1_m1_88000_580800 1.785412
R17325 n1_m1_91200_580800 n1_m1_88000_580800 3.570824
R17326 n1_m1_91200_580800 n1_m1_96000_580800 5.356235
R17327 n1_m1_96000_580800 n1_m1_100800_580800 5.356235
R17328 n1_m1_100800_580800 n1_m1_105600_580800 5.356235
R17329 n1_m1_105600_580800 n1_m1_110400_580800 5.356235
R17330 n1_m1_110400_580800 n1_m1_115200_580800 5.356235
R17331 n1_m1_115200_580800 n1_m1_116000_580800 0.892706
R17332 n1_m1_120000_580800 n1_m1_116000_580800 4.463529
R17333 n1_m1_120000_580800 n1_m1_124800_580800 5.356235
R17334 n1_m1_124800_580800 n1_m1_129600_580800 5.356235
R17335 n1_m1_129600_580800 n1_m1_134400_580800 5.356235
R17336 n1_m1_134400_580800 n1_m1_139200_580800 5.356235
R17337 n1_m1_139200_580800 n1_m1_144000_580800 5.356235
R17338 n1_m1_144000_580800 n1_m1_148800_580800 5.356235
R17339 n1_m1_148800_580800 n1_m1_153600_580800 5.356235
R17340 n1_m1_153600_580800 n1_m1_158400_580800 5.356235
R17341 n1_m1_158400_580800 n1_m1_163200_580800 5.356235
R17342 n1_m1_163200_580800 n1_m1_168000_580800 5.356235
R17343 n1_m1_168000_580800 n1_m1_172000_580800 4.463529
R17344 n1_m1_172800_580800 n1_m1_172000_580800 0.892706
R17345 n1_m1_172800_580800 n1_m1_177600_580800 5.356235
R17346 n1_m1_177600_580800 n1_m1_182400_580800 5.356235
R17347 n1_m1_182400_580800 n1_m1_187200_580800 5.356235
R17348 n1_m1_187200_580800 n1_m1_192000_580800 5.356235
R17349 n1_m1_192000_580800 n1_m1_196800_580800 5.356235
R17350 n1_m1_196800_580800 n1_m1_200000_580800 3.570824
R17351 n1_m1_201600_580800 n1_m1_200000_580800 1.785412
R17352 n1_m1_201600_580800 n1_m1_206400_580800 5.356235
R17353 n1_m1_206400_580800 n1_m1_211200_580800 5.356235
R17354 n1_m1_211200_580800 n1_m1_216000_580800 5.356235
R17355 n1_m1_216000_580800 n1_m1_220800_580800 5.356235
R17356 n1_m1_220800_580800 n1_m1_225600_580800 5.356235
R17357 n1_m1_225600_580800 n1_m1_228000_580800 2.678118
R17358 n1_m1_230400_580800 n1_m1_228000_580800 2.678118
R17359 n1_m1_230400_580800 n1_m1_235200_580800 5.356235
R17360 n1_m1_235200_580800 n1_m1_240000_580800 5.356235
R17361 n1_m1_240000_580800 n1_m1_244800_580800 5.356235
R17362 n1_m1_244800_580800 n1_m1_249600_580800 5.356235
R17363 n1_m1_249600_580800 n1_m1_254400_580800 5.356235
R17364 n1_m1_254400_580800 n1_m1_256000_580800 1.785412
R17365 n1_m1_259200_580800 n1_m1_256000_580800 3.570824
R17366 n1_m1_259200_580800 n1_m1_264000_580800 5.356235
R17367 n1_m1_264000_580800 n1_m1_268800_580800 5.356235
R17368 n1_m1_268800_580800 n1_m1_273600_580800 5.356235
R17369 n1_m1_273600_580800 n1_m1_278400_580800 5.356235
R17370 n1_m1_278400_580800 n1_m1_283200_580800 5.356235
R17371 n1_m1_283200_580800 n1_m1_284000_580800 0.892706
R17372 n1_m1_288000_580800 n1_m1_284000_580800 4.463529
R17373 n1_m1_288000_580800 n1_m1_292800_580800 5.356235
R17374 n1_m1_292800_580800 n1_m1_297600_580800 5.356235
R17375 n1_m1_297600_580800 n1_m1_302400_580800 5.356235
R17376 n1_m1_302400_580800 n1_m1_307200_580800 5.356235
R17377 n1_m1_307200_580800 n1_m1_312000_580800 5.356235
R17378 n1_m1_312000_580800 n1_m1_316800_580800 5.356235
R17379 n1_m1_316800_580800 n1_m1_321600_580800 5.356235
R17380 n1_m1_321600_580800 n1_m1_326400_580800 5.356235
R17381 n1_m1_326400_580800 n1_m1_331200_580800 5.356235
R17382 n1_m1_331200_580800 n1_m1_336000_580800 5.356235
R17383 n1_m1_336000_580800 n1_m1_340000_580800 4.463529
R17384 n1_m1_340800_580800 n1_m1_340000_580800 0.892706
R17385 n1_m1_340800_580800 n1_m1_345600_580800 5.356235
R17386 n1_m1_345600_580800 n1_m1_350400_580800 5.356235
R17387 n1_m1_350400_580800 n1_m1_355200_580800 5.356235
R17388 n1_m1_355200_580800 n1_m1_360000_580800 5.356235
R17389 n1_m1_360000_580800 n1_m1_364800_580800 5.356235
R17390 n1_m1_364800_580800 n1_m1_368000_580800 3.570824
R17391 n1_m1_369600_580800 n1_m1_368000_580800 1.785412
R17392 n1_m1_369600_580800 n1_m1_374400_580800 5.356235
R17393 n1_m1_374400_580800 n1_m1_379200_580800 5.356235
R17394 n1_m1_379200_580800 n1_m1_384000_580800 5.356235
R17395 n1_m1_384000_580800 n1_m1_388800_580800 5.356235
R17396 n1_m1_388800_580800 n1_m1_393600_580800 5.356235
R17397 n1_m1_393600_580800 n1_m1_396000_580800 2.678118
R17398 n1_m1_398400_580800 n1_m1_396000_580800 2.678118
R17399 n1_m1_398400_580800 n1_m1_403200_580800 5.356235
R17400 n1_m1_403200_580800 n1_m1_408000_580800 5.356235
R17401 n1_m1_408000_580800 n1_m1_412800_580800 5.356235
R17402 n1_m1_412800_580800 n1_m1_417600_580800 5.356235
R17403 n1_m1_417600_580800 n1_m1_422400_580800 5.356235
R17404 n1_m1_422400_580800 n1_m1_424000_580800 1.785412
R17405 n1_m1_427200_580800 n1_m1_424000_580800 3.570824
R17406 n1_m1_427200_580800 n1_m1_432000_580800 5.356235
R17407 n1_m1_432000_580800 n1_m1_436800_580800 5.356235
R17408 n1_m1_436800_580800 n1_m1_441600_580800 5.356235
R17409 n1_m1_441600_580800 n1_m1_446400_580800 5.356235
R17410 n1_m1_446400_580800 n1_m1_451200_580800 5.356235
R17411 n1_m1_451200_580800 n1_m1_452000_580800 0.892706
R17412 n1_m1_456000_580800 n1_m1_452000_580800 4.463529
R17413 n1_m1_456000_580800 n1_m1_460800_580800 5.356235
R17414 n1_m1_460800_580800 n1_m1_465600_580800 5.356235
R17415 n1_m1_465600_580800 n1_m1_470400_580800 5.356235
R17416 n1_m1_470400_580800 n1_m1_475200_580800 5.356235
R17417 n1_m1_475200_580800 n1_m1_480000_580800 5.356235
R17418 n1_m1_480000_580800 n1_m1_484800_580800 5.356235
R17419 n1_m1_484800_580800 n1_m1_489600_580800 5.356235
R17420 n1_m1_489600_580800 n1_m1_494400_580800 5.356235
R17421 n1_m1_494400_580800 n1_m1_499200_580800 5.356235
R17422 n1_m1_499200_580800 n1_m1_504000_580800 5.356235
R17423 n1_m1_504000_580800 n1_m1_508000_580800 4.463529
R17424 n1_m1_508800_580800 n1_m1_508000_580800 0.892706
R17425 n1_m1_508800_580800 n1_m1_513600_580800 5.356235
R17426 n1_m1_513600_580800 n1_m1_518400_580800 5.356235
R17427 n1_m1_518400_580800 n1_m1_523200_580800 5.356235
R17428 n1_m1_523200_580800 n1_m1_528000_580800 5.356235
R17429 n1_m1_528000_580800 n1_m1_532800_580800 5.356235
R17430 n1_m1_532800_580800 n1_m1_536000_580800 3.570824
R17431 n1_m1_537600_580800 n1_m1_536000_580800 1.785412
R17432 n1_m1_537600_580800 n1_m1_542400_580800 5.356235
R17433 n1_m1_542400_580800 n1_m1_547200_580800 5.356235
R17434 n1_m1_547200_580800 n1_m1_552000_580800 5.356235
R17435 n1_m1_552000_580800 n1_m1_556800_580800 5.356235
R17436 n1_m1_556800_580800 n1_m1_561600_580800 5.356235
R17437 n1_m1_561600_580800 n1_m1_564000_580800 2.678118
R17438 n1_m1_566400_580800 n1_m1_564000_580800 2.678118
R17439 n1_m1_566400_580800 n1_m1_571200_580800 5.356235
R17440 n1_m1_571200_580800 n1_m1_576000_580800 5.356235
R17441 n1_m1_576000_580800 n1_m1_580800_580800 5.356235
R17442 n1_m1_580800_580800 n1_m1_585600_580800 5.356235
R17443 n1_m1_585600_580800 n1_m1_590400_580800 5.356235
R17444 n1_m1_590400_580800 n1_m1_592000_580800 1.785412
R17445 n1_m1_595200_580800 n1_m1_592000_580800 3.570824
R17446 n1_m1_0_585600 n1_m1_4000_585600 4.463529
R17447 n1_m1_4800_585600 n1_m1_4000_585600 0.892706
R17448 n1_m1_4800_585600 n1_m1_9600_585600 5.356235
R17449 n1_m1_9600_585600 n1_m1_14400_585600 5.356235
R17450 n1_m1_14400_585600 n1_m1_19200_585600 5.356235
R17451 n1_m1_19200_585600 n1_m1_24000_585600 5.356235
R17452 n1_m1_24000_585600 n1_m1_28800_585600 5.356235
R17453 n1_m1_28800_585600 n1_m1_32000_585600 3.570824
R17454 n1_m1_33600_585600 n1_m1_32000_585600 1.785412
R17455 n1_m1_33600_585600 n1_m1_38400_585600 5.356235
R17456 n1_m1_38400_585600 n1_m1_43200_585600 5.356235
R17457 n1_m1_43200_585600 n1_m1_48000_585600 5.356235
R17458 n1_m1_48000_585600 n1_m1_52800_585600 5.356235
R17459 n1_m1_52800_585600 n1_m1_57600_585600 5.356235
R17460 n1_m1_57600_585600 n1_m1_60000_585600 2.678118
R17461 n1_m1_62400_585600 n1_m1_60000_585600 2.678118
R17462 n1_m1_62400_585600 n1_m1_67200_585600 5.356235
R17463 n1_m1_67200_585600 n1_m1_72000_585600 5.356235
R17464 n1_m1_72000_585600 n1_m1_76800_585600 5.356235
R17465 n1_m1_76800_585600 n1_m1_81600_585600 5.356235
R17466 n1_m1_81600_585600 n1_m1_86400_585600 5.356235
R17467 n1_m1_86400_585600 n1_m1_88000_585600 1.785412
R17468 n1_m1_91200_585600 n1_m1_88000_585600 3.570824
R17469 n1_m1_91200_585600 n1_m1_96000_585600 5.356235
R17470 n1_m1_96000_585600 n1_m1_100800_585600 5.356235
R17471 n1_m1_100800_585600 n1_m1_105600_585600 5.356235
R17472 n1_m1_105600_585600 n1_m1_110400_585600 5.356235
R17473 n1_m1_110400_585600 n1_m1_115200_585600 5.356235
R17474 n1_m1_115200_585600 n1_m1_116000_585600 0.892706
R17475 n1_m1_120000_585600 n1_m1_116000_585600 4.463529
R17476 n1_m1_120000_585600 n1_m1_124800_585600 5.356235
R17477 n1_m1_124800_585600 n1_m1_129600_585600 5.356235
R17478 n1_m1_129600_585600 n1_m1_134400_585600 5.356235
R17479 n1_m1_134400_585600 n1_m1_139200_585600 5.356235
R17480 n1_m1_139200_585600 n1_m1_144000_585600 5.356235
R17481 n1_m1_144000_585600 n1_m1_148800_585600 5.356235
R17482 n1_m1_148800_585600 n1_m1_153600_585600 5.356235
R17483 n1_m1_153600_585600 n1_m1_158400_585600 5.356235
R17484 n1_m1_158400_585600 n1_m1_163200_585600 5.356235
R17485 n1_m1_163200_585600 n1_m1_168000_585600 5.356235
R17486 n1_m1_168000_585600 n1_m1_172000_585600 4.463529
R17487 n1_m1_172800_585600 n1_m1_172000_585600 0.892706
R17488 n1_m1_172800_585600 n1_m1_177600_585600 5.356235
R17489 n1_m1_177600_585600 n1_m1_182400_585600 5.356235
R17490 n1_m1_182400_585600 n1_m1_187200_585600 5.356235
R17491 n1_m1_187200_585600 n1_m1_192000_585600 5.356235
R17492 n1_m1_192000_585600 n1_m1_196800_585600 5.356235
R17493 n1_m1_196800_585600 n1_m1_200000_585600 3.570824
R17494 n1_m1_201600_585600 n1_m1_200000_585600 1.785412
R17495 n1_m1_201600_585600 n1_m1_206400_585600 5.356235
R17496 n1_m1_206400_585600 n1_m1_211200_585600 5.356235
R17497 n1_m1_211200_585600 n1_m1_216000_585600 5.356235
R17498 n1_m1_216000_585600 n1_m1_220800_585600 5.356235
R17499 n1_m1_220800_585600 n1_m1_225600_585600 5.356235
R17500 n1_m1_225600_585600 n1_m1_228000_585600 2.678118
R17501 n1_m1_230400_585600 n1_m1_228000_585600 2.678118
R17502 n1_m1_230400_585600 n1_m1_235200_585600 5.356235
R17503 n1_m1_235200_585600 n1_m1_240000_585600 5.356235
R17504 n1_m1_240000_585600 n1_m1_244800_585600 5.356235
R17505 n1_m1_244800_585600 n1_m1_249600_585600 5.356235
R17506 n1_m1_249600_585600 n1_m1_254400_585600 5.356235
R17507 n1_m1_254400_585600 n1_m1_256000_585600 1.785412
R17508 n1_m1_259200_585600 n1_m1_256000_585600 3.570824
R17509 n1_m1_259200_585600 n1_m1_264000_585600 5.356235
R17510 n1_m1_264000_585600 n1_m1_268800_585600 5.356235
R17511 n1_m1_268800_585600 n1_m1_273600_585600 5.356235
R17512 n1_m1_273600_585600 n1_m1_278400_585600 5.356235
R17513 n1_m1_278400_585600 n1_m1_283200_585600 5.356235
R17514 n1_m1_283200_585600 n1_m1_284000_585600 0.892706
R17515 n1_m1_288000_585600 n1_m1_284000_585600 4.463529
R17516 n1_m1_288000_585600 n1_m1_292800_585600 5.356235
R17517 n1_m1_292800_585600 n1_m1_297600_585600 5.356235
R17518 n1_m1_297600_585600 n1_m1_302400_585600 5.356235
R17519 n1_m1_302400_585600 n1_m1_307200_585600 5.356235
R17520 n1_m1_307200_585600 n1_m1_312000_585600 5.356235
R17521 n1_m1_312000_585600 n1_m1_316800_585600 5.356235
R17522 n1_m1_316800_585600 n1_m1_321600_585600 5.356235
R17523 n1_m1_321600_585600 n1_m1_326400_585600 5.356235
R17524 n1_m1_326400_585600 n1_m1_331200_585600 5.356235
R17525 n1_m1_331200_585600 n1_m1_336000_585600 5.356235
R17526 n1_m1_336000_585600 n1_m1_340000_585600 4.463529
R17527 n1_m1_340800_585600 n1_m1_340000_585600 0.892706
R17528 n1_m1_340800_585600 n1_m1_345600_585600 5.356235
R17529 n1_m1_345600_585600 n1_m1_350400_585600 5.356235
R17530 n1_m1_350400_585600 n1_m1_355200_585600 5.356235
R17531 n1_m1_355200_585600 n1_m1_360000_585600 5.356235
R17532 n1_m1_360000_585600 n1_m1_364800_585600 5.356235
R17533 n1_m1_364800_585600 n1_m1_368000_585600 3.570824
R17534 n1_m1_369600_585600 n1_m1_368000_585600 1.785412
R17535 n1_m1_369600_585600 n1_m1_374400_585600 5.356235
R17536 n1_m1_374400_585600 n1_m1_379200_585600 5.356235
R17537 n1_m1_379200_585600 n1_m1_384000_585600 5.356235
R17538 n1_m1_384000_585600 n1_m1_388800_585600 5.356235
R17539 n1_m1_388800_585600 n1_m1_393600_585600 5.356235
R17540 n1_m1_393600_585600 n1_m1_396000_585600 2.678118
R17541 n1_m1_398400_585600 n1_m1_396000_585600 2.678118
R17542 n1_m1_398400_585600 n1_m1_403200_585600 5.356235
R17543 n1_m1_403200_585600 n1_m1_408000_585600 5.356235
R17544 n1_m1_408000_585600 n1_m1_412800_585600 5.356235
R17545 n1_m1_412800_585600 n1_m1_417600_585600 5.356235
R17546 n1_m1_417600_585600 n1_m1_422400_585600 5.356235
R17547 n1_m1_422400_585600 n1_m1_424000_585600 1.785412
R17548 n1_m1_427200_585600 n1_m1_424000_585600 3.570824
R17549 n1_m1_427200_585600 n1_m1_432000_585600 5.356235
R17550 n1_m1_432000_585600 n1_m1_436800_585600 5.356235
R17551 n1_m1_436800_585600 n1_m1_441600_585600 5.356235
R17552 n1_m1_441600_585600 n1_m1_446400_585600 5.356235
R17553 n1_m1_446400_585600 n1_m1_451200_585600 5.356235
R17554 n1_m1_451200_585600 n1_m1_452000_585600 0.892706
R17555 n1_m1_456000_585600 n1_m1_452000_585600 4.463529
R17556 n1_m1_456000_585600 n1_m1_460800_585600 5.356235
R17557 n1_m1_460800_585600 n1_m1_465600_585600 5.356235
R17558 n1_m1_465600_585600 n1_m1_470400_585600 5.356235
R17559 n1_m1_470400_585600 n1_m1_475200_585600 5.356235
R17560 n1_m1_475200_585600 n1_m1_480000_585600 5.356235
R17561 n1_m1_480000_585600 n1_m1_484800_585600 5.356235
R17562 n1_m1_484800_585600 n1_m1_489600_585600 5.356235
R17563 n1_m1_489600_585600 n1_m1_494400_585600 5.356235
R17564 n1_m1_494400_585600 n1_m1_499200_585600 5.356235
R17565 n1_m1_499200_585600 n1_m1_504000_585600 5.356235
R17566 n1_m1_504000_585600 n1_m1_508000_585600 4.463529
R17567 n1_m1_508800_585600 n1_m1_508000_585600 0.892706
R17568 n1_m1_508800_585600 n1_m1_513600_585600 5.356235
R17569 n1_m1_513600_585600 n1_m1_518400_585600 5.356235
R17570 n1_m1_518400_585600 n1_m1_523200_585600 5.356235
R17571 n1_m1_523200_585600 n1_m1_528000_585600 5.356235
R17572 n1_m1_528000_585600 n1_m1_532800_585600 5.356235
R17573 n1_m1_532800_585600 n1_m1_536000_585600 3.570824
R17574 n1_m1_537600_585600 n1_m1_536000_585600 1.785412
R17575 n1_m1_537600_585600 n1_m1_542400_585600 5.356235
R17576 n1_m1_542400_585600 n1_m1_547200_585600 5.356235
R17577 n1_m1_547200_585600 n1_m1_552000_585600 5.356235
R17578 n1_m1_552000_585600 n1_m1_556800_585600 5.356235
R17579 n1_m1_556800_585600 n1_m1_561600_585600 5.356235
R17580 n1_m1_561600_585600 n1_m1_564000_585600 2.678118
R17581 n1_m1_566400_585600 n1_m1_564000_585600 2.678118
R17582 n1_m1_566400_585600 n1_m1_571200_585600 5.356235
R17583 n1_m1_571200_585600 n1_m1_576000_585600 5.356235
R17584 n1_m1_576000_585600 n1_m1_580800_585600 5.356235
R17585 n1_m1_580800_585600 n1_m1_585600_585600 5.356235
R17586 n1_m1_585600_585600 n1_m1_590400_585600 5.356235
R17587 n1_m1_590400_585600 n1_m1_592000_585600 1.785412
R17588 n1_m1_595200_585600 n1_m1_592000_585600 3.570824
R17589 n1_m1_0_590400 n1_m1_4000_590400 4.463529
R17590 n1_m1_4800_590400 n1_m1_4000_590400 0.892706
R17591 n1_m1_4800_590400 n1_m1_9600_590400 5.356235
R17592 n1_m1_9600_590400 n1_m1_14400_590400 5.356235
R17593 n1_m1_14400_590400 n1_m1_19200_590400 5.356235
R17594 n1_m1_19200_590400 n1_m1_24000_590400 5.356235
R17595 n1_m1_24000_590400 n1_m1_28800_590400 5.356235
R17596 n1_m1_28800_590400 n1_m1_32000_590400 3.570824
R17597 n1_m1_33600_590400 n1_m1_32000_590400 1.785412
R17598 n1_m1_33600_590400 n1_m1_38400_590400 5.356235
R17599 n1_m1_38400_590400 n1_m1_43200_590400 5.356235
R17600 n1_m1_43200_590400 n1_m1_48000_590400 5.356235
R17601 n1_m1_48000_590400 n1_m1_52800_590400 5.356235
R17602 n1_m1_52800_590400 n1_m1_57600_590400 5.356235
R17603 n1_m1_57600_590400 n1_m1_60000_590400 2.678118
R17604 n1_m1_62400_590400 n1_m1_60000_590400 2.678118
R17605 n1_m1_62400_590400 n1_m1_67200_590400 5.356235
R17606 n1_m1_67200_590400 n1_m1_72000_590400 5.356235
R17607 n1_m1_72000_590400 n1_m1_76800_590400 5.356235
R17608 n1_m1_76800_590400 n1_m1_81600_590400 5.356235
R17609 n1_m1_81600_590400 n1_m1_86400_590400 5.356235
R17610 n1_m1_86400_590400 n1_m1_88000_590400 1.785412
R17611 n1_m1_91200_590400 n1_m1_88000_590400 3.570824
R17612 n1_m1_91200_590400 n1_m1_96000_590400 5.356235
R17613 n1_m1_96000_590400 n1_m1_100800_590400 5.356235
R17614 n1_m1_100800_590400 n1_m1_105600_590400 5.356235
R17615 n1_m1_105600_590400 n1_m1_110400_590400 5.356235
R17616 n1_m1_110400_590400 n1_m1_115200_590400 5.356235
R17617 n1_m1_115200_590400 n1_m1_116000_590400 0.892706
R17618 n1_m1_120000_590400 n1_m1_116000_590400 4.463529
R17619 n1_m1_120000_590400 n1_m1_124800_590400 5.356235
R17620 n1_m1_124800_590400 n1_m1_129600_590400 5.356235
R17621 n1_m1_129600_590400 n1_m1_134400_590400 5.356235
R17622 n1_m1_134400_590400 n1_m1_139200_590400 5.356235
R17623 n1_m1_139200_590400 n1_m1_144000_590400 5.356235
R17624 n1_m1_144000_590400 n1_m1_148800_590400 5.356235
R17625 n1_m1_148800_590400 n1_m1_153600_590400 5.356235
R17626 n1_m1_153600_590400 n1_m1_158400_590400 5.356235
R17627 n1_m1_158400_590400 n1_m1_163200_590400 5.356235
R17628 n1_m1_163200_590400 n1_m1_168000_590400 5.356235
R17629 n1_m1_168000_590400 n1_m1_172000_590400 4.463529
R17630 n1_m1_172800_590400 n1_m1_172000_590400 0.892706
R17631 n1_m1_172800_590400 n1_m1_177600_590400 5.356235
R17632 n1_m1_177600_590400 n1_m1_182400_590400 5.356235
R17633 n1_m1_182400_590400 n1_m1_187200_590400 5.356235
R17634 n1_m1_187200_590400 n1_m1_192000_590400 5.356235
R17635 n1_m1_192000_590400 n1_m1_196800_590400 5.356235
R17636 n1_m1_196800_590400 n1_m1_200000_590400 3.570824
R17637 n1_m1_201600_590400 n1_m1_200000_590400 1.785412
R17638 n1_m1_201600_590400 n1_m1_206400_590400 5.356235
R17639 n1_m1_206400_590400 n1_m1_211200_590400 5.356235
R17640 n1_m1_211200_590400 n1_m1_216000_590400 5.356235
R17641 n1_m1_216000_590400 n1_m1_220800_590400 5.356235
R17642 n1_m1_220800_590400 n1_m1_225600_590400 5.356235
R17643 n1_m1_225600_590400 n1_m1_228000_590400 2.678118
R17644 n1_m1_230400_590400 n1_m1_228000_590400 2.678118
R17645 n1_m1_230400_590400 n1_m1_235200_590400 5.356235
R17646 n1_m1_235200_590400 n1_m1_240000_590400 5.356235
R17647 n1_m1_240000_590400 n1_m1_244800_590400 5.356235
R17648 n1_m1_244800_590400 n1_m1_249600_590400 5.356235
R17649 n1_m1_249600_590400 n1_m1_254400_590400 5.356235
R17650 n1_m1_254400_590400 n1_m1_256000_590400 1.785412
R17651 n1_m1_259200_590400 n1_m1_256000_590400 3.570824
R17652 n1_m1_259200_590400 n1_m1_264000_590400 5.356235
R17653 n1_m1_264000_590400 n1_m1_268800_590400 5.356235
R17654 n1_m1_268800_590400 n1_m1_273600_590400 5.356235
R17655 n1_m1_273600_590400 n1_m1_278400_590400 5.356235
R17656 n1_m1_278400_590400 n1_m1_283200_590400 5.356235
R17657 n1_m1_283200_590400 n1_m1_284000_590400 0.892706
R17658 n1_m1_288000_590400 n1_m1_284000_590400 4.463529
R17659 n1_m1_288000_590400 n1_m1_292800_590400 5.356235
R17660 n1_m1_292800_590400 n1_m1_297600_590400 5.356235
R17661 n1_m1_297600_590400 n1_m1_302400_590400 5.356235
R17662 n1_m1_302400_590400 n1_m1_307200_590400 5.356235
R17663 n1_m1_307200_590400 n1_m1_312000_590400 5.356235
R17664 n1_m1_312000_590400 n1_m1_316800_590400 5.356235
R17665 n1_m1_316800_590400 n1_m1_321600_590400 5.356235
R17666 n1_m1_321600_590400 n1_m1_326400_590400 5.356235
R17667 n1_m1_326400_590400 n1_m1_331200_590400 5.356235
R17668 n1_m1_331200_590400 n1_m1_336000_590400 5.356235
R17669 n1_m1_336000_590400 n1_m1_340000_590400 4.463529
R17670 n1_m1_340800_590400 n1_m1_340000_590400 0.892706
R17671 n1_m1_340800_590400 n1_m1_345600_590400 5.356235
R17672 n1_m1_345600_590400 n1_m1_350400_590400 5.356235
R17673 n1_m1_350400_590400 n1_m1_355200_590400 5.356235
R17674 n1_m1_355200_590400 n1_m1_360000_590400 5.356235
R17675 n1_m1_360000_590400 n1_m1_364800_590400 5.356235
R17676 n1_m1_364800_590400 n1_m1_368000_590400 3.570824
R17677 n1_m1_369600_590400 n1_m1_368000_590400 1.785412
R17678 n1_m1_369600_590400 n1_m1_374400_590400 5.356235
R17679 n1_m1_374400_590400 n1_m1_379200_590400 5.356235
R17680 n1_m1_379200_590400 n1_m1_384000_590400 5.356235
R17681 n1_m1_384000_590400 n1_m1_388800_590400 5.356235
R17682 n1_m1_388800_590400 n1_m1_393600_590400 5.356235
R17683 n1_m1_393600_590400 n1_m1_396000_590400 2.678118
R17684 n1_m1_398400_590400 n1_m1_396000_590400 2.678118
R17685 n1_m1_398400_590400 n1_m1_403200_590400 5.356235
R17686 n1_m1_403200_590400 n1_m1_408000_590400 5.356235
R17687 n1_m1_408000_590400 n1_m1_412800_590400 5.356235
R17688 n1_m1_412800_590400 n1_m1_417600_590400 5.356235
R17689 n1_m1_417600_590400 n1_m1_422400_590400 5.356235
R17690 n1_m1_422400_590400 n1_m1_424000_590400 1.785412
R17691 n1_m1_427200_590400 n1_m1_424000_590400 3.570824
R17692 n1_m1_427200_590400 n1_m1_432000_590400 5.356235
R17693 n1_m1_432000_590400 n1_m1_436800_590400 5.356235
R17694 n1_m1_436800_590400 n1_m1_441600_590400 5.356235
R17695 n1_m1_441600_590400 n1_m1_446400_590400 5.356235
R17696 n1_m1_446400_590400 n1_m1_451200_590400 5.356235
R17697 n1_m1_451200_590400 n1_m1_452000_590400 0.892706
R17698 n1_m1_456000_590400 n1_m1_452000_590400 4.463529
R17699 n1_m1_456000_590400 n1_m1_460800_590400 5.356235
R17700 n1_m1_460800_590400 n1_m1_465600_590400 5.356235
R17701 n1_m1_465600_590400 n1_m1_470400_590400 5.356235
R17702 n1_m1_470400_590400 n1_m1_475200_590400 5.356235
R17703 n1_m1_475200_590400 n1_m1_480000_590400 5.356235
R17704 n1_m1_480000_590400 n1_m1_484800_590400 5.356235
R17705 n1_m1_484800_590400 n1_m1_489600_590400 5.356235
R17706 n1_m1_489600_590400 n1_m1_494400_590400 5.356235
R17707 n1_m1_494400_590400 n1_m1_499200_590400 5.356235
R17708 n1_m1_499200_590400 n1_m1_504000_590400 5.356235
R17709 n1_m1_504000_590400 n1_m1_508000_590400 4.463529
R17710 n1_m1_508800_590400 n1_m1_508000_590400 0.892706
R17711 n1_m1_508800_590400 n1_m1_513600_590400 5.356235
R17712 n1_m1_513600_590400 n1_m1_518400_590400 5.356235
R17713 n1_m1_518400_590400 n1_m1_523200_590400 5.356235
R17714 n1_m1_523200_590400 n1_m1_528000_590400 5.356235
R17715 n1_m1_528000_590400 n1_m1_532800_590400 5.356235
R17716 n1_m1_532800_590400 n1_m1_536000_590400 3.570824
R17717 n1_m1_537600_590400 n1_m1_536000_590400 1.785412
R17718 n1_m1_537600_590400 n1_m1_542400_590400 5.356235
R17719 n1_m1_542400_590400 n1_m1_547200_590400 5.356235
R17720 n1_m1_547200_590400 n1_m1_552000_590400 5.356235
R17721 n1_m1_552000_590400 n1_m1_556800_590400 5.356235
R17722 n1_m1_556800_590400 n1_m1_561600_590400 5.356235
R17723 n1_m1_561600_590400 n1_m1_564000_590400 2.678118
R17724 n1_m1_566400_590400 n1_m1_564000_590400 2.678118
R17725 n1_m1_566400_590400 n1_m1_571200_590400 5.356235
R17726 n1_m1_571200_590400 n1_m1_576000_590400 5.356235
R17727 n1_m1_576000_590400 n1_m1_580800_590400 5.356235
R17728 n1_m1_580800_590400 n1_m1_585600_590400 5.356235
R17729 n1_m1_585600_590400 n1_m1_590400_590400 5.356235
R17730 n1_m1_590400_590400 n1_m1_592000_590400 1.785412
R17731 n1_m1_595200_590400 n1_m1_592000_590400 3.570824
R17732 n1_m1_0_595200 n1_m1_4000_595200 4.463529
R17733 n1_m1_4800_595200 n1_m1_4000_595200 0.892706
R17734 n1_m1_4800_595200 n1_m1_9600_595200 5.356235
R17735 n1_m1_9600_595200 n1_m1_14400_595200 5.356235
R17736 n1_m1_14400_595200 n1_m1_19200_595200 5.356235
R17737 n1_m1_19200_595200 n1_m1_24000_595200 5.356235
R17738 n1_m1_24000_595200 n1_m1_28800_595200 5.356235
R17739 n1_m1_28800_595200 n1_m1_32000_595200 3.570824
R17740 n1_m1_33600_595200 n1_m1_32000_595200 1.785412
R17741 n1_m1_33600_595200 n1_m1_38400_595200 5.356235
R17742 n1_m1_38400_595200 n1_m1_43200_595200 5.356235
R17743 n1_m1_43200_595200 n1_m1_48000_595200 5.356235
R17744 n1_m1_48000_595200 n1_m1_52800_595200 5.356235
R17745 n1_m1_52800_595200 n1_m1_57600_595200 5.356235
R17746 n1_m1_57600_595200 n1_m1_60000_595200 2.678118
R17747 n1_m1_62400_595200 n1_m1_60000_595200 2.678118
R17748 n1_m1_62400_595200 n1_m1_67200_595200 5.356235
R17749 n1_m1_67200_595200 n1_m1_72000_595200 5.356235
R17750 n1_m1_72000_595200 n1_m1_76800_595200 5.356235
R17751 n1_m1_76800_595200 n1_m1_81600_595200 5.356235
R17752 n1_m1_81600_595200 n1_m1_86400_595200 5.356235
R17753 n1_m1_86400_595200 n1_m1_88000_595200 1.785412
R17754 n1_m1_91200_595200 n1_m1_88000_595200 3.570824
R17755 n1_m1_91200_595200 n1_m1_96000_595200 5.356235
R17756 n1_m1_96000_595200 n1_m1_100800_595200 5.356235
R17757 n1_m1_100800_595200 n1_m1_105600_595200 5.356235
R17758 n1_m1_105600_595200 n1_m1_110400_595200 5.356235
R17759 n1_m1_110400_595200 n1_m1_115200_595200 5.356235
R17760 n1_m1_115200_595200 n1_m1_116000_595200 0.892706
R17761 n1_m1_120000_595200 n1_m1_116000_595200 4.463529
R17762 n1_m1_120000_595200 n1_m1_124800_595200 5.356235
R17763 n1_m1_124800_595200 n1_m1_129600_595200 5.356235
R17764 n1_m1_129600_595200 n1_m1_134400_595200 5.356235
R17765 n1_m1_134400_595200 n1_m1_139200_595200 5.356235
R17766 n1_m1_139200_595200 n1_m1_144000_595200 5.356235
R17767 n1_m1_144000_595200 n1_m1_148800_595200 5.356235
R17768 n1_m1_148800_595200 n1_m1_153600_595200 5.356235
R17769 n1_m1_153600_595200 n1_m1_158400_595200 5.356235
R17770 n1_m1_158400_595200 n1_m1_163200_595200 5.356235
R17771 n1_m1_163200_595200 n1_m1_168000_595200 5.356235
R17772 n1_m1_168000_595200 n1_m1_172000_595200 4.463529
R17773 n1_m1_172800_595200 n1_m1_172000_595200 0.892706
R17774 n1_m1_172800_595200 n1_m1_177600_595200 5.356235
R17775 n1_m1_177600_595200 n1_m1_182400_595200 5.356235
R17776 n1_m1_182400_595200 n1_m1_187200_595200 5.356235
R17777 n1_m1_187200_595200 n1_m1_192000_595200 5.356235
R17778 n1_m1_192000_595200 n1_m1_196800_595200 5.356235
R17779 n1_m1_196800_595200 n1_m1_200000_595200 3.570824
R17780 n1_m1_201600_595200 n1_m1_200000_595200 1.785412
R17781 n1_m1_201600_595200 n1_m1_206400_595200 5.356235
R17782 n1_m1_206400_595200 n1_m1_211200_595200 5.356235
R17783 n1_m1_211200_595200 n1_m1_216000_595200 5.356235
R17784 n1_m1_216000_595200 n1_m1_220800_595200 5.356235
R17785 n1_m1_220800_595200 n1_m1_225600_595200 5.356235
R17786 n1_m1_225600_595200 n1_m1_228000_595200 2.678118
R17787 n1_m1_230400_595200 n1_m1_228000_595200 2.678118
R17788 n1_m1_230400_595200 n1_m1_235200_595200 5.356235
R17789 n1_m1_235200_595200 n1_m1_240000_595200 5.356235
R17790 n1_m1_240000_595200 n1_m1_244800_595200 5.356235
R17791 n1_m1_244800_595200 n1_m1_249600_595200 5.356235
R17792 n1_m1_249600_595200 n1_m1_254400_595200 5.356235
R17793 n1_m1_254400_595200 n1_m1_256000_595200 1.785412
R17794 n1_m1_259200_595200 n1_m1_256000_595200 3.570824
R17795 n1_m1_259200_595200 n1_m1_264000_595200 5.356235
R17796 n1_m1_264000_595200 n1_m1_268800_595200 5.356235
R17797 n1_m1_268800_595200 n1_m1_273600_595200 5.356235
R17798 n1_m1_273600_595200 n1_m1_278400_595200 5.356235
R17799 n1_m1_278400_595200 n1_m1_283200_595200 5.356235
R17800 n1_m1_283200_595200 n1_m1_284000_595200 0.892706
R17801 n1_m1_288000_595200 n1_m1_284000_595200 4.463529
R17802 n1_m1_288000_595200 n1_m1_292800_595200 5.356235
R17803 n1_m1_292800_595200 n1_m1_297600_595200 5.356235
R17804 n1_m1_297600_595200 n1_m1_302400_595200 5.356235
R17805 n1_m1_302400_595200 n1_m1_307200_595200 5.356235
R17806 n1_m1_307200_595200 n1_m1_312000_595200 5.356235
R17807 n1_m1_312000_595200 n1_m1_316800_595200 5.356235
R17808 n1_m1_316800_595200 n1_m1_321600_595200 5.356235
R17809 n1_m1_321600_595200 n1_m1_326400_595200 5.356235
R17810 n1_m1_326400_595200 n1_m1_331200_595200 5.356235
R17811 n1_m1_331200_595200 n1_m1_336000_595200 5.356235
R17812 n1_m1_336000_595200 n1_m1_340000_595200 4.463529
R17813 n1_m1_340800_595200 n1_m1_340000_595200 0.892706
R17814 n1_m1_340800_595200 n1_m1_345600_595200 5.356235
R17815 n1_m1_345600_595200 n1_m1_350400_595200 5.356235
R17816 n1_m1_350400_595200 n1_m1_355200_595200 5.356235
R17817 n1_m1_355200_595200 n1_m1_360000_595200 5.356235
R17818 n1_m1_360000_595200 n1_m1_364800_595200 5.356235
R17819 n1_m1_364800_595200 n1_m1_368000_595200 3.570824
R17820 n1_m1_369600_595200 n1_m1_368000_595200 1.785412
R17821 n1_m1_369600_595200 n1_m1_374400_595200 5.356235
R17822 n1_m1_374400_595200 n1_m1_379200_595200 5.356235
R17823 n1_m1_379200_595200 n1_m1_384000_595200 5.356235
R17824 n1_m1_384000_595200 n1_m1_388800_595200 5.356235
R17825 n1_m1_388800_595200 n1_m1_393600_595200 5.356235
R17826 n1_m1_393600_595200 n1_m1_396000_595200 2.678118
R17827 n1_m1_398400_595200 n1_m1_396000_595200 2.678118
R17828 n1_m1_398400_595200 n1_m1_403200_595200 5.356235
R17829 n1_m1_403200_595200 n1_m1_408000_595200 5.356235
R17830 n1_m1_408000_595200 n1_m1_412800_595200 5.356235
R17831 n1_m1_412800_595200 n1_m1_417600_595200 5.356235
R17832 n1_m1_417600_595200 n1_m1_422400_595200 5.356235
R17833 n1_m1_422400_595200 n1_m1_424000_595200 1.785412
R17834 n1_m1_427200_595200 n1_m1_424000_595200 3.570824
R17835 n1_m1_427200_595200 n1_m1_432000_595200 5.356235
R17836 n1_m1_432000_595200 n1_m1_436800_595200 5.356235
R17837 n1_m1_436800_595200 n1_m1_441600_595200 5.356235
R17838 n1_m1_441600_595200 n1_m1_446400_595200 5.356235
R17839 n1_m1_446400_595200 n1_m1_451200_595200 5.356235
R17840 n1_m1_451200_595200 n1_m1_452000_595200 0.892706
R17841 n1_m1_456000_595200 n1_m1_452000_595200 4.463529
R17842 n1_m1_456000_595200 n1_m1_460800_595200 5.356235
R17843 n1_m1_460800_595200 n1_m1_465600_595200 5.356235
R17844 n1_m1_465600_595200 n1_m1_470400_595200 5.356235
R17845 n1_m1_470400_595200 n1_m1_475200_595200 5.356235
R17846 n1_m1_475200_595200 n1_m1_480000_595200 5.356235
R17847 n1_m1_480000_595200 n1_m1_484800_595200 5.356235
R17848 n1_m1_484800_595200 n1_m1_489600_595200 5.356235
R17849 n1_m1_489600_595200 n1_m1_494400_595200 5.356235
R17850 n1_m1_494400_595200 n1_m1_499200_595200 5.356235
R17851 n1_m1_499200_595200 n1_m1_504000_595200 5.356235
R17852 n1_m1_504000_595200 n1_m1_508000_595200 4.463529
R17853 n1_m1_508800_595200 n1_m1_508000_595200 0.892706
R17854 n1_m1_508800_595200 n1_m1_513600_595200 5.356235
R17855 n1_m1_513600_595200 n1_m1_518400_595200 5.356235
R17856 n1_m1_518400_595200 n1_m1_523200_595200 5.356235
R17857 n1_m1_523200_595200 n1_m1_528000_595200 5.356235
R17858 n1_m1_528000_595200 n1_m1_532800_595200 5.356235
R17859 n1_m1_532800_595200 n1_m1_536000_595200 3.570824
R17860 n1_m1_537600_595200 n1_m1_536000_595200 1.785412
R17861 n1_m1_537600_595200 n1_m1_542400_595200 5.356235
R17862 n1_m1_542400_595200 n1_m1_547200_595200 5.356235
R17863 n1_m1_547200_595200 n1_m1_552000_595200 5.356235
R17864 n1_m1_552000_595200 n1_m1_556800_595200 5.356235
R17865 n1_m1_556800_595200 n1_m1_561600_595200 5.356235
R17866 n1_m1_561600_595200 n1_m1_564000_595200 2.678118
R17867 n1_m1_566400_595200 n1_m1_564000_595200 2.678118
R17868 n1_m1_566400_595200 n1_m1_571200_595200 5.356235
R17869 n1_m1_571200_595200 n1_m1_576000_595200 5.356235
R17870 n1_m1_576000_595200 n1_m1_580800_595200 5.356235
R17871 n1_m1_580800_595200 n1_m1_585600_595200 5.356235
R17872 n1_m1_585600_595200 n1_m1_590400_595200 5.356235
R17873 n1_m1_590400_595200 n1_m1_592000_595200 1.785412
R17874 n1_m1_595200_595200 n1_m1_592000_595200 3.570824
R17875 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R17876 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R17877 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R17878 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R17879 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R17880 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R17881 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R17882 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R17883 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R17884 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R17885 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R17886 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R17887 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R17888 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R17889 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R17890 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R17891 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R17892 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R17893 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R17894 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R17895 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R17896 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R17897 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R17898 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R17899 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R17900 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R17901 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R17902 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R17903 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R17904 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R17905 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R17906 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R17907 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R17908 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R17909 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R17910 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R17911 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R17912 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R17913 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R17914 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R17915 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R17916 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R17917 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R17918 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R17919 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R17920 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R17921 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R17922 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R17923 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R17924 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R17925 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R17926 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R17927 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R17928 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R17929 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R17930 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R17931 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R17932 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R17933 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R17934 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R17935 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R17936 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R17937 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R17938 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R17939 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R17940 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R17941 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R17942 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R17943 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R17944 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R17945 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R17946 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R17947 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R17948 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R17949 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R17950 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R17951 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R17952 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R17953 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R17954 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R17955 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R17956 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R17957 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R17958 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R17959 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R17960 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R17961 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R17962 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R17963 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R17964 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R17965 n1_m4_4000_408000 n1_m4_4000_404000 1.166667
R17966 n1_m4_4000_408000 n1_m4_4000_412800 1.400000
R17967 n1_m4_4000_412800 n1_m4_4000_417600 1.400000
R17968 n1_m4_4000_417600 n1_m4_4000_422400 1.400000
R17969 n1_m4_4000_422400 n1_m4_4000_427200 1.400000
R17970 n1_m4_4000_427200 n1_m4_4000_432000 1.400000
R17971 n1_m4_4000_432000 n1_m4_4000_436800 1.400000
R17972 n1_m4_4000_436800 n1_m4_4000_441600 1.400000
R17973 n1_m4_4000_441600 n1_m4_4000_446400 1.400000
R17974 n1_m4_4000_446400 n1_m4_4000_451200 1.400000
R17975 n1_m4_4000_451200 n1_m4_4000_456000 1.400000
R17976 n1_m4_4000_456000 n1_m4_4000_460800 1.400000
R17977 n1_m4_4000_460800 n1_m4_4000_465600 1.400000
R17978 n1_m4_4000_465600 n1_m4_4000_470400 1.400000
R17979 n1_m4_4000_470400 n1_m4_4000_475200 1.400000
R17980 n1_m4_4000_475200 n1_m4_4000_480000 1.400000
R17981 n1_m4_4000_480000 n1_m4_4000_484000 1.166667
R17982 n1_m4_4000_484800 n1_m4_4000_484000 0.233333
R17983 n1_m4_4000_484800 n1_m4_4000_489600 1.400000
R17984 n1_m4_4000_489600 n1_m4_4000_494400 1.400000
R17985 n1_m4_4000_494400 n1_m4_4000_499200 1.400000
R17986 n1_m4_4000_499200 n1_m4_4000_504000 1.400000
R17987 n1_m4_4000_504000 n1_m4_4000_508800 1.400000
R17988 n1_m4_4000_508800 n1_m4_4000_513600 1.400000
R17989 n1_m4_4000_513600 n1_m4_4000_518400 1.400000
R17990 n1_m4_4000_518400 n1_m4_4000_523200 1.400000
R17991 n1_m4_4000_523200 n1_m4_4000_528000 1.400000
R17992 n1_m4_4000_528000 n1_m4_4000_532800 1.400000
R17993 n1_m4_4000_532800 n1_m4_4000_537600 1.400000
R17994 n1_m4_4000_537600 n1_m4_4000_542400 1.400000
R17995 n1_m4_4000_542400 n1_m4_4000_547200 1.400000
R17996 n1_m4_4000_547200 n1_m4_4000_552000 1.400000
R17997 n1_m4_4000_552000 n1_m4_4000_556800 1.400000
R17998 n1_m4_4000_556800 n1_m4_4000_561600 1.400000
R17999 n1_m4_4000_561600 n1_m4_4000_564000 0.700000
R18000 n1_m4_4000_566400 n1_m4_4000_564000 0.700000
R18001 n1_m4_4000_566400 n1_m4_4000_571200 1.400000
R18002 n1_m4_4000_571200 n1_m4_4000_576000 1.400000
R18003 n1_m4_4000_576000 n1_m4_4000_580800 1.400000
R18004 n1_m4_4000_580800 n1_m4_4000_585600 1.400000
R18005 n1_m4_4000_585600 n1_m4_4000_590400 1.400000
R18006 n1_m4_4000_590400 n1_m4_4000_595200 1.400000
R18007 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R18008 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R18009 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R18010 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R18011 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R18012 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R18013 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R18014 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R18015 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R18016 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R18017 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R18018 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R18019 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R18020 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R18021 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R18022 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R18023 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R18024 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R18025 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R18026 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R18027 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R18028 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R18029 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R18030 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R18031 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R18032 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R18033 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R18034 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R18035 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R18036 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R18037 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R18038 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R18039 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R18040 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R18041 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R18042 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R18043 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R18044 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R18045 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R18046 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R18047 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R18048 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R18049 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R18050 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R18051 n1_m4_116000_196800 n1_m4_116000_201600 1.400000
R18052 n1_m4_116000_201600 n1_m4_116000_206400 1.400000
R18053 n1_m4_116000_206400 n1_m4_116000_211200 1.400000
R18054 n1_m4_116000_211200 n1_m4_116000_216000 1.400000
R18055 n1_m4_116000_216000 n1_m4_116000_220800 1.400000
R18056 n1_m4_116000_220800 n1_m4_116000_225600 1.400000
R18057 n1_m4_116000_225600 n1_m4_116000_230400 1.400000
R18058 n1_m4_116000_230400 n1_m4_116000_235200 1.400000
R18059 n1_m4_116000_235200 n1_m4_116000_240000 1.400000
R18060 n1_m4_116000_240000 n1_m4_116000_244000 1.166667
R18061 n1_m4_116000_244800 n1_m4_116000_244000 0.233333
R18062 n1_m4_116000_244800 n1_m4_116000_249600 1.400000
R18063 n1_m4_116000_249600 n1_m4_116000_254400 1.400000
R18064 n1_m4_116000_254400 n1_m4_116000_259200 1.400000
R18065 n1_m4_116000_259200 n1_m4_116000_264000 1.400000
R18066 n1_m4_116000_264000 n1_m4_116000_268800 1.400000
R18067 n1_m4_116000_268800 n1_m4_116000_273600 1.400000
R18068 n1_m4_116000_273600 n1_m4_116000_278400 1.400000
R18069 n1_m4_116000_278400 n1_m4_116000_283200 1.400000
R18070 n1_m4_116000_283200 n1_m4_116000_288000 1.400000
R18071 n1_m4_116000_288000 n1_m4_116000_292800 1.400000
R18072 n1_m4_116000_292800 n1_m4_116000_297600 1.400000
R18073 n1_m4_116000_297600 n1_m4_116000_302400 1.400000
R18074 n1_m4_116000_302400 n1_m4_116000_307200 1.400000
R18075 n1_m4_116000_307200 n1_m4_116000_312000 1.400000
R18076 n1_m4_116000_312000 n1_m4_116000_316800 1.400000
R18077 n1_m4_116000_316800 n1_m4_116000_321600 1.400000
R18078 n1_m4_116000_321600 n1_m4_116000_324000 0.700000
R18079 n1_m4_116000_326400 n1_m4_116000_324000 0.700000
R18080 n1_m4_116000_326400 n1_m4_116000_331200 1.400000
R18081 n1_m4_116000_331200 n1_m4_116000_336000 1.400000
R18082 n1_m4_116000_336000 n1_m4_116000_340800 1.400000
R18083 n1_m4_116000_340800 n1_m4_116000_345600 1.400000
R18084 n1_m4_116000_345600 n1_m4_116000_350400 1.400000
R18085 n1_m4_116000_350400 n1_m4_116000_355200 1.400000
R18086 n1_m4_116000_355200 n1_m4_116000_360000 1.400000
R18087 n1_m4_116000_360000 n1_m4_116000_364800 1.400000
R18088 n1_m4_116000_364800 n1_m4_116000_369600 1.400000
R18089 n1_m4_116000_369600 n1_m4_116000_374400 1.400000
R18090 n1_m4_116000_374400 n1_m4_116000_379200 1.400000
R18091 n1_m4_116000_379200 n1_m4_116000_384000 1.400000
R18092 n1_m4_116000_384000 n1_m4_116000_388800 1.400000
R18093 n1_m4_116000_388800 n1_m4_116000_393600 1.400000
R18094 n1_m4_116000_393600 n1_m4_116000_398400 1.400000
R18095 n1_m4_116000_398400 n1_m4_116000_403200 1.400000
R18096 n1_m4_116000_403200 n1_m4_116000_404000 0.233333
R18097 n1_m4_116000_408000 n1_m4_116000_404000 1.166667
R18098 n1_m4_116000_408000 n1_m4_116000_412800 1.400000
R18099 n1_m4_116000_412800 n1_m4_116000_417600 1.400000
R18100 n1_m4_116000_417600 n1_m4_116000_422400 1.400000
R18101 n1_m4_116000_422400 n1_m4_116000_427200 1.400000
R18102 n1_m4_116000_427200 n1_m4_116000_432000 1.400000
R18103 n1_m4_116000_432000 n1_m4_116000_436800 1.400000
R18104 n1_m4_116000_436800 n1_m4_116000_441600 1.400000
R18105 n1_m4_116000_441600 n1_m4_116000_446400 1.400000
R18106 n1_m4_116000_446400 n1_m4_116000_451200 1.400000
R18107 n1_m4_116000_451200 n1_m4_116000_456000 1.400000
R18108 n1_m4_116000_456000 n1_m4_116000_460800 1.400000
R18109 n1_m4_116000_460800 n1_m4_116000_465600 1.400000
R18110 n1_m4_116000_465600 n1_m4_116000_470400 1.400000
R18111 n1_m4_116000_470400 n1_m4_116000_475200 1.400000
R18112 n1_m4_116000_475200 n1_m4_116000_480000 1.400000
R18113 n1_m4_116000_480000 n1_m4_116000_484000 1.166667
R18114 n1_m4_116000_484800 n1_m4_116000_484000 0.233333
R18115 n1_m4_116000_484800 n1_m4_116000_489600 1.400000
R18116 n1_m4_116000_489600 n1_m4_116000_494400 1.400000
R18117 n1_m4_116000_494400 n1_m4_116000_499200 1.400000
R18118 n1_m4_116000_499200 n1_m4_116000_504000 1.400000
R18119 n1_m4_116000_504000 n1_m4_116000_508800 1.400000
R18120 n1_m4_116000_508800 n1_m4_116000_513600 1.400000
R18121 n1_m4_116000_513600 n1_m4_116000_518400 1.400000
R18122 n1_m4_116000_518400 n1_m4_116000_523200 1.400000
R18123 n1_m4_116000_523200 n1_m4_116000_528000 1.400000
R18124 n1_m4_116000_528000 n1_m4_116000_532800 1.400000
R18125 n1_m4_116000_532800 n1_m4_116000_537600 1.400000
R18126 n1_m4_116000_537600 n1_m4_116000_542400 1.400000
R18127 n1_m4_116000_542400 n1_m4_116000_547200 1.400000
R18128 n1_m4_116000_547200 n1_m4_116000_552000 1.400000
R18129 n1_m4_116000_552000 n1_m4_116000_556800 1.400000
R18130 n1_m4_116000_556800 n1_m4_116000_561600 1.400000
R18131 n1_m4_116000_561600 n1_m4_116000_564000 0.700000
R18132 n1_m4_116000_566400 n1_m4_116000_564000 0.700000
R18133 n1_m4_116000_566400 n1_m4_116000_571200 1.400000
R18134 n1_m4_116000_571200 n1_m4_116000_576000 1.400000
R18135 n1_m4_116000_576000 n1_m4_116000_580800 1.400000
R18136 n1_m4_116000_580800 n1_m4_116000_585600 1.400000
R18137 n1_m4_116000_585600 n1_m4_116000_590400 1.400000
R18138 n1_m4_116000_590400 n1_m4_116000_595200 1.400000
R18139 n1_m4_312000_0 n1_m4_312000_4000 1.166667
R18140 n1_m4_312000_4800 n1_m4_312000_4000 0.233333
R18141 n1_m4_312000_4800 n1_m4_312000_9600 1.400000
R18142 n1_m4_312000_9600 n1_m4_312000_14400 1.400000
R18143 n1_m4_312000_14400 n1_m4_312000_19200 1.400000
R18144 n1_m4_312000_19200 n1_m4_312000_24000 1.400000
R18145 n1_m4_312000_24000 n1_m4_312000_28800 1.400000
R18146 n1_m4_312000_28800 n1_m4_312000_33600 1.400000
R18147 n1_m4_312000_33600 n1_m4_312000_38400 1.400000
R18148 n1_m4_312000_38400 n1_m4_312000_43200 1.400000
R18149 n1_m4_312000_43200 n1_m4_312000_48000 1.400000
R18150 n1_m4_312000_48000 n1_m4_312000_52800 1.400000
R18151 n1_m4_312000_52800 n1_m4_312000_57600 1.400000
R18152 n1_m4_312000_57600 n1_m4_312000_62400 1.400000
R18153 n1_m4_312000_62400 n1_m4_312000_67200 1.400000
R18154 n1_m4_312000_67200 n1_m4_312000_72000 1.400000
R18155 n1_m4_312000_72000 n1_m4_312000_76800 1.400000
R18156 n1_m4_312000_76800 n1_m4_312000_81600 1.400000
R18157 n1_m4_312000_81600 n1_m4_312000_84000 0.700000
R18158 n1_m4_312000_86400 n1_m4_312000_84000 0.700000
R18159 n1_m4_312000_86400 n1_m4_312000_91200 1.400000
R18160 n1_m4_312000_91200 n1_m4_312000_96000 1.400000
R18161 n1_m4_312000_96000 n1_m4_312000_100800 1.400000
R18162 n1_m4_312000_100800 n1_m4_312000_105600 1.400000
R18163 n1_m4_312000_105600 n1_m4_312000_110400 1.400000
R18164 n1_m4_312000_110400 n1_m4_312000_115200 1.400000
R18165 n1_m4_312000_115200 n1_m4_312000_120000 1.400000
R18166 n1_m4_312000_120000 n1_m4_312000_124800 1.400000
R18167 n1_m4_312000_124800 n1_m4_312000_129600 1.400000
R18168 n1_m4_312000_129600 n1_m4_312000_134400 1.400000
R18169 n1_m4_312000_134400 n1_m4_312000_139200 1.400000
R18170 n1_m4_312000_139200 n1_m4_312000_144000 1.400000
R18171 n1_m4_312000_144000 n1_m4_312000_148800 1.400000
R18172 n1_m4_312000_148800 n1_m4_312000_153600 1.400000
R18173 n1_m4_312000_153600 n1_m4_312000_158400 1.400000
R18174 n1_m4_312000_158400 n1_m4_312000_163200 1.400000
R18175 n1_m4_312000_163200 n1_m4_312000_164000 0.233333
R18176 n1_m4_312000_168000 n1_m4_312000_164000 1.166667
R18177 n1_m4_312000_168000 n1_m4_312000_172800 1.400000
R18178 n1_m4_312000_172800 n1_m4_312000_177600 1.400000
R18179 n1_m4_312000_177600 n1_m4_312000_182400 1.400000
R18180 n1_m4_312000_182400 n1_m4_312000_187200 1.400000
R18181 n1_m4_312000_187200 n1_m4_312000_192000 1.400000
R18182 n1_m4_312000_192000 n1_m4_312000_196800 1.400000
R18183 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R18184 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R18185 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R18186 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R18187 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R18188 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R18189 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R18190 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R18191 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R18192 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R18193 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R18194 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R18195 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R18196 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R18197 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R18198 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R18199 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R18200 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R18201 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R18202 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R18203 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R18204 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R18205 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R18206 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R18207 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R18208 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R18209 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R18210 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R18211 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R18212 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R18213 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R18214 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R18215 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R18216 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R18217 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R18218 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R18219 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R18220 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R18221 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R18222 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R18223 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R18224 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R18225 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R18226 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R18227 n1_m4_312000_398400 n1_m4_312000_403200 1.400000
R18228 n1_m4_312000_403200 n1_m4_312000_404000 0.233333
R18229 n1_m4_312000_408000 n1_m4_312000_404000 1.166667
R18230 n1_m4_312000_408000 n1_m4_312000_412800 1.400000
R18231 n1_m4_312000_412800 n1_m4_312000_417600 1.400000
R18232 n1_m4_312000_417600 n1_m4_312000_422400 1.400000
R18233 n1_m4_312000_422400 n1_m4_312000_427200 1.400000
R18234 n1_m4_312000_427200 n1_m4_312000_432000 1.400000
R18235 n1_m4_312000_432000 n1_m4_312000_436800 1.400000
R18236 n1_m4_312000_436800 n1_m4_312000_441600 1.400000
R18237 n1_m4_312000_441600 n1_m4_312000_446400 1.400000
R18238 n1_m4_312000_446400 n1_m4_312000_451200 1.400000
R18239 n1_m4_312000_451200 n1_m4_312000_456000 1.400000
R18240 n1_m4_312000_456000 n1_m4_312000_460800 1.400000
R18241 n1_m4_312000_460800 n1_m4_312000_465600 1.400000
R18242 n1_m4_312000_465600 n1_m4_312000_470400 1.400000
R18243 n1_m4_312000_470400 n1_m4_312000_475200 1.400000
R18244 n1_m4_312000_475200 n1_m4_312000_480000 1.400000
R18245 n1_m4_312000_480000 n1_m4_312000_484000 1.166667
R18246 n1_m4_312000_484800 n1_m4_312000_484000 0.233333
R18247 n1_m4_312000_484800 n1_m4_312000_489600 1.400000
R18248 n1_m4_312000_489600 n1_m4_312000_494400 1.400000
R18249 n1_m4_312000_494400 n1_m4_312000_499200 1.400000
R18250 n1_m4_312000_499200 n1_m4_312000_504000 1.400000
R18251 n1_m4_312000_504000 n1_m4_312000_508800 1.400000
R18252 n1_m4_312000_508800 n1_m4_312000_513600 1.400000
R18253 n1_m4_312000_513600 n1_m4_312000_518400 1.400000
R18254 n1_m4_312000_518400 n1_m4_312000_523200 1.400000
R18255 n1_m4_312000_523200 n1_m4_312000_528000 1.400000
R18256 n1_m4_312000_528000 n1_m4_312000_532800 1.400000
R18257 n1_m4_312000_532800 n1_m4_312000_537600 1.400000
R18258 n1_m4_312000_537600 n1_m4_312000_542400 1.400000
R18259 n1_m4_312000_542400 n1_m4_312000_547200 1.400000
R18260 n1_m4_312000_547200 n1_m4_312000_552000 1.400000
R18261 n1_m4_312000_552000 n1_m4_312000_556800 1.400000
R18262 n1_m4_312000_556800 n1_m4_312000_561600 1.400000
R18263 n1_m4_312000_561600 n1_m4_312000_564000 0.700000
R18264 n1_m4_312000_566400 n1_m4_312000_564000 0.700000
R18265 n1_m4_312000_566400 n1_m4_312000_571200 1.400000
R18266 n1_m4_312000_571200 n1_m4_312000_576000 1.400000
R18267 n1_m4_312000_576000 n1_m4_312000_580800 1.400000
R18268 n1_m4_312000_580800 n1_m4_312000_585600 1.400000
R18269 n1_m4_312000_585600 n1_m4_312000_590400 1.400000
R18270 n1_m4_312000_590400 n1_m4_312000_595200 1.400000
R18271 n1_m4_424000_0 n1_m4_424000_4000 1.166667
R18272 n1_m4_424000_4800 n1_m4_424000_4000 0.233333
R18273 n1_m4_424000_4800 n1_m4_424000_9600 1.400000
R18274 n1_m4_424000_9600 n1_m4_424000_14400 1.400000
R18275 n1_m4_424000_14400 n1_m4_424000_19200 1.400000
R18276 n1_m4_424000_19200 n1_m4_424000_24000 1.400000
R18277 n1_m4_424000_24000 n1_m4_424000_28800 1.400000
R18278 n1_m4_424000_28800 n1_m4_424000_33600 1.400000
R18279 n1_m4_424000_33600 n1_m4_424000_38400 1.400000
R18280 n1_m4_424000_38400 n1_m4_424000_43200 1.400000
R18281 n1_m4_424000_43200 n1_m4_424000_48000 1.400000
R18282 n1_m4_424000_48000 n1_m4_424000_52800 1.400000
R18283 n1_m4_424000_52800 n1_m4_424000_57600 1.400000
R18284 n1_m4_424000_57600 n1_m4_424000_62400 1.400000
R18285 n1_m4_424000_62400 n1_m4_424000_67200 1.400000
R18286 n1_m4_424000_67200 n1_m4_424000_72000 1.400000
R18287 n1_m4_424000_72000 n1_m4_424000_76800 1.400000
R18288 n1_m4_424000_76800 n1_m4_424000_81600 1.400000
R18289 n1_m4_424000_81600 n1_m4_424000_84000 0.700000
R18290 n1_m4_424000_86400 n1_m4_424000_84000 0.700000
R18291 n1_m4_424000_86400 n1_m4_424000_91200 1.400000
R18292 n1_m4_424000_91200 n1_m4_424000_96000 1.400000
R18293 n1_m4_424000_96000 n1_m4_424000_100800 1.400000
R18294 n1_m4_424000_100800 n1_m4_424000_105600 1.400000
R18295 n1_m4_424000_105600 n1_m4_424000_110400 1.400000
R18296 n1_m4_424000_110400 n1_m4_424000_115200 1.400000
R18297 n1_m4_424000_115200 n1_m4_424000_120000 1.400000
R18298 n1_m4_424000_120000 n1_m4_424000_124800 1.400000
R18299 n1_m4_424000_124800 n1_m4_424000_129600 1.400000
R18300 n1_m4_424000_129600 n1_m4_424000_134400 1.400000
R18301 n1_m4_424000_134400 n1_m4_424000_139200 1.400000
R18302 n1_m4_424000_139200 n1_m4_424000_144000 1.400000
R18303 n1_m4_424000_144000 n1_m4_424000_148800 1.400000
R18304 n1_m4_424000_148800 n1_m4_424000_153600 1.400000
R18305 n1_m4_424000_153600 n1_m4_424000_158400 1.400000
R18306 n1_m4_424000_158400 n1_m4_424000_163200 1.400000
R18307 n1_m4_424000_163200 n1_m4_424000_164000 0.233333
R18308 n1_m4_424000_168000 n1_m4_424000_164000 1.166667
R18309 n1_m4_424000_168000 n1_m4_424000_172800 1.400000
R18310 n1_m4_424000_172800 n1_m4_424000_177600 1.400000
R18311 n1_m4_424000_177600 n1_m4_424000_182400 1.400000
R18312 n1_m4_424000_182400 n1_m4_424000_187200 1.400000
R18313 n1_m4_424000_187200 n1_m4_424000_192000 1.400000
R18314 n1_m4_424000_192000 n1_m4_424000_196800 1.400000
R18315 n1_m4_424000_196800 n1_m4_424000_201600 1.400000
R18316 n1_m4_424000_201600 n1_m4_424000_206400 1.400000
R18317 n1_m4_424000_206400 n1_m4_424000_211200 1.400000
R18318 n1_m4_424000_211200 n1_m4_424000_216000 1.400000
R18319 n1_m4_424000_216000 n1_m4_424000_220800 1.400000
R18320 n1_m4_424000_220800 n1_m4_424000_225600 1.400000
R18321 n1_m4_424000_225600 n1_m4_424000_230400 1.400000
R18322 n1_m4_424000_230400 n1_m4_424000_235200 1.400000
R18323 n1_m4_424000_235200 n1_m4_424000_240000 1.400000
R18324 n1_m4_424000_240000 n1_m4_424000_244000 1.166667
R18325 n1_m4_424000_244800 n1_m4_424000_244000 0.233333
R18326 n1_m4_424000_244800 n1_m4_424000_249600 1.400000
R18327 n1_m4_424000_249600 n1_m4_424000_254400 1.400000
R18328 n1_m4_424000_254400 n1_m4_424000_259200 1.400000
R18329 n1_m4_424000_259200 n1_m4_424000_264000 1.400000
R18330 n1_m4_424000_264000 n1_m4_424000_268800 1.400000
R18331 n1_m4_424000_268800 n1_m4_424000_273600 1.400000
R18332 n1_m4_424000_273600 n1_m4_424000_278400 1.400000
R18333 n1_m4_424000_278400 n1_m4_424000_283200 1.400000
R18334 n1_m4_424000_283200 n1_m4_424000_288000 1.400000
R18335 n1_m4_424000_288000 n1_m4_424000_292800 1.400000
R18336 n1_m4_424000_292800 n1_m4_424000_297600 1.400000
R18337 n1_m4_424000_297600 n1_m4_424000_302400 1.400000
R18338 n1_m4_424000_302400 n1_m4_424000_307200 1.400000
R18339 n1_m4_424000_307200 n1_m4_424000_312000 1.400000
R18340 n1_m4_424000_312000 n1_m4_424000_316800 1.400000
R18341 n1_m4_424000_316800 n1_m4_424000_321600 1.400000
R18342 n1_m4_424000_321600 n1_m4_424000_324000 0.700000
R18343 n1_m4_424000_326400 n1_m4_424000_324000 0.700000
R18344 n1_m4_424000_326400 n1_m4_424000_331200 1.400000
R18345 n1_m4_424000_331200 n1_m4_424000_336000 1.400000
R18346 n1_m4_424000_336000 n1_m4_424000_340800 1.400000
R18347 n1_m4_424000_340800 n1_m4_424000_345600 1.400000
R18348 n1_m4_424000_345600 n1_m4_424000_350400 1.400000
R18349 n1_m4_424000_350400 n1_m4_424000_355200 1.400000
R18350 n1_m4_424000_355200 n1_m4_424000_360000 1.400000
R18351 n1_m4_424000_360000 n1_m4_424000_364800 1.400000
R18352 n1_m4_424000_364800 n1_m4_424000_369600 1.400000
R18353 n1_m4_424000_369600 n1_m4_424000_374400 1.400000
R18354 n1_m4_424000_374400 n1_m4_424000_379200 1.400000
R18355 n1_m4_424000_379200 n1_m4_424000_384000 1.400000
R18356 n1_m4_424000_384000 n1_m4_424000_388800 1.400000
R18357 n1_m4_424000_388800 n1_m4_424000_393600 1.400000
R18358 n1_m4_424000_393600 n1_m4_424000_398400 1.400000
R18359 n1_m4_424000_398400 n1_m4_424000_403200 1.400000
R18360 n1_m4_424000_403200 n1_m4_424000_404000 0.233333
R18361 n1_m4_424000_408000 n1_m4_424000_404000 1.166667
R18362 n1_m4_424000_408000 n1_m4_424000_412800 1.400000
R18363 n1_m4_424000_412800 n1_m4_424000_417600 1.400000
R18364 n1_m4_424000_417600 n1_m4_424000_422400 1.400000
R18365 n1_m4_424000_422400 n1_m4_424000_427200 1.400000
R18366 n1_m4_424000_427200 n1_m4_424000_432000 1.400000
R18367 n1_m4_424000_432000 n1_m4_424000_436800 1.400000
R18368 n1_m4_424000_436800 n1_m4_424000_441600 1.400000
R18369 n1_m4_424000_441600 n1_m4_424000_446400 1.400000
R18370 n1_m4_424000_446400 n1_m4_424000_451200 1.400000
R18371 n1_m4_424000_451200 n1_m4_424000_456000 1.400000
R18372 n1_m4_424000_456000 n1_m4_424000_460800 1.400000
R18373 n1_m4_424000_460800 n1_m4_424000_465600 1.400000
R18374 n1_m4_424000_465600 n1_m4_424000_470400 1.400000
R18375 n1_m4_424000_470400 n1_m4_424000_475200 1.400000
R18376 n1_m4_424000_475200 n1_m4_424000_480000 1.400000
R18377 n1_m4_424000_480000 n1_m4_424000_484000 1.166667
R18378 n1_m4_424000_484800 n1_m4_424000_484000 0.233333
R18379 n1_m4_424000_484800 n1_m4_424000_489600 1.400000
R18380 n1_m4_424000_489600 n1_m4_424000_494400 1.400000
R18381 n1_m4_424000_494400 n1_m4_424000_499200 1.400000
R18382 n1_m4_424000_499200 n1_m4_424000_504000 1.400000
R18383 n1_m4_424000_504000 n1_m4_424000_508800 1.400000
R18384 n1_m4_424000_508800 n1_m4_424000_513600 1.400000
R18385 n1_m4_424000_513600 n1_m4_424000_518400 1.400000
R18386 n1_m4_424000_518400 n1_m4_424000_523200 1.400000
R18387 n1_m4_424000_523200 n1_m4_424000_528000 1.400000
R18388 n1_m4_424000_528000 n1_m4_424000_532800 1.400000
R18389 n1_m4_424000_532800 n1_m4_424000_537600 1.400000
R18390 n1_m4_424000_537600 n1_m4_424000_542400 1.400000
R18391 n1_m4_424000_542400 n1_m4_424000_547200 1.400000
R18392 n1_m4_424000_547200 n1_m4_424000_552000 1.400000
R18393 n1_m4_424000_552000 n1_m4_424000_556800 1.400000
R18394 n1_m4_424000_556800 n1_m4_424000_561600 1.400000
R18395 n1_m4_424000_561600 n1_m4_424000_564000 0.700000
R18396 n1_m4_424000_566400 n1_m4_424000_564000 0.700000
R18397 n1_m4_424000_566400 n1_m4_424000_571200 1.400000
R18398 n1_m4_424000_571200 n1_m4_424000_576000 1.400000
R18399 n1_m4_424000_576000 n1_m4_424000_580800 1.400000
R18400 n1_m4_424000_580800 n1_m4_424000_585600 1.400000
R18401 n1_m4_424000_585600 n1_m4_424000_590400 1.400000
R18402 n1_m4_424000_590400 n1_m4_424000_595200 1.400000
R18403 n1_m4_536000_0 n1_m4_536000_4000 1.166667
R18404 n1_m4_536000_4800 n1_m4_536000_4000 0.233333
R18405 n1_m4_536000_4800 n1_m4_536000_9600 1.400000
R18406 n1_m4_536000_9600 n1_m4_536000_14400 1.400000
R18407 n1_m4_536000_14400 n1_m4_536000_19200 1.400000
R18408 n1_m4_536000_19200 n1_m4_536000_24000 1.400000
R18409 n1_m4_536000_24000 n1_m4_536000_28800 1.400000
R18410 n1_m4_536000_28800 n1_m4_536000_33600 1.400000
R18411 n1_m4_536000_33600 n1_m4_536000_38400 1.400000
R18412 n1_m4_536000_38400 n1_m4_536000_43200 1.400000
R18413 n1_m4_536000_43200 n1_m4_536000_48000 1.400000
R18414 n1_m4_536000_48000 n1_m4_536000_52800 1.400000
R18415 n1_m4_536000_52800 n1_m4_536000_57600 1.400000
R18416 n1_m4_536000_57600 n1_m4_536000_62400 1.400000
R18417 n1_m4_536000_62400 n1_m4_536000_67200 1.400000
R18418 n1_m4_536000_67200 n1_m4_536000_72000 1.400000
R18419 n1_m4_536000_72000 n1_m4_536000_76800 1.400000
R18420 n1_m4_536000_76800 n1_m4_536000_81600 1.400000
R18421 n1_m4_536000_81600 n1_m4_536000_84000 0.700000
R18422 n1_m4_536000_86400 n1_m4_536000_84000 0.700000
R18423 n1_m4_536000_86400 n1_m4_536000_91200 1.400000
R18424 n1_m4_536000_91200 n1_m4_536000_96000 1.400000
R18425 n1_m4_536000_96000 n1_m4_536000_100800 1.400000
R18426 n1_m4_536000_100800 n1_m4_536000_105600 1.400000
R18427 n1_m4_536000_105600 n1_m4_536000_110400 1.400000
R18428 n1_m4_536000_110400 n1_m4_536000_115200 1.400000
R18429 n1_m4_536000_115200 n1_m4_536000_120000 1.400000
R18430 n1_m4_536000_120000 n1_m4_536000_124800 1.400000
R18431 n1_m4_536000_124800 n1_m4_536000_129600 1.400000
R18432 n1_m4_536000_129600 n1_m4_536000_134400 1.400000
R18433 n1_m4_536000_134400 n1_m4_536000_139200 1.400000
R18434 n1_m4_536000_139200 n1_m4_536000_144000 1.400000
R18435 n1_m4_536000_144000 n1_m4_536000_148800 1.400000
R18436 n1_m4_536000_148800 n1_m4_536000_153600 1.400000
R18437 n1_m4_536000_153600 n1_m4_536000_158400 1.400000
R18438 n1_m4_536000_158400 n1_m4_536000_163200 1.400000
R18439 n1_m4_536000_163200 n1_m4_536000_164000 0.233333
R18440 n1_m4_536000_168000 n1_m4_536000_164000 1.166667
R18441 n1_m4_536000_168000 n1_m4_536000_172800 1.400000
R18442 n1_m4_536000_172800 n1_m4_536000_177600 1.400000
R18443 n1_m4_536000_177600 n1_m4_536000_182400 1.400000
R18444 n1_m4_536000_182400 n1_m4_536000_187200 1.400000
R18445 n1_m4_536000_187200 n1_m4_536000_192000 1.400000
R18446 n1_m4_536000_192000 n1_m4_536000_196800 1.400000
R18447 n1_m4_536000_196800 n1_m4_536000_201600 1.400000
R18448 n1_m4_536000_201600 n1_m4_536000_206400 1.400000
R18449 n1_m4_536000_206400 n1_m4_536000_211200 1.400000
R18450 n1_m4_536000_211200 n1_m4_536000_216000 1.400000
R18451 n1_m4_536000_216000 n1_m4_536000_220800 1.400000
R18452 n1_m4_536000_220800 n1_m4_536000_225600 1.400000
R18453 n1_m4_536000_225600 n1_m4_536000_230400 1.400000
R18454 n1_m4_536000_230400 n1_m4_536000_235200 1.400000
R18455 n1_m4_536000_235200 n1_m4_536000_240000 1.400000
R18456 n1_m4_536000_240000 n1_m4_536000_244000 1.166667
R18457 n1_m4_536000_244800 n1_m4_536000_244000 0.233333
R18458 n1_m4_536000_244800 n1_m4_536000_249600 1.400000
R18459 n1_m4_536000_249600 n1_m4_536000_254400 1.400000
R18460 n1_m4_536000_254400 n1_m4_536000_259200 1.400000
R18461 n1_m4_536000_259200 n1_m4_536000_264000 1.400000
R18462 n1_m4_536000_264000 n1_m4_536000_268800 1.400000
R18463 n1_m4_536000_268800 n1_m4_536000_273600 1.400000
R18464 n1_m4_536000_273600 n1_m4_536000_278400 1.400000
R18465 n1_m4_536000_278400 n1_m4_536000_283200 1.400000
R18466 n1_m4_536000_283200 n1_m4_536000_288000 1.400000
R18467 n1_m4_536000_288000 n1_m4_536000_292800 1.400000
R18468 n1_m4_536000_292800 n1_m4_536000_297600 1.400000
R18469 n1_m4_536000_297600 n1_m4_536000_302400 1.400000
R18470 n1_m4_536000_302400 n1_m4_536000_307200 1.400000
R18471 n1_m4_536000_307200 n1_m4_536000_312000 1.400000
R18472 n1_m4_536000_312000 n1_m4_536000_316800 1.400000
R18473 n1_m4_536000_316800 n1_m4_536000_321600 1.400000
R18474 n1_m4_536000_321600 n1_m4_536000_324000 0.700000
R18475 n1_m4_536000_326400 n1_m4_536000_324000 0.700000
R18476 n1_m4_536000_326400 n1_m4_536000_331200 1.400000
R18477 n1_m4_536000_331200 n1_m4_536000_336000 1.400000
R18478 n1_m4_536000_336000 n1_m4_536000_340800 1.400000
R18479 n1_m4_536000_340800 n1_m4_536000_345600 1.400000
R18480 n1_m4_536000_345600 n1_m4_536000_350400 1.400000
R18481 n1_m4_536000_350400 n1_m4_536000_355200 1.400000
R18482 n1_m4_536000_355200 n1_m4_536000_360000 1.400000
R18483 n1_m4_536000_360000 n1_m4_536000_364800 1.400000
R18484 n1_m4_536000_364800 n1_m4_536000_369600 1.400000
R18485 n1_m4_536000_369600 n1_m4_536000_374400 1.400000
R18486 n1_m4_536000_374400 n1_m4_536000_379200 1.400000
R18487 n1_m4_536000_379200 n1_m4_536000_384000 1.400000
R18488 n1_m4_536000_384000 n1_m4_536000_388800 1.400000
R18489 n1_m4_536000_388800 n1_m4_536000_393600 1.400000
R18490 n1_m4_536000_393600 n1_m4_536000_398400 1.400000
R18491 n1_m4_536000_398400 n1_m4_536000_403200 1.400000
R18492 n1_m4_536000_403200 n1_m4_536000_404000 0.233333
R18493 n1_m4_536000_408000 n1_m4_536000_404000 1.166667
R18494 n1_m4_536000_408000 n1_m4_536000_412800 1.400000
R18495 n1_m4_536000_412800 n1_m4_536000_417600 1.400000
R18496 n1_m4_536000_417600 n1_m4_536000_422400 1.400000
R18497 n1_m4_536000_422400 n1_m4_536000_427200 1.400000
R18498 n1_m4_536000_427200 n1_m4_536000_432000 1.400000
R18499 n1_m4_536000_432000 n1_m4_536000_436800 1.400000
R18500 n1_m4_536000_436800 n1_m4_536000_441600 1.400000
R18501 n1_m4_536000_441600 n1_m4_536000_446400 1.400000
R18502 n1_m4_536000_446400 n1_m4_536000_451200 1.400000
R18503 n1_m4_536000_451200 n1_m4_536000_456000 1.400000
R18504 n1_m4_536000_456000 n1_m4_536000_460800 1.400000
R18505 n1_m4_536000_460800 n1_m4_536000_465600 1.400000
R18506 n1_m4_536000_465600 n1_m4_536000_470400 1.400000
R18507 n1_m4_536000_470400 n1_m4_536000_475200 1.400000
R18508 n1_m4_536000_475200 n1_m4_536000_480000 1.400000
R18509 n1_m4_536000_480000 n1_m4_536000_484000 1.166667
R18510 n1_m4_536000_484800 n1_m4_536000_484000 0.233333
R18511 n1_m4_536000_484800 n1_m4_536000_489600 1.400000
R18512 n1_m4_536000_489600 n1_m4_536000_494400 1.400000
R18513 n1_m4_536000_494400 n1_m4_536000_499200 1.400000
R18514 n1_m4_536000_499200 n1_m4_536000_504000 1.400000
R18515 n1_m4_536000_504000 n1_m4_536000_508800 1.400000
R18516 n1_m4_536000_508800 n1_m4_536000_513600 1.400000
R18517 n1_m4_536000_513600 n1_m4_536000_518400 1.400000
R18518 n1_m4_536000_518400 n1_m4_536000_523200 1.400000
R18519 n1_m4_536000_523200 n1_m4_536000_528000 1.400000
R18520 n1_m4_536000_528000 n1_m4_536000_532800 1.400000
R18521 n1_m4_536000_532800 n1_m4_536000_537600 1.400000
R18522 n1_m4_536000_537600 n1_m4_536000_542400 1.400000
R18523 n1_m4_536000_542400 n1_m4_536000_547200 1.400000
R18524 n1_m4_536000_547200 n1_m4_536000_552000 1.400000
R18525 n1_m4_536000_552000 n1_m4_536000_556800 1.400000
R18526 n1_m4_536000_556800 n1_m4_536000_561600 1.400000
R18527 n1_m4_536000_561600 n1_m4_536000_564000 0.700000
R18528 n1_m4_536000_566400 n1_m4_536000_564000 0.700000
R18529 n1_m4_536000_566400 n1_m4_536000_571200 1.400000
R18530 n1_m4_536000_571200 n1_m4_536000_576000 1.400000
R18531 n1_m4_536000_576000 n1_m4_536000_580800 1.400000
R18532 n1_m4_536000_580800 n1_m4_536000_585600 1.400000
R18533 n1_m4_536000_585600 n1_m4_536000_590400 1.400000
R18534 n1_m4_536000_590400 n1_m4_536000_595200 1.400000
R18535 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R18536 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R18537 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R18538 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R18539 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R18540 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R18541 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R18542 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R18543 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R18544 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R18545 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R18546 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R18547 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R18548 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R18549 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R18550 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R18551 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R18552 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R18553 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R18554 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R18555 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R18556 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R18557 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R18558 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R18559 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R18560 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R18561 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R18562 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R18563 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R18564 n1_m7_424000_4000 n1_m7_407200_4000 0.445680
R18565 n1_m7_424000_4000 n1_m7_429600_4000 0.148560
R18566 n1_m7_452000_4000 n1_m7_429600_4000 0.594240
R18567 n1_m7_452000_4000 n1_m7_474400_4000 0.594240
R18568 n1_m7_480000_4000 n1_m7_474400_4000 0.148560
R18569 n1_m7_480000_4000 n1_m7_496800_4000 0.445680
R18570 n1_m7_508000_4000 n1_m7_496800_4000 0.297120
R18571 n1_m7_508000_4000 n1_m7_519200_4000 0.297120
R18572 n1_m7_536000_4000 n1_m7_519200_4000 0.445680
R18573 n1_m7_536000_4000 n1_m7_541600_4000 0.148560
R18574 n1_m7_564000_4000 n1_m7_541600_4000 0.594240
R18575 n1_m7_564000_4000 n1_m7_586400_4000 0.594240
R18576 n1_m7_592000_4000 n1_m7_586400_4000 0.148560
R18577 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R18578 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R18579 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R18580 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R18581 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R18582 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R18583 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R18584 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R18585 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R18586 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R18587 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R18588 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R18589 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R18590 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R18591 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R18592 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R18593 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R18594 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R18595 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R18596 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R18597 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R18598 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R18599 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R18600 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R18601 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R18602 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R18603 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R18604 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R18605 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R18606 n1_m7_424000_84000 n1_m7_407200_84000 0.445680
R18607 n1_m7_424000_84000 n1_m7_429600_84000 0.148560
R18608 n1_m7_452000_84000 n1_m7_429600_84000 0.594240
R18609 n1_m7_452000_84000 n1_m7_474400_84000 0.594240
R18610 n1_m7_480000_84000 n1_m7_474400_84000 0.148560
R18611 n1_m7_480000_84000 n1_m7_496800_84000 0.445680
R18612 n1_m7_508000_84000 n1_m7_496800_84000 0.297120
R18613 n1_m7_508000_84000 n1_m7_519200_84000 0.297120
R18614 n1_m7_536000_84000 n1_m7_519200_84000 0.445680
R18615 n1_m7_536000_84000 n1_m7_541600_84000 0.148560
R18616 n1_m7_564000_84000 n1_m7_541600_84000 0.594240
R18617 n1_m7_564000_84000 n1_m7_586400_84000 0.594240
R18618 n1_m7_592000_84000 n1_m7_586400_84000 0.148560
R18619 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R18620 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R18621 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R18622 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R18623 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R18624 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R18625 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R18626 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R18627 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R18628 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R18629 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R18630 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R18631 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R18632 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R18633 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R18634 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R18635 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R18636 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R18637 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R18638 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R18639 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R18640 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R18641 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R18642 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R18643 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R18644 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R18645 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R18646 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R18647 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R18648 n1_m7_424000_164000 n1_m7_407200_164000 0.445680
R18649 n1_m7_424000_164000 n1_m7_429600_164000 0.148560
R18650 n1_m7_452000_164000 n1_m7_429600_164000 0.594240
R18651 n1_m7_452000_164000 n1_m7_474400_164000 0.594240
R18652 n1_m7_480000_164000 n1_m7_474400_164000 0.148560
R18653 n1_m7_480000_164000 n1_m7_496800_164000 0.445680
R18654 n1_m7_508000_164000 n1_m7_496800_164000 0.297120
R18655 n1_m7_508000_164000 n1_m7_519200_164000 0.297120
R18656 n1_m7_536000_164000 n1_m7_519200_164000 0.445680
R18657 n1_m7_536000_164000 n1_m7_541600_164000 0.148560
R18658 n1_m7_564000_164000 n1_m7_541600_164000 0.594240
R18659 n1_m7_564000_164000 n1_m7_586400_164000 0.594240
R18660 n1_m7_592000_164000 n1_m7_586400_164000 0.148560
R18661 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R18662 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R18663 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R18664 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R18665 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R18666 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R18667 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R18668 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R18669 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R18670 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R18671 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R18672 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R18673 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R18674 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R18675 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R18676 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R18677 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R18678 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R18679 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R18680 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R18681 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R18682 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R18683 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R18684 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R18685 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R18686 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R18687 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R18688 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R18689 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R18690 n1_m7_424000_244000 n1_m7_407200_244000 0.445680
R18691 n1_m7_424000_244000 n1_m7_429600_244000 0.148560
R18692 n1_m7_452000_244000 n1_m7_429600_244000 0.594240
R18693 n1_m7_452000_244000 n1_m7_474400_244000 0.594240
R18694 n1_m7_480000_244000 n1_m7_474400_244000 0.148560
R18695 n1_m7_480000_244000 n1_m7_496800_244000 0.445680
R18696 n1_m7_508000_244000 n1_m7_496800_244000 0.297120
R18697 n1_m7_508000_244000 n1_m7_519200_244000 0.297120
R18698 n1_m7_536000_244000 n1_m7_519200_244000 0.445680
R18699 n1_m7_536000_244000 n1_m7_541600_244000 0.148560
R18700 n1_m7_564000_244000 n1_m7_541600_244000 0.594240
R18701 n1_m7_564000_244000 n1_m7_586400_244000 0.594240
R18702 n1_m7_592000_244000 n1_m7_586400_244000 0.148560
R18703 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R18704 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R18705 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R18706 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R18707 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R18708 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R18709 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R18710 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R18711 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R18712 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R18713 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R18714 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R18715 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R18716 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R18717 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R18718 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R18719 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R18720 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R18721 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R18722 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R18723 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R18724 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R18725 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R18726 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R18727 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R18728 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R18729 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R18730 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R18731 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R18732 n1_m7_424000_324000 n1_m7_407200_324000 0.445680
R18733 n1_m7_424000_324000 n1_m7_429600_324000 0.148560
R18734 n1_m7_452000_324000 n1_m7_429600_324000 0.594240
R18735 n1_m7_452000_324000 n1_m7_474400_324000 0.594240
R18736 n1_m7_480000_324000 n1_m7_474400_324000 0.148560
R18737 n1_m7_480000_324000 n1_m7_496800_324000 0.445680
R18738 n1_m7_508000_324000 n1_m7_496800_324000 0.297120
R18739 n1_m7_508000_324000 n1_m7_519200_324000 0.297120
R18740 n1_m7_536000_324000 n1_m7_519200_324000 0.445680
R18741 n1_m7_536000_324000 n1_m7_541600_324000 0.148560
R18742 n1_m7_564000_324000 n1_m7_541600_324000 0.594240
R18743 n1_m7_564000_324000 n1_m7_586400_324000 0.594240
R18744 n1_m7_592000_324000 n1_m7_586400_324000 0.148560
R18745 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R18746 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R18747 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R18748 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R18749 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R18750 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R18751 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R18752 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R18753 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R18754 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R18755 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R18756 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R18757 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R18758 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R18759 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R18760 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R18761 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R18762 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R18763 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R18764 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R18765 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R18766 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R18767 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R18768 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R18769 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R18770 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R18771 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R18772 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R18773 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R18774 n1_m7_424000_404000 n1_m7_407200_404000 0.445680
R18775 n1_m7_424000_404000 n1_m7_429600_404000 0.148560
R18776 n1_m7_452000_404000 n1_m7_429600_404000 0.594240
R18777 n1_m7_452000_404000 n1_m7_474400_404000 0.594240
R18778 n1_m7_480000_404000 n1_m7_474400_404000 0.148560
R18779 n1_m7_480000_404000 n1_m7_496800_404000 0.445680
R18780 n1_m7_508000_404000 n1_m7_496800_404000 0.297120
R18781 n1_m7_508000_404000 n1_m7_519200_404000 0.297120
R18782 n1_m7_536000_404000 n1_m7_519200_404000 0.445680
R18783 n1_m7_536000_404000 n1_m7_541600_404000 0.148560
R18784 n1_m7_564000_404000 n1_m7_541600_404000 0.594240
R18785 n1_m7_564000_404000 n1_m7_586400_404000 0.594240
R18786 n1_m7_592000_404000 n1_m7_586400_404000 0.148560
R18787 n1_m7_4000_484000 n1_m7_26400_484000 0.594240
R18788 n1_m7_32000_484000 n1_m7_26400_484000 0.148560
R18789 n1_m7_32000_484000 n1_m7_48800_484000 0.445680
R18790 n1_m7_60000_484000 n1_m7_48800_484000 0.297120
R18791 n1_m7_60000_484000 n1_m7_71200_484000 0.297120
R18792 n1_m7_88000_484000 n1_m7_71200_484000 0.445680
R18793 n1_m7_88000_484000 n1_m7_93600_484000 0.148560
R18794 n1_m7_116000_484000 n1_m7_93600_484000 0.594240
R18795 n1_m7_116000_484000 n1_m7_138400_484000 0.594240
R18796 n1_m7_144000_484000 n1_m7_138400_484000 0.148560
R18797 n1_m7_144000_484000 n1_m7_160800_484000 0.445680
R18798 n1_m7_172000_484000 n1_m7_160800_484000 0.297120
R18799 n1_m7_172000_484000 n1_m7_183200_484000 0.297120
R18800 n1_m7_200000_484000 n1_m7_183200_484000 0.445680
R18801 n1_m7_200000_484000 n1_m7_205600_484000 0.148560
R18802 n1_m7_228000_484000 n1_m7_205600_484000 0.594240
R18803 n1_m7_228000_484000 n1_m7_250400_484000 0.594240
R18804 n1_m7_256000_484000 n1_m7_250400_484000 0.148560
R18805 n1_m7_256000_484000 n1_m7_272800_484000 0.445680
R18806 n1_m7_284000_484000 n1_m7_272800_484000 0.297120
R18807 n1_m7_284000_484000 n1_m7_295200_484000 0.297120
R18808 n1_m7_312000_484000 n1_m7_295200_484000 0.445680
R18809 n1_m7_312000_484000 n1_m7_317600_484000 0.148560
R18810 n1_m7_340000_484000 n1_m7_317600_484000 0.594240
R18811 n1_m7_340000_484000 n1_m7_362400_484000 0.594240
R18812 n1_m7_368000_484000 n1_m7_362400_484000 0.148560
R18813 n1_m7_368000_484000 n1_m7_384800_484000 0.445680
R18814 n1_m7_396000_484000 n1_m7_384800_484000 0.297120
R18815 n1_m7_396000_484000 n1_m7_407200_484000 0.297120
R18816 n1_m7_424000_484000 n1_m7_407200_484000 0.445680
R18817 n1_m7_424000_484000 n1_m7_429600_484000 0.148560
R18818 n1_m7_452000_484000 n1_m7_429600_484000 0.594240
R18819 n1_m7_452000_484000 n1_m7_474400_484000 0.594240
R18820 n1_m7_480000_484000 n1_m7_474400_484000 0.148560
R18821 n1_m7_480000_484000 n1_m7_496800_484000 0.445680
R18822 n1_m7_508000_484000 n1_m7_496800_484000 0.297120
R18823 n1_m7_508000_484000 n1_m7_519200_484000 0.297120
R18824 n1_m7_536000_484000 n1_m7_519200_484000 0.445680
R18825 n1_m7_536000_484000 n1_m7_541600_484000 0.148560
R18826 n1_m7_564000_484000 n1_m7_541600_484000 0.594240
R18827 n1_m7_564000_484000 n1_m7_586400_484000 0.594240
R18828 n1_m7_592000_484000 n1_m7_586400_484000 0.148560
R18829 n1_m7_4000_564000 n1_m7_26400_564000 0.594240
R18830 n1_m7_32000_564000 n1_m7_26400_564000 0.148560
R18831 n1_m7_32000_564000 n1_m7_48800_564000 0.445680
R18832 n1_m7_60000_564000 n1_m7_48800_564000 0.297120
R18833 n1_m7_60000_564000 n1_m7_71200_564000 0.297120
R18834 n1_m7_88000_564000 n1_m7_71200_564000 0.445680
R18835 n1_m7_88000_564000 n1_m7_93600_564000 0.148560
R18836 n1_m7_116000_564000 n1_m7_93600_564000 0.594240
R18837 n1_m7_116000_564000 n1_m7_138400_564000 0.594240
R18838 n1_m7_144000_564000 n1_m7_138400_564000 0.148560
R18839 n1_m7_144000_564000 n1_m7_160800_564000 0.445680
R18840 n1_m7_172000_564000 n1_m7_160800_564000 0.297120
R18841 n1_m7_172000_564000 n1_m7_183200_564000 0.297120
R18842 n1_m7_200000_564000 n1_m7_183200_564000 0.445680
R18843 n1_m7_200000_564000 n1_m7_205600_564000 0.148560
R18844 n1_m7_228000_564000 n1_m7_205600_564000 0.594240
R18845 n1_m7_228000_564000 n1_m7_250400_564000 0.594240
R18846 n1_m7_256000_564000 n1_m7_250400_564000 0.148560
R18847 n1_m7_256000_564000 n1_m7_272800_564000 0.445680
R18848 n1_m7_284000_564000 n1_m7_272800_564000 0.297120
R18849 n1_m7_284000_564000 n1_m7_295200_564000 0.297120
R18850 n1_m7_312000_564000 n1_m7_295200_564000 0.445680
R18851 n1_m7_312000_564000 n1_m7_317600_564000 0.148560
R18852 n1_m7_340000_564000 n1_m7_317600_564000 0.594240
R18853 n1_m7_340000_564000 n1_m7_362400_564000 0.594240
R18854 n1_m7_368000_564000 n1_m7_362400_564000 0.148560
R18855 n1_m7_368000_564000 n1_m7_384800_564000 0.445680
R18856 n1_m7_396000_564000 n1_m7_384800_564000 0.297120
R18857 n1_m7_396000_564000 n1_m7_407200_564000 0.297120
R18858 n1_m7_424000_564000 n1_m7_407200_564000 0.445680
R18859 n1_m7_424000_564000 n1_m7_429600_564000 0.148560
R18860 n1_m7_452000_564000 n1_m7_429600_564000 0.594240
R18861 n1_m7_452000_564000 n1_m7_474400_564000 0.594240
R18862 n1_m7_480000_564000 n1_m7_474400_564000 0.148560
R18863 n1_m7_480000_564000 n1_m7_496800_564000 0.445680
R18864 n1_m7_508000_564000 n1_m7_496800_564000 0.297120
R18865 n1_m7_508000_564000 n1_m7_519200_564000 0.297120
R18866 n1_m7_536000_564000 n1_m7_519200_564000 0.445680
R18867 n1_m7_536000_564000 n1_m7_541600_564000 0.148560
R18868 n1_m7_564000_564000 n1_m7_541600_564000 0.594240
R18869 n1_m7_564000_564000 n1_m7_586400_564000 0.594240
R18870 n1_m7_592000_564000 n1_m7_586400_564000 0.148560
R18871 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R18872 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R18873 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R18874 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R18875 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R18876 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R18877 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R18878 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R18879 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R18880 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R18881 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R18882 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R18883 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R18884 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R18885 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R18886 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R18887 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R18888 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R18889 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R18890 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R18891 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R18892 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R18893 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R18894 n1_m8_4000_407200 n1_m8_4000_429600 0.120000
R18895 n1_m8_4000_429600 n1_m8_4000_452000 0.120000
R18896 n1_m8_4000_452000 n1_m8_4000_474400 0.120000
R18897 n1_m8_4000_484000 n1_m8_4000_474400 0.051429
R18898 n1_m8_4000_484000 n1_m8_4000_496800 0.068571
R18899 n1_m8_4000_496800 n1_m8_4000_519200 0.120000
R18900 n1_m8_4000_519200 n1_m8_4000_541600 0.120000
R18901 n1_m8_4000_564000 n1_m8_4000_541600 0.120000
R18902 n1_m8_4000_564000 n1_m8_4000_586400 0.120000
R18903 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R18904 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R18905 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R18906 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R18907 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R18908 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R18909 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R18910 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R18911 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R18912 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R18913 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R18914 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R18915 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R18916 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R18917 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R18918 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R18919 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R18920 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R18921 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R18922 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R18923 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R18924 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R18925 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R18926 n1_m8_26400_407200 n1_m8_26400_429600 0.120000
R18927 n1_m8_26400_429600 n1_m8_26400_452000 0.120000
R18928 n1_m8_26400_452000 n1_m8_26400_474400 0.120000
R18929 n1_m8_26400_484000 n1_m8_26400_474400 0.051429
R18930 n1_m8_26400_484000 n1_m8_26400_496800 0.068571
R18931 n1_m8_26400_496800 n1_m8_26400_519200 0.120000
R18932 n1_m8_26400_519200 n1_m8_26400_541600 0.120000
R18933 n1_m8_26400_564000 n1_m8_26400_541600 0.120000
R18934 n1_m8_26400_564000 n1_m8_26400_586400 0.120000
R18935 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R18936 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R18937 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R18938 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R18939 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R18940 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R18941 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R18942 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R18943 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R18944 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R18945 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R18946 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R18947 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R18948 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R18949 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R18950 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R18951 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R18952 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R18953 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R18954 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R18955 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R18956 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R18957 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R18958 n1_m8_48800_407200 n1_m8_48800_429600 0.120000
R18959 n1_m8_48800_429600 n1_m8_48800_452000 0.120000
R18960 n1_m8_48800_452000 n1_m8_48800_474400 0.120000
R18961 n1_m8_48800_484000 n1_m8_48800_474400 0.051429
R18962 n1_m8_48800_484000 n1_m8_48800_496800 0.068571
R18963 n1_m8_48800_496800 n1_m8_48800_519200 0.120000
R18964 n1_m8_48800_519200 n1_m8_48800_541600 0.120000
R18965 n1_m8_48800_564000 n1_m8_48800_541600 0.120000
R18966 n1_m8_48800_564000 n1_m8_48800_586400 0.120000
R18967 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R18968 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R18969 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R18970 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R18971 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R18972 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R18973 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R18974 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R18975 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R18976 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R18977 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R18978 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R18979 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R18980 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R18981 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R18982 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R18983 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R18984 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R18985 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R18986 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R18987 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R18988 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R18989 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R18990 n1_m8_71200_407200 n1_m8_71200_429600 0.120000
R18991 n1_m8_71200_429600 n1_m8_71200_452000 0.120000
R18992 n1_m8_71200_452000 n1_m8_71200_474400 0.120000
R18993 n1_m8_71200_484000 n1_m8_71200_474400 0.051429
R18994 n1_m8_71200_484000 n1_m8_71200_496800 0.068571
R18995 n1_m8_71200_496800 n1_m8_71200_519200 0.120000
R18996 n1_m8_71200_519200 n1_m8_71200_541600 0.120000
R18997 n1_m8_71200_564000 n1_m8_71200_541600 0.120000
R18998 n1_m8_71200_564000 n1_m8_71200_586400 0.120000
R18999 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R19000 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R19001 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R19002 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R19003 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R19004 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R19005 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R19006 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R19007 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R19008 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R19009 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R19010 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R19011 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R19012 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R19013 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R19014 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R19015 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R19016 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R19017 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R19018 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R19019 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R19020 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R19021 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R19022 n1_m8_93600_407200 n1_m8_93600_429600 0.120000
R19023 n1_m8_93600_429600 n1_m8_93600_452000 0.120000
R19024 n1_m8_93600_452000 n1_m8_93600_474400 0.120000
R19025 n1_m8_93600_484000 n1_m8_93600_474400 0.051429
R19026 n1_m8_93600_484000 n1_m8_93600_496800 0.068571
R19027 n1_m8_93600_496800 n1_m8_93600_519200 0.120000
R19028 n1_m8_93600_519200 n1_m8_93600_541600 0.120000
R19029 n1_m8_93600_564000 n1_m8_93600_541600 0.120000
R19030 n1_m8_93600_564000 n1_m8_93600_586400 0.120000
R19031 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R19032 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R19033 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R19034 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R19035 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R19036 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R19037 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R19038 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R19039 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R19040 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R19041 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R19042 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R19043 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R19044 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R19045 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R19046 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R19047 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R19048 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R19049 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R19050 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R19051 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R19052 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R19053 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R19054 n1_m8_116000_407200 n1_m8_116000_429600 0.120000
R19055 n1_m8_116000_429600 n1_m8_116000_452000 0.120000
R19056 n1_m8_116000_452000 n1_m8_116000_474400 0.120000
R19057 n1_m8_116000_484000 n1_m8_116000_474400 0.051429
R19058 n1_m8_116000_484000 n1_m8_116000_496800 0.068571
R19059 n1_m8_116000_496800 n1_m8_116000_519200 0.120000
R19060 n1_m8_116000_519200 n1_m8_116000_541600 0.120000
R19061 n1_m8_116000_564000 n1_m8_116000_541600 0.120000
R19062 n1_m8_116000_564000 n1_m8_116000_586400 0.120000
R19063 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R19064 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R19065 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R19066 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R19067 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R19068 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R19069 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R19070 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R19071 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R19072 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R19073 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R19074 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R19075 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R19076 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R19077 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R19078 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R19079 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R19080 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R19081 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R19082 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R19083 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R19084 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R19085 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R19086 n1_m8_138400_407200 n1_m8_138400_429600 0.120000
R19087 n1_m8_138400_429600 n1_m8_138400_452000 0.120000
R19088 n1_m8_138400_452000 n1_m8_138400_474400 0.120000
R19089 n1_m8_138400_484000 n1_m8_138400_474400 0.051429
R19090 n1_m8_138400_484000 n1_m8_138400_496800 0.068571
R19091 n1_m8_138400_496800 n1_m8_138400_519200 0.120000
R19092 n1_m8_138400_519200 n1_m8_138400_541600 0.120000
R19093 n1_m8_138400_564000 n1_m8_138400_541600 0.120000
R19094 n1_m8_138400_564000 n1_m8_138400_586400 0.120000
R19095 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R19096 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R19097 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R19098 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R19099 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R19100 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R19101 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R19102 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R19103 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R19104 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R19105 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R19106 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R19107 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R19108 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R19109 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R19110 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R19111 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R19112 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R19113 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R19114 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R19115 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R19116 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R19117 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R19118 n1_m8_160800_407200 n1_m8_160800_429600 0.120000
R19119 n1_m8_160800_429600 n1_m8_160800_452000 0.120000
R19120 n1_m8_160800_452000 n1_m8_160800_474400 0.120000
R19121 n1_m8_160800_484000 n1_m8_160800_474400 0.051429
R19122 n1_m8_160800_484000 n1_m8_160800_496800 0.068571
R19123 n1_m8_160800_496800 n1_m8_160800_519200 0.120000
R19124 n1_m8_160800_519200 n1_m8_160800_541600 0.120000
R19125 n1_m8_160800_564000 n1_m8_160800_541600 0.120000
R19126 n1_m8_160800_564000 n1_m8_160800_586400 0.120000
R19127 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R19128 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R19129 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R19130 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R19131 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R19132 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R19133 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R19134 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R19135 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R19136 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R19137 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R19138 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R19139 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R19140 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R19141 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R19142 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R19143 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R19144 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R19145 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R19146 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R19147 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R19148 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R19149 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R19150 n1_m8_183200_407200 n1_m8_183200_429600 0.120000
R19151 n1_m8_183200_429600 n1_m8_183200_452000 0.120000
R19152 n1_m8_183200_452000 n1_m8_183200_474400 0.120000
R19153 n1_m8_183200_484000 n1_m8_183200_474400 0.051429
R19154 n1_m8_183200_484000 n1_m8_183200_496800 0.068571
R19155 n1_m8_183200_496800 n1_m8_183200_519200 0.120000
R19156 n1_m8_183200_519200 n1_m8_183200_541600 0.120000
R19157 n1_m8_183200_564000 n1_m8_183200_541600 0.120000
R19158 n1_m8_183200_564000 n1_m8_183200_586400 0.120000
R19159 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R19160 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R19161 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R19162 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R19163 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R19164 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R19165 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R19166 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R19167 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R19168 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R19169 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R19170 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R19171 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R19172 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R19173 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R19174 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R19175 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R19176 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R19177 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R19178 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R19179 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R19180 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R19181 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R19182 n1_m8_205600_407200 n1_m8_205600_429600 0.120000
R19183 n1_m8_205600_429600 n1_m8_205600_452000 0.120000
R19184 n1_m8_205600_452000 n1_m8_205600_474400 0.120000
R19185 n1_m8_205600_484000 n1_m8_205600_474400 0.051429
R19186 n1_m8_205600_484000 n1_m8_205600_496800 0.068571
R19187 n1_m8_205600_496800 n1_m8_205600_519200 0.120000
R19188 n1_m8_205600_519200 n1_m8_205600_541600 0.120000
R19189 n1_m8_205600_564000 n1_m8_205600_541600 0.120000
R19190 n1_m8_205600_564000 n1_m8_205600_586400 0.120000
R19191 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R19192 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R19193 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R19194 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R19195 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R19196 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R19197 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R19198 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R19199 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R19200 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R19201 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R19202 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R19203 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R19204 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R19205 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R19206 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R19207 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R19208 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R19209 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R19210 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R19211 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R19212 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R19213 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R19214 n1_m8_228000_407200 n1_m8_228000_429600 0.120000
R19215 n1_m8_228000_429600 n1_m8_228000_452000 0.120000
R19216 n1_m8_228000_452000 n1_m8_228000_474400 0.120000
R19217 n1_m8_228000_484000 n1_m8_228000_474400 0.051429
R19218 n1_m8_228000_484000 n1_m8_228000_496800 0.068571
R19219 n1_m8_228000_496800 n1_m8_228000_519200 0.120000
R19220 n1_m8_228000_519200 n1_m8_228000_541600 0.120000
R19221 n1_m8_228000_564000 n1_m8_228000_541600 0.120000
R19222 n1_m8_228000_564000 n1_m8_228000_586400 0.120000
R19223 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R19224 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R19225 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R19226 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R19227 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R19228 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R19229 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R19230 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R19231 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R19232 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R19233 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R19234 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R19235 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R19236 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R19237 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R19238 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R19239 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R19240 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R19241 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R19242 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R19243 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R19244 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R19245 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R19246 n1_m8_250400_407200 n1_m8_250400_429600 0.120000
R19247 n1_m8_250400_429600 n1_m8_250400_452000 0.120000
R19248 n1_m8_250400_452000 n1_m8_250400_474400 0.120000
R19249 n1_m8_250400_484000 n1_m8_250400_474400 0.051429
R19250 n1_m8_250400_484000 n1_m8_250400_496800 0.068571
R19251 n1_m8_250400_496800 n1_m8_250400_519200 0.120000
R19252 n1_m8_250400_519200 n1_m8_250400_541600 0.120000
R19253 n1_m8_250400_564000 n1_m8_250400_541600 0.120000
R19254 n1_m8_250400_564000 n1_m8_250400_586400 0.120000
R19255 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R19256 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R19257 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R19258 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R19259 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R19260 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R19261 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R19262 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R19263 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R19264 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R19265 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R19266 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R19267 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R19268 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R19269 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R19270 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R19271 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R19272 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R19273 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R19274 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R19275 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R19276 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R19277 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R19278 n1_m8_272800_407200 n1_m8_272800_429600 0.120000
R19279 n1_m8_272800_429600 n1_m8_272800_452000 0.120000
R19280 n1_m8_272800_452000 n1_m8_272800_474400 0.120000
R19281 n1_m8_272800_484000 n1_m8_272800_474400 0.051429
R19282 n1_m8_272800_484000 n1_m8_272800_496800 0.068571
R19283 n1_m8_272800_496800 n1_m8_272800_519200 0.120000
R19284 n1_m8_272800_519200 n1_m8_272800_541600 0.120000
R19285 n1_m8_272800_564000 n1_m8_272800_541600 0.120000
R19286 n1_m8_272800_564000 n1_m8_272800_586400 0.120000
R19287 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R19288 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R19289 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R19290 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R19291 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R19292 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R19293 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R19294 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R19295 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R19296 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R19297 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R19298 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R19299 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R19300 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R19301 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R19302 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R19303 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R19304 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R19305 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R19306 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R19307 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R19308 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R19309 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R19310 n1_m8_295200_407200 n1_m8_295200_429600 0.120000
R19311 n1_m8_295200_429600 n1_m8_295200_452000 0.120000
R19312 n1_m8_295200_452000 n1_m8_295200_474400 0.120000
R19313 n1_m8_295200_484000 n1_m8_295200_474400 0.051429
R19314 n1_m8_295200_484000 n1_m8_295200_496800 0.068571
R19315 n1_m8_295200_496800 n1_m8_295200_519200 0.120000
R19316 n1_m8_295200_519200 n1_m8_295200_541600 0.120000
R19317 n1_m8_295200_564000 n1_m8_295200_541600 0.120000
R19318 n1_m8_295200_564000 n1_m8_295200_586400 0.120000
R19319 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R19320 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R19321 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R19322 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R19323 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R19324 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R19325 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R19326 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R19327 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R19328 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R19329 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R19330 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R19331 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R19332 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R19333 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R19334 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R19335 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R19336 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R19337 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R19338 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R19339 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R19340 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R19341 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R19342 n1_m8_317600_407200 n1_m8_317600_429600 0.120000
R19343 n1_m8_317600_429600 n1_m8_317600_452000 0.120000
R19344 n1_m8_317600_452000 n1_m8_317600_474400 0.120000
R19345 n1_m8_317600_484000 n1_m8_317600_474400 0.051429
R19346 n1_m8_317600_484000 n1_m8_317600_496800 0.068571
R19347 n1_m8_317600_496800 n1_m8_317600_519200 0.120000
R19348 n1_m8_317600_519200 n1_m8_317600_541600 0.120000
R19349 n1_m8_317600_564000 n1_m8_317600_541600 0.120000
R19350 n1_m8_317600_564000 n1_m8_317600_586400 0.120000
R19351 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R19352 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R19353 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R19354 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R19355 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R19356 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R19357 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R19358 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R19359 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R19360 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R19361 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R19362 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R19363 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R19364 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R19365 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R19366 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R19367 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R19368 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R19369 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R19370 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R19371 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R19372 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R19373 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R19374 n1_m8_340000_407200 n1_m8_340000_429600 0.120000
R19375 n1_m8_340000_429600 n1_m8_340000_452000 0.120000
R19376 n1_m8_340000_452000 n1_m8_340000_474400 0.120000
R19377 n1_m8_340000_484000 n1_m8_340000_474400 0.051429
R19378 n1_m8_340000_484000 n1_m8_340000_496800 0.068571
R19379 n1_m8_340000_496800 n1_m8_340000_519200 0.120000
R19380 n1_m8_340000_519200 n1_m8_340000_541600 0.120000
R19381 n1_m8_340000_564000 n1_m8_340000_541600 0.120000
R19382 n1_m8_340000_564000 n1_m8_340000_586400 0.120000
R19383 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R19384 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R19385 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R19386 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R19387 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R19388 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R19389 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R19390 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R19391 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R19392 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R19393 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R19394 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R19395 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R19396 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R19397 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R19398 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R19399 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R19400 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R19401 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R19402 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R19403 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R19404 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R19405 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R19406 n1_m8_362400_407200 n1_m8_362400_429600 0.120000
R19407 n1_m8_362400_429600 n1_m8_362400_452000 0.120000
R19408 n1_m8_362400_452000 n1_m8_362400_474400 0.120000
R19409 n1_m8_362400_484000 n1_m8_362400_474400 0.051429
R19410 n1_m8_362400_484000 n1_m8_362400_496800 0.068571
R19411 n1_m8_362400_496800 n1_m8_362400_519200 0.120000
R19412 n1_m8_362400_519200 n1_m8_362400_541600 0.120000
R19413 n1_m8_362400_564000 n1_m8_362400_541600 0.120000
R19414 n1_m8_362400_564000 n1_m8_362400_586400 0.120000
R19415 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R19416 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R19417 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R19418 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R19419 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R19420 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R19421 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R19422 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R19423 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R19424 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R19425 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R19426 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R19427 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R19428 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R19429 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R19430 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R19431 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R19432 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R19433 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R19434 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R19435 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R19436 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R19437 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R19438 n1_m8_384800_407200 n1_m8_384800_429600 0.120000
R19439 n1_m8_384800_429600 n1_m8_384800_452000 0.120000
R19440 n1_m8_384800_452000 n1_m8_384800_474400 0.120000
R19441 n1_m8_384800_484000 n1_m8_384800_474400 0.051429
R19442 n1_m8_384800_484000 n1_m8_384800_496800 0.068571
R19443 n1_m8_384800_496800 n1_m8_384800_519200 0.120000
R19444 n1_m8_384800_519200 n1_m8_384800_541600 0.120000
R19445 n1_m8_384800_564000 n1_m8_384800_541600 0.120000
R19446 n1_m8_384800_564000 n1_m8_384800_586400 0.120000
R19447 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R19448 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R19449 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R19450 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R19451 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R19452 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R19453 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R19454 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R19455 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R19456 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R19457 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R19458 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R19459 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R19460 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R19461 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R19462 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R19463 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R19464 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R19465 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R19466 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R19467 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R19468 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R19469 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R19470 n1_m8_407200_407200 n1_m8_407200_429600 0.120000
R19471 n1_m8_407200_429600 n1_m8_407200_452000 0.120000
R19472 n1_m8_407200_452000 n1_m8_407200_474400 0.120000
R19473 n1_m8_407200_484000 n1_m8_407200_474400 0.051429
R19474 n1_m8_407200_484000 n1_m8_407200_496800 0.068571
R19475 n1_m8_407200_496800 n1_m8_407200_519200 0.120000
R19476 n1_m8_407200_519200 n1_m8_407200_541600 0.120000
R19477 n1_m8_407200_564000 n1_m8_407200_541600 0.120000
R19478 n1_m8_407200_564000 n1_m8_407200_586400 0.120000
R19479 n1_m8_429600_4000 n1_m8_429600_26400 0.120000
R19480 n1_m8_429600_26400 n1_m8_429600_48800 0.120000
R19481 n1_m8_429600_48800 n1_m8_429600_71200 0.120000
R19482 n1_m8_429600_84000 n1_m8_429600_71200 0.068571
R19483 n1_m8_429600_84000 n1_m8_429600_93600 0.051429
R19484 n1_m8_429600_93600 n1_m8_429600_116000 0.120000
R19485 n1_m8_429600_116000 n1_m8_429600_138400 0.120000
R19486 n1_m8_429600_138400 n1_m8_429600_160800 0.120000
R19487 n1_m8_429600_164000 n1_m8_429600_160800 0.017143
R19488 n1_m8_429600_164000 n1_m8_429600_183200 0.102857
R19489 n1_m8_429600_183200 n1_m8_429600_205600 0.120000
R19490 n1_m8_429600_205600 n1_m8_429600_228000 0.120000
R19491 n1_m8_429600_244000 n1_m8_429600_228000 0.085714
R19492 n1_m8_429600_244000 n1_m8_429600_250400 0.034286
R19493 n1_m8_429600_250400 n1_m8_429600_272800 0.120000
R19494 n1_m8_429600_272800 n1_m8_429600_295200 0.120000
R19495 n1_m8_429600_295200 n1_m8_429600_317600 0.120000
R19496 n1_m8_429600_324000 n1_m8_429600_317600 0.034286
R19497 n1_m8_429600_324000 n1_m8_429600_340000 0.085714
R19498 n1_m8_429600_340000 n1_m8_429600_362400 0.120000
R19499 n1_m8_429600_362400 n1_m8_429600_384800 0.120000
R19500 n1_m8_429600_404000 n1_m8_429600_384800 0.102857
R19501 n1_m8_429600_404000 n1_m8_429600_407200 0.017143
R19502 n1_m8_429600_407200 n1_m8_429600_429600 0.120000
R19503 n1_m8_429600_429600 n1_m8_429600_452000 0.120000
R19504 n1_m8_429600_452000 n1_m8_429600_474400 0.120000
R19505 n1_m8_429600_484000 n1_m8_429600_474400 0.051429
R19506 n1_m8_429600_484000 n1_m8_429600_496800 0.068571
R19507 n1_m8_429600_496800 n1_m8_429600_519200 0.120000
R19508 n1_m8_429600_519200 n1_m8_429600_541600 0.120000
R19509 n1_m8_429600_564000 n1_m8_429600_541600 0.120000
R19510 n1_m8_429600_564000 n1_m8_429600_586400 0.120000
R19511 n1_m8_452000_4000 n1_m8_452000_26400 0.120000
R19512 n1_m8_452000_26400 n1_m8_452000_48800 0.120000
R19513 n1_m8_452000_48800 n1_m8_452000_71200 0.120000
R19514 n1_m8_452000_84000 n1_m8_452000_71200 0.068571
R19515 n1_m8_452000_84000 n1_m8_452000_93600 0.051429
R19516 n1_m8_452000_93600 n1_m8_452000_116000 0.120000
R19517 n1_m8_452000_116000 n1_m8_452000_138400 0.120000
R19518 n1_m8_452000_138400 n1_m8_452000_160800 0.120000
R19519 n1_m8_452000_164000 n1_m8_452000_160800 0.017143
R19520 n1_m8_452000_164000 n1_m8_452000_183200 0.102857
R19521 n1_m8_452000_183200 n1_m8_452000_205600 0.120000
R19522 n1_m8_452000_205600 n1_m8_452000_228000 0.120000
R19523 n1_m8_452000_244000 n1_m8_452000_228000 0.085714
R19524 n1_m8_452000_244000 n1_m8_452000_250400 0.034286
R19525 n1_m8_452000_250400 n1_m8_452000_272800 0.120000
R19526 n1_m8_452000_272800 n1_m8_452000_295200 0.120000
R19527 n1_m8_452000_295200 n1_m8_452000_317600 0.120000
R19528 n1_m8_452000_324000 n1_m8_452000_317600 0.034286
R19529 n1_m8_452000_324000 n1_m8_452000_340000 0.085714
R19530 n1_m8_452000_340000 n1_m8_452000_362400 0.120000
R19531 n1_m8_452000_362400 n1_m8_452000_384800 0.120000
R19532 n1_m8_452000_404000 n1_m8_452000_384800 0.102857
R19533 n1_m8_452000_404000 n1_m8_452000_407200 0.017143
R19534 n1_m8_452000_407200 n1_m8_452000_429600 0.120000
R19535 n1_m8_452000_429600 n1_m8_452000_452000 0.120000
R19536 n1_m8_452000_452000 n1_m8_452000_474400 0.120000
R19537 n1_m8_452000_484000 n1_m8_452000_474400 0.051429
R19538 n1_m8_452000_484000 n1_m8_452000_496800 0.068571
R19539 n1_m8_452000_496800 n1_m8_452000_519200 0.120000
R19540 n1_m8_452000_519200 n1_m8_452000_541600 0.120000
R19541 n1_m8_452000_564000 n1_m8_452000_541600 0.120000
R19542 n1_m8_452000_564000 n1_m8_452000_586400 0.120000
R19543 n1_m8_474400_4000 n1_m8_474400_26400 0.120000
R19544 n1_m8_474400_26400 n1_m8_474400_48800 0.120000
R19545 n1_m8_474400_48800 n1_m8_474400_71200 0.120000
R19546 n1_m8_474400_84000 n1_m8_474400_71200 0.068571
R19547 n1_m8_474400_84000 n1_m8_474400_93600 0.051429
R19548 n1_m8_474400_93600 n1_m8_474400_116000 0.120000
R19549 n1_m8_474400_116000 n1_m8_474400_138400 0.120000
R19550 n1_m8_474400_138400 n1_m8_474400_160800 0.120000
R19551 n1_m8_474400_164000 n1_m8_474400_160800 0.017143
R19552 n1_m8_474400_164000 n1_m8_474400_183200 0.102857
R19553 n1_m8_474400_183200 n1_m8_474400_205600 0.120000
R19554 n1_m8_474400_205600 n1_m8_474400_228000 0.120000
R19555 n1_m8_474400_244000 n1_m8_474400_228000 0.085714
R19556 n1_m8_474400_244000 n1_m8_474400_250400 0.034286
R19557 n1_m8_474400_250400 n1_m8_474400_272800 0.120000
R19558 n1_m8_474400_272800 n1_m8_474400_295200 0.120000
R19559 n1_m8_474400_295200 n1_m8_474400_317600 0.120000
R19560 n1_m8_474400_324000 n1_m8_474400_317600 0.034286
R19561 n1_m8_474400_324000 n1_m8_474400_340000 0.085714
R19562 n1_m8_474400_340000 n1_m8_474400_362400 0.120000
R19563 n1_m8_474400_362400 n1_m8_474400_384800 0.120000
R19564 n1_m8_474400_404000 n1_m8_474400_384800 0.102857
R19565 n1_m8_474400_404000 n1_m8_474400_407200 0.017143
R19566 n1_m8_474400_407200 n1_m8_474400_429600 0.120000
R19567 n1_m8_474400_429600 n1_m8_474400_452000 0.120000
R19568 n1_m8_474400_452000 n1_m8_474400_474400 0.120000
R19569 n1_m8_474400_484000 n1_m8_474400_474400 0.051429
R19570 n1_m8_474400_484000 n1_m8_474400_496800 0.068571
R19571 n1_m8_474400_496800 n1_m8_474400_519200 0.120000
R19572 n1_m8_474400_519200 n1_m8_474400_541600 0.120000
R19573 n1_m8_474400_564000 n1_m8_474400_541600 0.120000
R19574 n1_m8_474400_564000 n1_m8_474400_586400 0.120000
R19575 n1_m8_496800_4000 n1_m8_496800_26400 0.120000
R19576 n1_m8_496800_26400 n1_m8_496800_48800 0.120000
R19577 n1_m8_496800_48800 n1_m8_496800_71200 0.120000
R19578 n1_m8_496800_84000 n1_m8_496800_71200 0.068571
R19579 n1_m8_496800_84000 n1_m8_496800_93600 0.051429
R19580 n1_m8_496800_93600 n1_m8_496800_116000 0.120000
R19581 n1_m8_496800_116000 n1_m8_496800_138400 0.120000
R19582 n1_m8_496800_138400 n1_m8_496800_160800 0.120000
R19583 n1_m8_496800_164000 n1_m8_496800_160800 0.017143
R19584 n1_m8_496800_164000 n1_m8_496800_183200 0.102857
R19585 n1_m8_496800_183200 n1_m8_496800_205600 0.120000
R19586 n1_m8_496800_205600 n1_m8_496800_228000 0.120000
R19587 n1_m8_496800_244000 n1_m8_496800_228000 0.085714
R19588 n1_m8_496800_244000 n1_m8_496800_250400 0.034286
R19589 n1_m8_496800_250400 n1_m8_496800_272800 0.120000
R19590 n1_m8_496800_272800 n1_m8_496800_295200 0.120000
R19591 n1_m8_496800_295200 n1_m8_496800_317600 0.120000
R19592 n1_m8_496800_324000 n1_m8_496800_317600 0.034286
R19593 n1_m8_496800_324000 n1_m8_496800_340000 0.085714
R19594 n1_m8_496800_340000 n1_m8_496800_362400 0.120000
R19595 n1_m8_496800_362400 n1_m8_496800_384800 0.120000
R19596 n1_m8_496800_404000 n1_m8_496800_384800 0.102857
R19597 n1_m8_496800_404000 n1_m8_496800_407200 0.017143
R19598 n1_m8_496800_407200 n1_m8_496800_429600 0.120000
R19599 n1_m8_496800_429600 n1_m8_496800_452000 0.120000
R19600 n1_m8_496800_452000 n1_m8_496800_474400 0.120000
R19601 n1_m8_496800_484000 n1_m8_496800_474400 0.051429
R19602 n1_m8_496800_484000 n1_m8_496800_496800 0.068571
R19603 n1_m8_496800_496800 n1_m8_496800_519200 0.120000
R19604 n1_m8_496800_519200 n1_m8_496800_541600 0.120000
R19605 n1_m8_496800_564000 n1_m8_496800_541600 0.120000
R19606 n1_m8_496800_564000 n1_m8_496800_586400 0.120000
R19607 n1_m8_519200_4000 n1_m8_519200_26400 0.120000
R19608 n1_m8_519200_26400 n1_m8_519200_48800 0.120000
R19609 n1_m8_519200_48800 n1_m8_519200_71200 0.120000
R19610 n1_m8_519200_84000 n1_m8_519200_71200 0.068571
R19611 n1_m8_519200_84000 n1_m8_519200_93600 0.051429
R19612 n1_m8_519200_93600 n1_m8_519200_116000 0.120000
R19613 n1_m8_519200_116000 n1_m8_519200_138400 0.120000
R19614 n1_m8_519200_138400 n1_m8_519200_160800 0.120000
R19615 n1_m8_519200_164000 n1_m8_519200_160800 0.017143
R19616 n1_m8_519200_164000 n1_m8_519200_183200 0.102857
R19617 n1_m8_519200_183200 n1_m8_519200_205600 0.120000
R19618 n1_m8_519200_205600 n1_m8_519200_228000 0.120000
R19619 n1_m8_519200_244000 n1_m8_519200_228000 0.085714
R19620 n1_m8_519200_244000 n1_m8_519200_250400 0.034286
R19621 n1_m8_519200_250400 n1_m8_519200_272800 0.120000
R19622 n1_m8_519200_272800 n1_m8_519200_295200 0.120000
R19623 n1_m8_519200_295200 n1_m8_519200_317600 0.120000
R19624 n1_m8_519200_324000 n1_m8_519200_317600 0.034286
R19625 n1_m8_519200_324000 n1_m8_519200_340000 0.085714
R19626 n1_m8_519200_340000 n1_m8_519200_362400 0.120000
R19627 n1_m8_519200_362400 n1_m8_519200_384800 0.120000
R19628 n1_m8_519200_404000 n1_m8_519200_384800 0.102857
R19629 n1_m8_519200_404000 n1_m8_519200_407200 0.017143
R19630 n1_m8_519200_407200 n1_m8_519200_429600 0.120000
R19631 n1_m8_519200_429600 n1_m8_519200_452000 0.120000
R19632 n1_m8_519200_452000 n1_m8_519200_474400 0.120000
R19633 n1_m8_519200_484000 n1_m8_519200_474400 0.051429
R19634 n1_m8_519200_484000 n1_m8_519200_496800 0.068571
R19635 n1_m8_519200_496800 n1_m8_519200_519200 0.120000
R19636 n1_m8_519200_519200 n1_m8_519200_541600 0.120000
R19637 n1_m8_519200_564000 n1_m8_519200_541600 0.120000
R19638 n1_m8_519200_564000 n1_m8_519200_586400 0.120000
R19639 n1_m8_541600_4000 n1_m8_541600_26400 0.120000
R19640 n1_m8_541600_26400 n1_m8_541600_48800 0.120000
R19641 n1_m8_541600_48800 n1_m8_541600_71200 0.120000
R19642 n1_m8_541600_84000 n1_m8_541600_71200 0.068571
R19643 n1_m8_541600_84000 n1_m8_541600_93600 0.051429
R19644 n1_m8_541600_93600 n1_m8_541600_116000 0.120000
R19645 n1_m8_541600_116000 n1_m8_541600_138400 0.120000
R19646 n1_m8_541600_138400 n1_m8_541600_160800 0.120000
R19647 n1_m8_541600_164000 n1_m8_541600_160800 0.017143
R19648 n1_m8_541600_164000 n1_m8_541600_183200 0.102857
R19649 n1_m8_541600_183200 n1_m8_541600_205600 0.120000
R19650 n1_m8_541600_205600 n1_m8_541600_228000 0.120000
R19651 n1_m8_541600_244000 n1_m8_541600_228000 0.085714
R19652 n1_m8_541600_244000 n1_m8_541600_250400 0.034286
R19653 n1_m8_541600_250400 n1_m8_541600_272800 0.120000
R19654 n1_m8_541600_272800 n1_m8_541600_295200 0.120000
R19655 n1_m8_541600_295200 n1_m8_541600_317600 0.120000
R19656 n1_m8_541600_324000 n1_m8_541600_317600 0.034286
R19657 n1_m8_541600_324000 n1_m8_541600_340000 0.085714
R19658 n1_m8_541600_340000 n1_m8_541600_362400 0.120000
R19659 n1_m8_541600_362400 n1_m8_541600_384800 0.120000
R19660 n1_m8_541600_404000 n1_m8_541600_384800 0.102857
R19661 n1_m8_541600_404000 n1_m8_541600_407200 0.017143
R19662 n1_m8_541600_407200 n1_m8_541600_429600 0.120000
R19663 n1_m8_541600_429600 n1_m8_541600_452000 0.120000
R19664 n1_m8_541600_452000 n1_m8_541600_474400 0.120000
R19665 n1_m8_541600_484000 n1_m8_541600_474400 0.051429
R19666 n1_m8_541600_484000 n1_m8_541600_496800 0.068571
R19667 n1_m8_541600_496800 n1_m8_541600_519200 0.120000
R19668 n1_m8_541600_519200 n1_m8_541600_541600 0.120000
R19669 n1_m8_541600_564000 n1_m8_541600_541600 0.120000
R19670 n1_m8_541600_564000 n1_m8_541600_586400 0.120000
R19671 n1_m8_564000_4000 n1_m8_564000_26400 0.120000
R19672 n1_m8_564000_26400 n1_m8_564000_48800 0.120000
R19673 n1_m8_564000_48800 n1_m8_564000_71200 0.120000
R19674 n1_m8_564000_84000 n1_m8_564000_71200 0.068571
R19675 n1_m8_564000_84000 n1_m8_564000_93600 0.051429
R19676 n1_m8_564000_93600 n1_m8_564000_116000 0.120000
R19677 n1_m8_564000_116000 n1_m8_564000_138400 0.120000
R19678 n1_m8_564000_138400 n1_m8_564000_160800 0.120000
R19679 n1_m8_564000_164000 n1_m8_564000_160800 0.017143
R19680 n1_m8_564000_164000 n1_m8_564000_183200 0.102857
R19681 n1_m8_564000_183200 n1_m8_564000_205600 0.120000
R19682 n1_m8_564000_205600 n1_m8_564000_228000 0.120000
R19683 n1_m8_564000_244000 n1_m8_564000_228000 0.085714
R19684 n1_m8_564000_244000 n1_m8_564000_250400 0.034286
R19685 n1_m8_564000_250400 n1_m8_564000_272800 0.120000
R19686 n1_m8_564000_272800 n1_m8_564000_295200 0.120000
R19687 n1_m8_564000_295200 n1_m8_564000_317600 0.120000
R19688 n1_m8_564000_324000 n1_m8_564000_317600 0.034286
R19689 n1_m8_564000_324000 n1_m8_564000_340000 0.085714
R19690 n1_m8_564000_340000 n1_m8_564000_362400 0.120000
R19691 n1_m8_564000_362400 n1_m8_564000_384800 0.120000
R19692 n1_m8_564000_404000 n1_m8_564000_384800 0.102857
R19693 n1_m8_564000_404000 n1_m8_564000_407200 0.017143
R19694 n1_m8_564000_407200 n1_m8_564000_429600 0.120000
R19695 n1_m8_564000_429600 n1_m8_564000_452000 0.120000
R19696 n1_m8_564000_452000 n1_m8_564000_474400 0.120000
R19697 n1_m8_564000_484000 n1_m8_564000_474400 0.051429
R19698 n1_m8_564000_484000 n1_m8_564000_496800 0.068571
R19699 n1_m8_564000_496800 n1_m8_564000_519200 0.120000
R19700 n1_m8_564000_519200 n1_m8_564000_541600 0.120000
R19701 n1_m8_564000_564000 n1_m8_564000_541600 0.120000
R19702 n1_m8_564000_564000 n1_m8_564000_586400 0.120000
R19703 n1_m8_586400_4000 n1_m8_586400_26400 0.120000
R19704 n1_m8_586400_26400 n1_m8_586400_48800 0.120000
R19705 n1_m8_586400_48800 n1_m8_586400_71200 0.120000
R19706 n1_m8_586400_84000 n1_m8_586400_71200 0.068571
R19707 n1_m8_586400_84000 n1_m8_586400_93600 0.051429
R19708 n1_m8_586400_93600 n1_m8_586400_116000 0.120000
R19709 n1_m8_586400_116000 n1_m8_586400_138400 0.120000
R19710 n1_m8_586400_138400 n1_m8_586400_160800 0.120000
R19711 n1_m8_586400_164000 n1_m8_586400_160800 0.017143
R19712 n1_m8_586400_164000 n1_m8_586400_183200 0.102857
R19713 n1_m8_586400_183200 n1_m8_586400_205600 0.120000
R19714 n1_m8_586400_205600 n1_m8_586400_228000 0.120000
R19715 n1_m8_586400_244000 n1_m8_586400_228000 0.085714
R19716 n1_m8_586400_244000 n1_m8_586400_250400 0.034286
R19717 n1_m8_586400_250400 n1_m8_586400_272800 0.120000
R19718 n1_m8_586400_272800 n1_m8_586400_295200 0.120000
R19719 n1_m8_586400_295200 n1_m8_586400_317600 0.120000
R19720 n1_m8_586400_324000 n1_m8_586400_317600 0.034286
R19721 n1_m8_586400_324000 n1_m8_586400_340000 0.085714
R19722 n1_m8_586400_340000 n1_m8_586400_362400 0.120000
R19723 n1_m8_586400_362400 n1_m8_586400_384800 0.120000
R19724 n1_m8_586400_404000 n1_m8_586400_384800 0.102857
R19725 n1_m8_586400_404000 n1_m8_586400_407200 0.017143
R19726 n1_m8_586400_407200 n1_m8_586400_429600 0.120000
R19727 n1_m8_586400_429600 n1_m8_586400_452000 0.120000
R19728 n1_m8_586400_452000 n1_m8_586400_474400 0.120000
R19729 n1_m8_586400_484000 n1_m8_586400_474400 0.051429
R19730 n1_m8_586400_484000 n1_m8_586400_496800 0.068571
R19731 n1_m8_586400_496800 n1_m8_586400_519200 0.120000
R19732 n1_m8_586400_519200 n1_m8_586400_541600 0.120000
R19733 n1_m8_586400_564000 n1_m8_586400_541600 0.120000
R19734 n1_m8_586400_564000 n1_m8_586400_586400 0.120000
R19735 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R19736 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R19737 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R19738 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R19739 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R19740 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R19741 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R19742 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R19743 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R19744 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R19745 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R19746 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R19747 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R19748 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R19749 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R19750 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R19751 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R19752 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R19753 n1_m9_407200_4000 n1_m9_429600_4000 0.096000
R19754 n1_m9_429600_4000 n1_m9_452000_4000 0.096000
R19755 n1_m9_452000_4000 n1_m9_474400_4000 0.096000
R19756 n1_m9_474400_4000 n1_m9_496800_4000 0.096000
R19757 n1_m9_496800_4000 n1_m9_519200_4000 0.096000
R19758 n1_m9_519200_4000 n1_m9_541600_4000 0.096000
R19759 n1_m9_541600_4000 n1_m9_564000_4000 0.096000
R19760 n1_m9_564000_4000 n1_m9_586400_4000 0.096000
R19761 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R19762 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R19763 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R19764 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R19765 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R19766 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R19767 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R19768 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R19769 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R19770 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R19771 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R19772 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R19773 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R19774 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R19775 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R19776 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R19777 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R19778 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R19779 n1_m9_407200_26400 n1_m9_429600_26400 0.096000
R19780 n1_m9_429600_26400 n1_m9_452000_26400 0.096000
R19781 n1_m9_452000_26400 n1_m9_474400_26400 0.096000
R19782 n1_m9_474400_26400 n1_m9_496800_26400 0.096000
R19783 n1_m9_496800_26400 n1_m9_519200_26400 0.096000
R19784 n1_m9_519200_26400 n1_m9_541600_26400 0.096000
R19785 n1_m9_541600_26400 n1_m9_564000_26400 0.096000
R19786 n1_m9_564000_26400 n1_m9_586400_26400 0.096000
R19787 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R19788 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R19789 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R19790 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R19791 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R19792 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R19793 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R19794 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R19795 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R19796 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R19797 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R19798 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R19799 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R19800 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R19801 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R19802 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R19803 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R19804 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R19805 n1_m9_407200_48800 n1_m9_429600_48800 0.096000
R19806 n1_m9_429600_48800 n1_m9_452000_48800 0.096000
R19807 n1_m9_452000_48800 n1_m9_474400_48800 0.096000
R19808 n1_m9_474400_48800 n1_m9_496800_48800 0.096000
R19809 n1_m9_496800_48800 n1_m9_519200_48800 0.096000
R19810 n1_m9_519200_48800 n1_m9_541600_48800 0.096000
R19811 n1_m9_541600_48800 n1_m9_564000_48800 0.096000
R19812 n1_m9_564000_48800 n1_m9_586400_48800 0.096000
R19813 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R19814 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R19815 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R19816 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R19817 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R19818 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R19819 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R19820 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R19821 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R19822 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R19823 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R19824 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R19825 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R19826 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R19827 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R19828 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R19829 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R19830 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R19831 n1_m9_407200_71200 n1_m9_429600_71200 0.096000
R19832 n1_m9_429600_71200 n1_m9_452000_71200 0.096000
R19833 n1_m9_452000_71200 n1_m9_474400_71200 0.096000
R19834 n1_m9_474400_71200 n1_m9_496800_71200 0.096000
R19835 n1_m9_496800_71200 n1_m9_519200_71200 0.096000
R19836 n1_m9_519200_71200 n1_m9_541600_71200 0.096000
R19837 n1_m9_541600_71200 n1_m9_564000_71200 0.096000
R19838 n1_m9_564000_71200 n1_m9_586400_71200 0.096000
R19839 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R19840 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R19841 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R19842 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R19843 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R19844 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R19845 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R19846 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R19847 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R19848 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R19849 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R19850 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R19851 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R19852 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R19853 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R19854 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R19855 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R19856 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R19857 n1_m9_407200_93600 n1_m9_429600_93600 0.096000
R19858 n1_m9_429600_93600 n1_m9_452000_93600 0.096000
R19859 n1_m9_452000_93600 n1_m9_474400_93600 0.096000
R19860 n1_m9_474400_93600 n1_m9_496800_93600 0.096000
R19861 n1_m9_496800_93600 n1_m9_519200_93600 0.096000
R19862 n1_m9_519200_93600 n1_m9_541600_93600 0.096000
R19863 n1_m9_541600_93600 n1_m9_564000_93600 0.096000
R19864 n1_m9_564000_93600 n1_m9_586400_93600 0.096000
R19865 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R19866 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R19867 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R19868 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R19869 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R19870 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R19871 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R19872 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R19873 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R19874 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R19875 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R19876 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R19877 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R19878 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R19879 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R19880 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R19881 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R19882 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R19883 n1_m9_407200_116000 n1_m9_429600_116000 0.096000
R19884 n1_m9_429600_116000 n1_m9_452000_116000 0.096000
R19885 n1_m9_452000_116000 n1_m9_474400_116000 0.096000
R19886 n1_m9_474400_116000 n1_m9_496800_116000 0.096000
R19887 n1_m9_496800_116000 n1_m9_519200_116000 0.096000
R19888 n1_m9_519200_116000 n1_m9_541600_116000 0.096000
R19889 n1_m9_541600_116000 n1_m9_564000_116000 0.096000
R19890 n1_m9_564000_116000 n1_m9_586400_116000 0.096000
R19891 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R19892 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R19893 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R19894 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R19895 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R19896 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R19897 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R19898 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R19899 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R19900 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R19901 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R19902 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R19903 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R19904 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R19905 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R19906 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R19907 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R19908 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R19909 n1_m9_407200_138400 n1_m9_429600_138400 0.096000
R19910 n1_m9_429600_138400 n1_m9_452000_138400 0.096000
R19911 n1_m9_452000_138400 n1_m9_474400_138400 0.096000
R19912 n1_m9_474400_138400 n1_m9_496800_138400 0.096000
R19913 n1_m9_496800_138400 n1_m9_519200_138400 0.096000
R19914 n1_m9_519200_138400 n1_m9_541600_138400 0.096000
R19915 n1_m9_541600_138400 n1_m9_564000_138400 0.096000
R19916 n1_m9_564000_138400 n1_m9_586400_138400 0.096000
R19917 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R19918 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R19919 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R19920 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R19921 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R19922 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R19923 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R19924 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R19925 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R19926 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R19927 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R19928 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R19929 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R19930 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R19931 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R19932 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R19933 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R19934 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R19935 n1_m9_407200_160800 n1_m9_429600_160800 0.096000
R19936 n1_m9_429600_160800 n1_m9_452000_160800 0.096000
R19937 n1_m9_452000_160800 n1_m9_474400_160800 0.096000
R19938 n1_m9_474400_160800 n1_m9_496800_160800 0.096000
R19939 n1_m9_496800_160800 n1_m9_519200_160800 0.096000
R19940 n1_m9_519200_160800 n1_m9_541600_160800 0.096000
R19941 n1_m9_541600_160800 n1_m9_564000_160800 0.096000
R19942 n1_m9_564000_160800 n1_m9_586400_160800 0.096000
R19943 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R19944 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R19945 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R19946 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R19947 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R19948 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R19949 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R19950 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R19951 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R19952 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R19953 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R19954 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R19955 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R19956 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R19957 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R19958 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R19959 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R19960 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R19961 n1_m9_407200_183200 n1_m9_429600_183200 0.096000
R19962 n1_m9_429600_183200 n1_m9_452000_183200 0.096000
R19963 n1_m9_452000_183200 n1_m9_474400_183200 0.096000
R19964 n1_m9_474400_183200 n1_m9_496800_183200 0.096000
R19965 n1_m9_496800_183200 n1_m9_519200_183200 0.096000
R19966 n1_m9_519200_183200 n1_m9_541600_183200 0.096000
R19967 n1_m9_541600_183200 n1_m9_564000_183200 0.096000
R19968 n1_m9_564000_183200 n1_m9_586400_183200 0.096000
R19969 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R19970 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R19971 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R19972 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R19973 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R19974 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R19975 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R19976 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R19977 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R19978 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R19979 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R19980 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R19981 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R19982 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R19983 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R19984 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R19985 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R19986 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R19987 n1_m9_407200_205600 n1_m9_429600_205600 0.096000
R19988 n1_m9_429600_205600 n1_m9_452000_205600 0.096000
R19989 n1_m9_452000_205600 n1_m9_474400_205600 0.096000
R19990 n1_m9_474400_205600 n1_m9_496800_205600 0.096000
R19991 n1_m9_496800_205600 n1_m9_519200_205600 0.096000
R19992 n1_m9_519200_205600 n1_m9_541600_205600 0.096000
R19993 n1_m9_541600_205600 n1_m9_564000_205600 0.096000
R19994 n1_m9_564000_205600 n1_m9_586400_205600 0.096000
R19995 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R19996 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R19997 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R19998 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R19999 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R20000 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R20001 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R20002 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R20003 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R20004 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R20005 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R20006 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R20007 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R20008 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R20009 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R20010 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R20011 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R20012 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R20013 n1_m9_407200_228000 n1_m9_429600_228000 0.096000
R20014 n1_m9_429600_228000 n1_m9_452000_228000 0.096000
R20015 n1_m9_452000_228000 n1_m9_474400_228000 0.096000
R20016 n1_m9_474400_228000 n1_m9_496800_228000 0.096000
R20017 n1_m9_496800_228000 n1_m9_519200_228000 0.096000
R20018 n1_m9_519200_228000 n1_m9_541600_228000 0.096000
R20019 n1_m9_541600_228000 n1_m9_564000_228000 0.096000
R20020 n1_m9_564000_228000 n1_m9_586400_228000 0.096000
R20021 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R20022 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R20023 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R20024 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R20025 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R20026 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R20027 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R20028 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R20029 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R20030 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R20031 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R20032 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R20033 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R20034 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R20035 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R20036 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R20037 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R20038 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R20039 n1_m9_407200_250400 n1_m9_429600_250400 0.096000
R20040 n1_m9_429600_250400 n1_m9_452000_250400 0.096000
R20041 n1_m9_452000_250400 n1_m9_474400_250400 0.096000
R20042 n1_m9_474400_250400 n1_m9_496800_250400 0.096000
R20043 n1_m9_496800_250400 n1_m9_519200_250400 0.096000
R20044 n1_m9_519200_250400 n1_m9_541600_250400 0.096000
R20045 n1_m9_541600_250400 n1_m9_564000_250400 0.096000
R20046 n1_m9_564000_250400 n1_m9_586400_250400 0.096000
R20047 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R20048 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R20049 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R20050 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R20051 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R20052 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R20053 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R20054 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R20055 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R20056 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R20057 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R20058 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R20059 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R20060 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R20061 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R20062 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R20063 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R20064 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R20065 n1_m9_407200_272800 n1_m9_429600_272800 0.096000
R20066 n1_m9_429600_272800 n1_m9_452000_272800 0.096000
R20067 n1_m9_452000_272800 n1_m9_474400_272800 0.096000
R20068 n1_m9_474400_272800 n1_m9_496800_272800 0.096000
R20069 n1_m9_496800_272800 n1_m9_519200_272800 0.096000
R20070 n1_m9_519200_272800 n1_m9_541600_272800 0.096000
R20071 n1_m9_541600_272800 n1_m9_564000_272800 0.096000
R20072 n1_m9_564000_272800 n1_m9_586400_272800 0.096000
R20073 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R20074 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R20075 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R20076 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R20077 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R20078 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R20079 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R20080 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R20081 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R20082 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R20083 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R20084 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R20085 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R20086 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R20087 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R20088 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R20089 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R20090 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R20091 n1_m9_407200_295200 n1_m9_429600_295200 0.096000
R20092 n1_m9_429600_295200 n1_m9_452000_295200 0.096000
R20093 n1_m9_452000_295200 n1_m9_474400_295200 0.096000
R20094 n1_m9_474400_295200 n1_m9_496800_295200 0.096000
R20095 n1_m9_496800_295200 n1_m9_519200_295200 0.096000
R20096 n1_m9_519200_295200 n1_m9_541600_295200 0.096000
R20097 n1_m9_541600_295200 n1_m9_564000_295200 0.096000
R20098 n1_m9_564000_295200 n1_m9_586400_295200 0.096000
R20099 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R20100 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R20101 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R20102 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R20103 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R20104 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R20105 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R20106 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R20107 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R20108 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R20109 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R20110 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R20111 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R20112 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R20113 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R20114 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R20115 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R20116 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R20117 n1_m9_407200_317600 n1_m9_429600_317600 0.096000
R20118 n1_m9_429600_317600 n1_m9_452000_317600 0.096000
R20119 n1_m9_452000_317600 n1_m9_474400_317600 0.096000
R20120 n1_m9_474400_317600 n1_m9_496800_317600 0.096000
R20121 n1_m9_496800_317600 n1_m9_519200_317600 0.096000
R20122 n1_m9_519200_317600 n1_m9_541600_317600 0.096000
R20123 n1_m9_541600_317600 n1_m9_564000_317600 0.096000
R20124 n1_m9_564000_317600 n1_m9_586400_317600 0.096000
R20125 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R20126 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R20127 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R20128 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R20129 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R20130 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R20131 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R20132 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R20133 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R20134 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R20135 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R20136 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R20137 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R20138 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R20139 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R20140 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R20141 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R20142 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R20143 n1_m9_407200_340000 n1_m9_429600_340000 0.096000
R20144 n1_m9_429600_340000 n1_m9_452000_340000 0.096000
R20145 n1_m9_452000_340000 n1_m9_474400_340000 0.096000
R20146 n1_m9_474400_340000 n1_m9_496800_340000 0.096000
R20147 n1_m9_496800_340000 n1_m9_519200_340000 0.096000
R20148 n1_m9_519200_340000 n1_m9_541600_340000 0.096000
R20149 n1_m9_541600_340000 n1_m9_564000_340000 0.096000
R20150 n1_m9_564000_340000 n1_m9_586400_340000 0.096000
R20151 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R20152 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R20153 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R20154 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R20155 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R20156 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R20157 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R20158 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R20159 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R20160 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R20161 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R20162 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R20163 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R20164 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R20165 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R20166 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R20167 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R20168 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R20169 n1_m9_407200_362400 n1_m9_429600_362400 0.096000
R20170 n1_m9_429600_362400 n1_m9_452000_362400 0.096000
R20171 n1_m9_452000_362400 n1_m9_474400_362400 0.096000
R20172 n1_m9_474400_362400 n1_m9_496800_362400 0.096000
R20173 n1_m9_496800_362400 n1_m9_519200_362400 0.096000
R20174 n1_m9_519200_362400 n1_m9_541600_362400 0.096000
R20175 n1_m9_541600_362400 n1_m9_564000_362400 0.096000
R20176 n1_m9_564000_362400 n1_m9_586400_362400 0.096000
R20177 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R20178 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R20179 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R20180 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R20181 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R20182 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R20183 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R20184 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R20185 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R20186 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R20187 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R20188 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R20189 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R20190 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R20191 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R20192 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R20193 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R20194 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R20195 n1_m9_407200_384800 n1_m9_429600_384800 0.096000
R20196 n1_m9_429600_384800 n1_m9_452000_384800 0.096000
R20197 n1_m9_452000_384800 n1_m9_474400_384800 0.096000
R20198 n1_m9_474400_384800 n1_m9_496800_384800 0.096000
R20199 n1_m9_496800_384800 n1_m9_519200_384800 0.096000
R20200 n1_m9_519200_384800 n1_m9_541600_384800 0.096000
R20201 n1_m9_541600_384800 n1_m9_564000_384800 0.096000
R20202 n1_m9_564000_384800 n1_m9_586400_384800 0.096000
R20203 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R20204 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R20205 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R20206 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R20207 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R20208 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R20209 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R20210 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R20211 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R20212 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R20213 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R20214 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R20215 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R20216 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R20217 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R20218 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R20219 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R20220 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R20221 n1_m9_407200_407200 n1_m9_429600_407200 0.096000
R20222 n1_m9_429600_407200 n1_m9_452000_407200 0.096000
R20223 n1_m9_452000_407200 n1_m9_474400_407200 0.096000
R20224 n1_m9_474400_407200 n1_m9_496800_407200 0.096000
R20225 n1_m9_496800_407200 n1_m9_519200_407200 0.096000
R20226 n1_m9_519200_407200 n1_m9_541600_407200 0.096000
R20227 n1_m9_541600_407200 n1_m9_564000_407200 0.096000
R20228 n1_m9_564000_407200 n1_m9_586400_407200 0.096000
R20229 n1_m9_4000_429600 n1_m9_26400_429600 0.096000
R20230 n1_m9_26400_429600 n1_m9_48800_429600 0.096000
R20231 n1_m9_48800_429600 n1_m9_71200_429600 0.096000
R20232 n1_m9_71200_429600 n1_m9_93600_429600 0.096000
R20233 n1_m9_93600_429600 n1_m9_116000_429600 0.096000
R20234 n1_m9_116000_429600 n1_m9_138400_429600 0.096000
R20235 n1_m9_138400_429600 n1_m9_160800_429600 0.096000
R20236 n1_m9_160800_429600 n1_m9_183200_429600 0.096000
R20237 n1_m9_183200_429600 n1_m9_205600_429600 0.096000
R20238 n1_m9_205600_429600 n1_m9_228000_429600 0.096000
R20239 n1_m9_228000_429600 n1_m9_250400_429600 0.096000
R20240 n1_m9_250400_429600 n1_m9_272800_429600 0.096000
R20241 n1_m9_272800_429600 n1_m9_295200_429600 0.096000
R20242 n1_m9_295200_429600 n1_m9_317600_429600 0.096000
R20243 n1_m9_317600_429600 n1_m9_340000_429600 0.096000
R20244 n1_m9_340000_429600 n1_m9_362400_429600 0.096000
R20245 n1_m9_362400_429600 n1_m9_384800_429600 0.096000
R20246 n1_m9_384800_429600 n1_m9_407200_429600 0.096000
R20247 n1_m9_407200_429600 n1_m9_429600_429600 0.096000
R20248 n1_m9_429600_429600 n1_m9_452000_429600 0.096000
R20249 n1_m9_452000_429600 n1_m9_474400_429600 0.096000
R20250 n1_m9_474400_429600 n1_m9_496800_429600 0.096000
R20251 n1_m9_496800_429600 n1_m9_519200_429600 0.096000
R20252 n1_m9_519200_429600 n1_m9_541600_429600 0.096000
R20253 n1_m9_541600_429600 n1_m9_564000_429600 0.096000
R20254 n1_m9_564000_429600 n1_m9_586400_429600 0.096000
R20255 n1_m9_4000_452000 n1_m9_26400_452000 0.096000
R20256 n1_m9_26400_452000 n1_m9_48800_452000 0.096000
R20257 n1_m9_48800_452000 n1_m9_71200_452000 0.096000
R20258 n1_m9_71200_452000 n1_m9_93600_452000 0.096000
R20259 n1_m9_93600_452000 n1_m9_116000_452000 0.096000
R20260 n1_m9_116000_452000 n1_m9_138400_452000 0.096000
R20261 n1_m9_138400_452000 n1_m9_160800_452000 0.096000
R20262 n1_m9_160800_452000 n1_m9_183200_452000 0.096000
R20263 n1_m9_183200_452000 n1_m9_205600_452000 0.096000
R20264 n1_m9_205600_452000 n1_m9_228000_452000 0.096000
R20265 n1_m9_228000_452000 n1_m9_250400_452000 0.096000
R20266 n1_m9_250400_452000 n1_m9_272800_452000 0.096000
R20267 n1_m9_272800_452000 n1_m9_295200_452000 0.096000
R20268 n1_m9_295200_452000 n1_m9_317600_452000 0.096000
R20269 n1_m9_317600_452000 n1_m9_340000_452000 0.096000
R20270 n1_m9_340000_452000 n1_m9_362400_452000 0.096000
R20271 n1_m9_362400_452000 n1_m9_384800_452000 0.096000
R20272 n1_m9_384800_452000 n1_m9_407200_452000 0.096000
R20273 n1_m9_407200_452000 n1_m9_429600_452000 0.096000
R20274 n1_m9_429600_452000 n1_m9_452000_452000 0.096000
R20275 n1_m9_452000_452000 n1_m9_474400_452000 0.096000
R20276 n1_m9_474400_452000 n1_m9_496800_452000 0.096000
R20277 n1_m9_496800_452000 n1_m9_519200_452000 0.096000
R20278 n1_m9_519200_452000 n1_m9_541600_452000 0.096000
R20279 n1_m9_541600_452000 n1_m9_564000_452000 0.096000
R20280 n1_m9_564000_452000 n1_m9_586400_452000 0.096000
R20281 n1_m9_4000_474400 n1_m9_26400_474400 0.096000
R20282 n1_m9_26400_474400 n1_m9_48800_474400 0.096000
R20283 n1_m9_48800_474400 n1_m9_71200_474400 0.096000
R20284 n1_m9_71200_474400 n1_m9_93600_474400 0.096000
R20285 n1_m9_93600_474400 n1_m9_116000_474400 0.096000
R20286 n1_m9_116000_474400 n1_m9_138400_474400 0.096000
R20287 n1_m9_138400_474400 n1_m9_160800_474400 0.096000
R20288 n1_m9_160800_474400 n1_m9_183200_474400 0.096000
R20289 n1_m9_183200_474400 n1_m9_205600_474400 0.096000
R20290 n1_m9_205600_474400 n1_m9_228000_474400 0.096000
R20291 n1_m9_228000_474400 n1_m9_250400_474400 0.096000
R20292 n1_m9_250400_474400 n1_m9_272800_474400 0.096000
R20293 n1_m9_272800_474400 n1_m9_295200_474400 0.096000
R20294 n1_m9_295200_474400 n1_m9_317600_474400 0.096000
R20295 n1_m9_317600_474400 n1_m9_340000_474400 0.096000
R20296 n1_m9_340000_474400 n1_m9_362400_474400 0.096000
R20297 n1_m9_362400_474400 n1_m9_384800_474400 0.096000
R20298 n1_m9_384800_474400 n1_m9_407200_474400 0.096000
R20299 n1_m9_407200_474400 n1_m9_429600_474400 0.096000
R20300 n1_m9_429600_474400 n1_m9_452000_474400 0.096000
R20301 n1_m9_452000_474400 n1_m9_474400_474400 0.096000
R20302 n1_m9_474400_474400 n1_m9_496800_474400 0.096000
R20303 n1_m9_496800_474400 n1_m9_519200_474400 0.096000
R20304 n1_m9_519200_474400 n1_m9_541600_474400 0.096000
R20305 n1_m9_541600_474400 n1_m9_564000_474400 0.096000
R20306 n1_m9_564000_474400 n1_m9_586400_474400 0.096000
R20307 n1_m9_4000_496800 n1_m9_26400_496800 0.096000
R20308 n1_m9_26400_496800 n1_m9_48800_496800 0.096000
R20309 n1_m9_48800_496800 n1_m9_71200_496800 0.096000
R20310 n1_m9_71200_496800 n1_m9_93600_496800 0.096000
R20311 n1_m9_93600_496800 n1_m9_116000_496800 0.096000
R20312 n1_m9_116000_496800 n1_m9_138400_496800 0.096000
R20313 n1_m9_138400_496800 n1_m9_160800_496800 0.096000
R20314 n1_m9_160800_496800 n1_m9_183200_496800 0.096000
R20315 n1_m9_183200_496800 n1_m9_205600_496800 0.096000
R20316 n1_m9_205600_496800 n1_m9_228000_496800 0.096000
R20317 n1_m9_228000_496800 n1_m9_250400_496800 0.096000
R20318 n1_m9_250400_496800 n1_m9_272800_496800 0.096000
R20319 n1_m9_272800_496800 n1_m9_295200_496800 0.096000
R20320 n1_m9_295200_496800 n1_m9_317600_496800 0.096000
R20321 n1_m9_317600_496800 n1_m9_340000_496800 0.096000
R20322 n1_m9_340000_496800 n1_m9_362400_496800 0.096000
R20323 n1_m9_362400_496800 n1_m9_384800_496800 0.096000
R20324 n1_m9_384800_496800 n1_m9_407200_496800 0.096000
R20325 n1_m9_407200_496800 n1_m9_429600_496800 0.096000
R20326 n1_m9_429600_496800 n1_m9_452000_496800 0.096000
R20327 n1_m9_452000_496800 n1_m9_474400_496800 0.096000
R20328 n1_m9_474400_496800 n1_m9_496800_496800 0.096000
R20329 n1_m9_496800_496800 n1_m9_519200_496800 0.096000
R20330 n1_m9_519200_496800 n1_m9_541600_496800 0.096000
R20331 n1_m9_541600_496800 n1_m9_564000_496800 0.096000
R20332 n1_m9_564000_496800 n1_m9_586400_496800 0.096000
R20333 n1_m9_4000_519200 n1_m9_26400_519200 0.096000
R20334 n1_m9_26400_519200 n1_m9_48800_519200 0.096000
R20335 n1_m9_48800_519200 n1_m9_71200_519200 0.096000
R20336 n1_m9_71200_519200 n1_m9_93600_519200 0.096000
R20337 n1_m9_93600_519200 n1_m9_116000_519200 0.096000
R20338 n1_m9_116000_519200 n1_m9_138400_519200 0.096000
R20339 n1_m9_138400_519200 n1_m9_160800_519200 0.096000
R20340 n1_m9_160800_519200 n1_m9_183200_519200 0.096000
R20341 n1_m9_183200_519200 n1_m9_205600_519200 0.096000
R20342 n1_m9_205600_519200 n1_m9_228000_519200 0.096000
R20343 n1_m9_228000_519200 n1_m9_250400_519200 0.096000
R20344 n1_m9_250400_519200 n1_m9_272800_519200 0.096000
R20345 n1_m9_272800_519200 n1_m9_295200_519200 0.096000
R20346 n1_m9_295200_519200 n1_m9_317600_519200 0.096000
R20347 n1_m9_317600_519200 n1_m9_340000_519200 0.096000
R20348 n1_m9_340000_519200 n1_m9_362400_519200 0.096000
R20349 n1_m9_362400_519200 n1_m9_384800_519200 0.096000
R20350 n1_m9_384800_519200 n1_m9_407200_519200 0.096000
R20351 n1_m9_407200_519200 n1_m9_429600_519200 0.096000
R20352 n1_m9_429600_519200 n1_m9_452000_519200 0.096000
R20353 n1_m9_452000_519200 n1_m9_474400_519200 0.096000
R20354 n1_m9_474400_519200 n1_m9_496800_519200 0.096000
R20355 n1_m9_496800_519200 n1_m9_519200_519200 0.096000
R20356 n1_m9_519200_519200 n1_m9_541600_519200 0.096000
R20357 n1_m9_541600_519200 n1_m9_564000_519200 0.096000
R20358 n1_m9_564000_519200 n1_m9_586400_519200 0.096000
R20359 n1_m9_4000_541600 n1_m9_26400_541600 0.096000
R20360 n1_m9_26400_541600 n1_m9_48800_541600 0.096000
R20361 n1_m9_48800_541600 n1_m9_71200_541600 0.096000
R20362 n1_m9_71200_541600 n1_m9_93600_541600 0.096000
R20363 n1_m9_93600_541600 n1_m9_116000_541600 0.096000
R20364 n1_m9_116000_541600 n1_m9_138400_541600 0.096000
R20365 n1_m9_138400_541600 n1_m9_160800_541600 0.096000
R20366 n1_m9_160800_541600 n1_m9_183200_541600 0.096000
R20367 n1_m9_183200_541600 n1_m9_205600_541600 0.096000
R20368 n1_m9_205600_541600 n1_m9_228000_541600 0.096000
R20369 n1_m9_228000_541600 n1_m9_250400_541600 0.096000
R20370 n1_m9_250400_541600 n1_m9_272800_541600 0.096000
R20371 n1_m9_272800_541600 n1_m9_295200_541600 0.096000
R20372 n1_m9_295200_541600 n1_m9_317600_541600 0.096000
R20373 n1_m9_317600_541600 n1_m9_340000_541600 0.096000
R20374 n1_m9_340000_541600 n1_m9_362400_541600 0.096000
R20375 n1_m9_362400_541600 n1_m9_384800_541600 0.096000
R20376 n1_m9_384800_541600 n1_m9_407200_541600 0.096000
R20377 n1_m9_407200_541600 n1_m9_429600_541600 0.096000
R20378 n1_m9_429600_541600 n1_m9_452000_541600 0.096000
R20379 n1_m9_452000_541600 n1_m9_474400_541600 0.096000
R20380 n1_m9_474400_541600 n1_m9_496800_541600 0.096000
R20381 n1_m9_496800_541600 n1_m9_519200_541600 0.096000
R20382 n1_m9_519200_541600 n1_m9_541600_541600 0.096000
R20383 n1_m9_541600_541600 n1_m9_564000_541600 0.096000
R20384 n1_m9_564000_541600 n1_m9_586400_541600 0.096000
R20385 n1_m9_4000_564000 n1_m9_26400_564000 0.096000
R20386 n1_m9_26400_564000 n1_m9_48800_564000 0.096000
R20387 n1_m9_48800_564000 n1_m9_71200_564000 0.096000
R20388 n1_m9_71200_564000 n1_m9_93600_564000 0.096000
R20389 n1_m9_93600_564000 n1_m9_116000_564000 0.096000
R20390 n1_m9_116000_564000 n1_m9_138400_564000 0.096000
R20391 n1_m9_138400_564000 n1_m9_160800_564000 0.096000
R20392 n1_m9_160800_564000 n1_m9_183200_564000 0.096000
R20393 n1_m9_183200_564000 n1_m9_205600_564000 0.096000
R20394 n1_m9_205600_564000 n1_m9_228000_564000 0.096000
R20395 n1_m9_228000_564000 n1_m9_250400_564000 0.096000
R20396 n1_m9_250400_564000 n1_m9_272800_564000 0.096000
R20397 n1_m9_272800_564000 n1_m9_295200_564000 0.096000
R20398 n1_m9_295200_564000 n1_m9_317600_564000 0.096000
R20399 n1_m9_317600_564000 n1_m9_340000_564000 0.096000
R20400 n1_m9_340000_564000 n1_m9_362400_564000 0.096000
R20401 n1_m9_362400_564000 n1_m9_384800_564000 0.096000
R20402 n1_m9_384800_564000 n1_m9_407200_564000 0.096000
R20403 n1_m9_407200_564000 n1_m9_429600_564000 0.096000
R20404 n1_m9_429600_564000 n1_m9_452000_564000 0.096000
R20405 n1_m9_452000_564000 n1_m9_474400_564000 0.096000
R20406 n1_m9_474400_564000 n1_m9_496800_564000 0.096000
R20407 n1_m9_496800_564000 n1_m9_519200_564000 0.096000
R20408 n1_m9_519200_564000 n1_m9_541600_564000 0.096000
R20409 n1_m9_541600_564000 n1_m9_564000_564000 0.096000
R20410 n1_m9_564000_564000 n1_m9_586400_564000 0.096000
R20411 n1_m9_4000_586400 n1_m9_26400_586400 0.096000
R20412 n1_m9_26400_586400 n1_m9_48800_586400 0.096000
R20413 n1_m9_48800_586400 n1_m9_71200_586400 0.096000
R20414 n1_m9_71200_586400 n1_m9_93600_586400 0.096000
R20415 n1_m9_93600_586400 n1_m9_116000_586400 0.096000
R20416 n1_m9_116000_586400 n1_m9_138400_586400 0.096000
R20417 n1_m9_138400_586400 n1_m9_160800_586400 0.096000
R20418 n1_m9_160800_586400 n1_m9_183200_586400 0.096000
R20419 n1_m9_183200_586400 n1_m9_205600_586400 0.096000
R20420 n1_m9_205600_586400 n1_m9_228000_586400 0.096000
R20421 n1_m9_228000_586400 n1_m9_250400_586400 0.096000
R20422 n1_m9_250400_586400 n1_m9_272800_586400 0.096000
R20423 n1_m9_272800_586400 n1_m9_295200_586400 0.096000
R20424 n1_m9_295200_586400 n1_m9_317600_586400 0.096000
R20425 n1_m9_317600_586400 n1_m9_340000_586400 0.096000
R20426 n1_m9_340000_586400 n1_m9_362400_586400 0.096000
R20427 n1_m9_362400_586400 n1_m9_384800_586400 0.096000
R20428 n1_m9_384800_586400 n1_m9_407200_586400 0.096000
R20429 n1_m9_407200_586400 n1_m9_429600_586400 0.096000
R20430 n1_m9_429600_586400 n1_m9_452000_586400 0.096000
R20431 n1_m9_452000_586400 n1_m9_474400_586400 0.096000
R20432 n1_m9_474400_586400 n1_m9_496800_586400 0.096000
R20433 n1_m9_496800_586400 n1_m9_519200_586400 0.096000
R20434 n1_m9_519200_586400 n1_m9_541600_586400 0.096000
R20435 n1_m9_541600_586400 n1_m9_564000_586400 0.096000
R20436 n1_m9_564000_586400 n1_m9_586400_586400 0.096000
R20437 n1_m1_4000_0 n1_m4_4000_0 15.000000
R20438 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R20439 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R20440 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R20441 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R20442 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R20443 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R20444 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R20445 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R20446 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R20447 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R20448 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R20449 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R20450 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R20451 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R20452 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R20453 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R20454 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R20455 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R20456 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R20457 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R20458 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R20459 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R20460 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R20461 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R20462 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R20463 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R20464 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R20465 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R20466 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R20467 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R20468 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R20469 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R20470 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R20471 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R20472 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R20473 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R20474 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R20475 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R20476 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R20477 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R20478 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R20479 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R20480 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R20481 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R20482 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R20483 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R20484 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R20485 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R20486 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R20487 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R20488 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R20489 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R20490 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R20491 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R20492 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R20493 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R20494 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R20495 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R20496 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R20497 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R20498 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R20499 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R20500 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R20501 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R20502 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R20503 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R20504 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R20505 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R20506 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R20507 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R20508 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R20509 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R20510 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R20511 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R20512 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R20513 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R20514 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R20515 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R20516 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R20517 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R20518 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R20519 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R20520 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R20521 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R20522 n1_m1_4000_408000 n1_m4_4000_408000 15.000000
R20523 n1_m1_4000_412800 n1_m4_4000_412800 15.000000
R20524 n1_m1_4000_417600 n1_m4_4000_417600 15.000000
R20525 n1_m1_4000_422400 n1_m4_4000_422400 15.000000
R20526 n1_m1_4000_427200 n1_m4_4000_427200 15.000000
R20527 n1_m1_4000_432000 n1_m4_4000_432000 15.000000
R20528 n1_m1_4000_436800 n1_m4_4000_436800 15.000000
R20529 n1_m1_4000_441600 n1_m4_4000_441600 15.000000
R20530 n1_m1_4000_446400 n1_m4_4000_446400 15.000000
R20531 n1_m1_4000_451200 n1_m4_4000_451200 15.000000
R20532 n1_m1_4000_456000 n1_m4_4000_456000 15.000000
R20533 n1_m1_4000_460800 n1_m4_4000_460800 15.000000
R20534 n1_m1_4000_465600 n1_m4_4000_465600 15.000000
R20535 n1_m1_4000_470400 n1_m4_4000_470400 15.000000
R20536 n1_m1_4000_475200 n1_m4_4000_475200 15.000000
R20537 n1_m1_4000_480000 n1_m4_4000_480000 15.000000
R20538 n1_m1_4000_484800 n1_m4_4000_484800 15.000000
R20539 n1_m1_4000_489600 n1_m4_4000_489600 15.000000
R20540 n1_m1_4000_494400 n1_m4_4000_494400 15.000000
R20541 n1_m1_4000_499200 n1_m4_4000_499200 15.000000
R20542 n1_m1_4000_504000 n1_m4_4000_504000 15.000000
R20543 n1_m1_4000_508800 n1_m4_4000_508800 15.000000
R20544 n1_m1_4000_513600 n1_m4_4000_513600 15.000000
R20545 n1_m1_4000_518400 n1_m4_4000_518400 15.000000
R20546 n1_m1_4000_523200 n1_m4_4000_523200 15.000000
R20547 n1_m1_4000_528000 n1_m4_4000_528000 15.000000
R20548 n1_m1_4000_532800 n1_m4_4000_532800 15.000000
R20549 n1_m1_4000_537600 n1_m4_4000_537600 15.000000
R20550 n1_m1_4000_542400 n1_m4_4000_542400 15.000000
R20551 n1_m1_4000_547200 n1_m4_4000_547200 15.000000
R20552 n1_m1_4000_552000 n1_m4_4000_552000 15.000000
R20553 n1_m1_4000_556800 n1_m4_4000_556800 15.000000
R20554 n1_m1_4000_561600 n1_m4_4000_561600 15.000000
R20555 n1_m1_4000_566400 n1_m4_4000_566400 15.000000
R20556 n1_m1_4000_571200 n1_m4_4000_571200 15.000000
R20557 n1_m1_4000_576000 n1_m4_4000_576000 15.000000
R20558 n1_m1_4000_580800 n1_m4_4000_580800 15.000000
R20559 n1_m1_4000_585600 n1_m4_4000_585600 15.000000
R20560 n1_m1_4000_590400 n1_m4_4000_590400 15.000000
R20561 n1_m1_4000_595200 n1_m4_4000_595200 15.000000
R20562 n1_m1_32000_0 n1_m4_32000_0 15.000000
R20563 n1_m1_60000_0 n1_m4_60000_0 15.000000
R20564 n1_m1_88000_0 n1_m4_88000_0 15.000000
R20565 n1_m1_116000_0 n1_m4_116000_0 15.000000
R20566 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R20567 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R20568 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R20569 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R20570 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R20571 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R20572 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R20573 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R20574 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R20575 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R20576 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R20577 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R20578 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R20579 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R20580 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R20581 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R20582 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R20583 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R20584 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R20585 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R20586 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R20587 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R20588 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R20589 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R20590 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R20591 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R20592 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R20593 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R20594 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R20595 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R20596 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R20597 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R20598 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R20599 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R20600 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R20601 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R20602 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R20603 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R20604 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R20605 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R20606 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R20607 n1_m1_116000_201600 n1_m4_116000_201600 15.000000
R20608 n1_m1_116000_206400 n1_m4_116000_206400 15.000000
R20609 n1_m1_116000_211200 n1_m4_116000_211200 15.000000
R20610 n1_m1_116000_216000 n1_m4_116000_216000 15.000000
R20611 n1_m1_116000_220800 n1_m4_116000_220800 15.000000
R20612 n1_m1_116000_225600 n1_m4_116000_225600 15.000000
R20613 n1_m1_116000_230400 n1_m4_116000_230400 15.000000
R20614 n1_m1_116000_235200 n1_m4_116000_235200 15.000000
R20615 n1_m1_116000_240000 n1_m4_116000_240000 15.000000
R20616 n1_m1_116000_244800 n1_m4_116000_244800 15.000000
R20617 n1_m1_116000_249600 n1_m4_116000_249600 15.000000
R20618 n1_m1_116000_254400 n1_m4_116000_254400 15.000000
R20619 n1_m1_116000_259200 n1_m4_116000_259200 15.000000
R20620 n1_m1_116000_264000 n1_m4_116000_264000 15.000000
R20621 n1_m1_116000_268800 n1_m4_116000_268800 15.000000
R20622 n1_m1_116000_273600 n1_m4_116000_273600 15.000000
R20623 n1_m1_116000_278400 n1_m4_116000_278400 15.000000
R20624 n1_m1_116000_283200 n1_m4_116000_283200 15.000000
R20625 n1_m1_116000_288000 n1_m4_116000_288000 15.000000
R20626 n1_m1_116000_292800 n1_m4_116000_292800 15.000000
R20627 n1_m1_116000_297600 n1_m4_116000_297600 15.000000
R20628 n1_m1_116000_302400 n1_m4_116000_302400 15.000000
R20629 n1_m1_116000_307200 n1_m4_116000_307200 15.000000
R20630 n1_m1_116000_312000 n1_m4_116000_312000 15.000000
R20631 n1_m1_116000_316800 n1_m4_116000_316800 15.000000
R20632 n1_m1_116000_321600 n1_m4_116000_321600 15.000000
R20633 n1_m1_116000_326400 n1_m4_116000_326400 15.000000
R20634 n1_m1_116000_331200 n1_m4_116000_331200 15.000000
R20635 n1_m1_116000_336000 n1_m4_116000_336000 15.000000
R20636 n1_m1_116000_340800 n1_m4_116000_340800 15.000000
R20637 n1_m1_116000_345600 n1_m4_116000_345600 15.000000
R20638 n1_m1_116000_350400 n1_m4_116000_350400 15.000000
R20639 n1_m1_116000_355200 n1_m4_116000_355200 15.000000
R20640 n1_m1_116000_360000 n1_m4_116000_360000 15.000000
R20641 n1_m1_116000_364800 n1_m4_116000_364800 15.000000
R20642 n1_m1_116000_369600 n1_m4_116000_369600 15.000000
R20643 n1_m1_116000_374400 n1_m4_116000_374400 15.000000
R20644 n1_m1_116000_379200 n1_m4_116000_379200 15.000000
R20645 n1_m1_116000_384000 n1_m4_116000_384000 15.000000
R20646 n1_m1_116000_388800 n1_m4_116000_388800 15.000000
R20647 n1_m1_116000_393600 n1_m4_116000_393600 15.000000
R20648 n1_m1_116000_398400 n1_m4_116000_398400 15.000000
R20649 n1_m1_116000_403200 n1_m4_116000_403200 15.000000
R20650 n1_m1_116000_408000 n1_m4_116000_408000 15.000000
R20651 n1_m1_116000_412800 n1_m4_116000_412800 15.000000
R20652 n1_m1_116000_417600 n1_m4_116000_417600 15.000000
R20653 n1_m1_116000_422400 n1_m4_116000_422400 15.000000
R20654 n1_m1_116000_427200 n1_m4_116000_427200 15.000000
R20655 n1_m1_116000_432000 n1_m4_116000_432000 15.000000
R20656 n1_m1_116000_436800 n1_m4_116000_436800 15.000000
R20657 n1_m1_116000_441600 n1_m4_116000_441600 15.000000
R20658 n1_m1_116000_446400 n1_m4_116000_446400 15.000000
R20659 n1_m1_116000_451200 n1_m4_116000_451200 15.000000
R20660 n1_m1_116000_456000 n1_m4_116000_456000 15.000000
R20661 n1_m1_116000_460800 n1_m4_116000_460800 15.000000
R20662 n1_m1_116000_465600 n1_m4_116000_465600 15.000000
R20663 n1_m1_116000_470400 n1_m4_116000_470400 15.000000
R20664 n1_m1_116000_475200 n1_m4_116000_475200 15.000000
R20665 n1_m1_116000_480000 n1_m4_116000_480000 15.000000
R20666 n1_m1_116000_484800 n1_m4_116000_484800 15.000000
R20667 n1_m1_116000_489600 n1_m4_116000_489600 15.000000
R20668 n1_m1_116000_494400 n1_m4_116000_494400 15.000000
R20669 n1_m1_116000_499200 n1_m4_116000_499200 15.000000
R20670 n1_m1_116000_504000 n1_m4_116000_504000 15.000000
R20671 n1_m1_116000_508800 n1_m4_116000_508800 15.000000
R20672 n1_m1_116000_513600 n1_m4_116000_513600 15.000000
R20673 n1_m1_116000_518400 n1_m4_116000_518400 15.000000
R20674 n1_m1_116000_523200 n1_m4_116000_523200 15.000000
R20675 n1_m1_116000_528000 n1_m4_116000_528000 15.000000
R20676 n1_m1_116000_532800 n1_m4_116000_532800 15.000000
R20677 n1_m1_116000_537600 n1_m4_116000_537600 15.000000
R20678 n1_m1_116000_542400 n1_m4_116000_542400 15.000000
R20679 n1_m1_116000_547200 n1_m4_116000_547200 15.000000
R20680 n1_m1_116000_552000 n1_m4_116000_552000 15.000000
R20681 n1_m1_116000_556800 n1_m4_116000_556800 15.000000
R20682 n1_m1_116000_561600 n1_m4_116000_561600 15.000000
R20683 n1_m1_116000_566400 n1_m4_116000_566400 15.000000
R20684 n1_m1_116000_571200 n1_m4_116000_571200 15.000000
R20685 n1_m1_116000_576000 n1_m4_116000_576000 15.000000
R20686 n1_m1_116000_580800 n1_m4_116000_580800 15.000000
R20687 n1_m1_116000_585600 n1_m4_116000_585600 15.000000
R20688 n1_m1_116000_590400 n1_m4_116000_590400 15.000000
R20689 n1_m1_116000_595200 n1_m4_116000_595200 15.000000
R20690 n1_m1_144000_0 n1_m4_144000_0 15.000000
R20691 n1_m1_172000_0 n1_m4_172000_0 15.000000
R20692 n1_m1_200000_0 n1_m4_200000_0 15.000000
R20693 n1_m1_228000_0 n1_m4_228000_0 15.000000
R20694 n1_m1_256000_0 n1_m4_256000_0 15.000000
R20695 n1_m1_284000_0 n1_m4_284000_0 15.000000
R20696 n1_m1_312000_0 n1_m4_312000_0 15.000000
R20697 n1_m1_312000_4800 n1_m4_312000_4800 15.000000
R20698 n1_m1_312000_9600 n1_m4_312000_9600 15.000000
R20699 n1_m1_312000_14400 n1_m4_312000_14400 15.000000
R20700 n1_m1_312000_19200 n1_m4_312000_19200 15.000000
R20701 n1_m1_312000_24000 n1_m4_312000_24000 15.000000
R20702 n1_m1_312000_28800 n1_m4_312000_28800 15.000000
R20703 n1_m1_312000_33600 n1_m4_312000_33600 15.000000
R20704 n1_m1_312000_38400 n1_m4_312000_38400 15.000000
R20705 n1_m1_312000_43200 n1_m4_312000_43200 15.000000
R20706 n1_m1_312000_48000 n1_m4_312000_48000 15.000000
R20707 n1_m1_312000_52800 n1_m4_312000_52800 15.000000
R20708 n1_m1_312000_57600 n1_m4_312000_57600 15.000000
R20709 n1_m1_312000_62400 n1_m4_312000_62400 15.000000
R20710 n1_m1_312000_67200 n1_m4_312000_67200 15.000000
R20711 n1_m1_312000_72000 n1_m4_312000_72000 15.000000
R20712 n1_m1_312000_76800 n1_m4_312000_76800 15.000000
R20713 n1_m1_312000_81600 n1_m4_312000_81600 15.000000
R20714 n1_m1_312000_86400 n1_m4_312000_86400 15.000000
R20715 n1_m1_312000_91200 n1_m4_312000_91200 15.000000
R20716 n1_m1_312000_96000 n1_m4_312000_96000 15.000000
R20717 n1_m1_312000_100800 n1_m4_312000_100800 15.000000
R20718 n1_m1_312000_105600 n1_m4_312000_105600 15.000000
R20719 n1_m1_312000_110400 n1_m4_312000_110400 15.000000
R20720 n1_m1_312000_115200 n1_m4_312000_115200 15.000000
R20721 n1_m1_312000_120000 n1_m4_312000_120000 15.000000
R20722 n1_m1_312000_124800 n1_m4_312000_124800 15.000000
R20723 n1_m1_312000_129600 n1_m4_312000_129600 15.000000
R20724 n1_m1_312000_134400 n1_m4_312000_134400 15.000000
R20725 n1_m1_312000_139200 n1_m4_312000_139200 15.000000
R20726 n1_m1_312000_144000 n1_m4_312000_144000 15.000000
R20727 n1_m1_312000_148800 n1_m4_312000_148800 15.000000
R20728 n1_m1_312000_153600 n1_m4_312000_153600 15.000000
R20729 n1_m1_312000_158400 n1_m4_312000_158400 15.000000
R20730 n1_m1_312000_163200 n1_m4_312000_163200 15.000000
R20731 n1_m1_312000_168000 n1_m4_312000_168000 15.000000
R20732 n1_m1_312000_172800 n1_m4_312000_172800 15.000000
R20733 n1_m1_312000_177600 n1_m4_312000_177600 15.000000
R20734 n1_m1_312000_182400 n1_m4_312000_182400 15.000000
R20735 n1_m1_312000_187200 n1_m4_312000_187200 15.000000
R20736 n1_m1_312000_192000 n1_m4_312000_192000 15.000000
R20737 n1_m1_312000_196800 n1_m4_312000_196800 15.000000
R20738 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R20739 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R20740 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R20741 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R20742 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R20743 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R20744 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R20745 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R20746 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R20747 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R20748 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R20749 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R20750 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R20751 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R20752 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R20753 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R20754 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R20755 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R20756 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R20757 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R20758 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R20759 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R20760 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R20761 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R20762 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R20763 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R20764 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R20765 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R20766 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R20767 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R20768 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R20769 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R20770 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R20771 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R20772 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R20773 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R20774 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R20775 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R20776 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R20777 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R20778 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R20779 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R20780 n1_m1_312000_403200 n1_m4_312000_403200 15.000000
R20781 n1_m1_312000_408000 n1_m4_312000_408000 15.000000
R20782 n1_m1_312000_412800 n1_m4_312000_412800 15.000000
R20783 n1_m1_312000_417600 n1_m4_312000_417600 15.000000
R20784 n1_m1_312000_422400 n1_m4_312000_422400 15.000000
R20785 n1_m1_312000_427200 n1_m4_312000_427200 15.000000
R20786 n1_m1_312000_432000 n1_m4_312000_432000 15.000000
R20787 n1_m1_312000_436800 n1_m4_312000_436800 15.000000
R20788 n1_m1_312000_441600 n1_m4_312000_441600 15.000000
R20789 n1_m1_312000_446400 n1_m4_312000_446400 15.000000
R20790 n1_m1_312000_451200 n1_m4_312000_451200 15.000000
R20791 n1_m1_312000_456000 n1_m4_312000_456000 15.000000
R20792 n1_m1_312000_460800 n1_m4_312000_460800 15.000000
R20793 n1_m1_312000_465600 n1_m4_312000_465600 15.000000
R20794 n1_m1_312000_470400 n1_m4_312000_470400 15.000000
R20795 n1_m1_312000_475200 n1_m4_312000_475200 15.000000
R20796 n1_m1_312000_480000 n1_m4_312000_480000 15.000000
R20797 n1_m1_312000_484800 n1_m4_312000_484800 15.000000
R20798 n1_m1_312000_489600 n1_m4_312000_489600 15.000000
R20799 n1_m1_312000_494400 n1_m4_312000_494400 15.000000
R20800 n1_m1_312000_499200 n1_m4_312000_499200 15.000000
R20801 n1_m1_312000_504000 n1_m4_312000_504000 15.000000
R20802 n1_m1_312000_508800 n1_m4_312000_508800 15.000000
R20803 n1_m1_312000_513600 n1_m4_312000_513600 15.000000
R20804 n1_m1_312000_518400 n1_m4_312000_518400 15.000000
R20805 n1_m1_312000_523200 n1_m4_312000_523200 15.000000
R20806 n1_m1_312000_528000 n1_m4_312000_528000 15.000000
R20807 n1_m1_312000_532800 n1_m4_312000_532800 15.000000
R20808 n1_m1_312000_537600 n1_m4_312000_537600 15.000000
R20809 n1_m1_312000_542400 n1_m4_312000_542400 15.000000
R20810 n1_m1_312000_547200 n1_m4_312000_547200 15.000000
R20811 n1_m1_312000_552000 n1_m4_312000_552000 15.000000
R20812 n1_m1_312000_556800 n1_m4_312000_556800 15.000000
R20813 n1_m1_312000_561600 n1_m4_312000_561600 15.000000
R20814 n1_m1_312000_566400 n1_m4_312000_566400 15.000000
R20815 n1_m1_312000_571200 n1_m4_312000_571200 15.000000
R20816 n1_m1_312000_576000 n1_m4_312000_576000 15.000000
R20817 n1_m1_312000_580800 n1_m4_312000_580800 15.000000
R20818 n1_m1_312000_585600 n1_m4_312000_585600 15.000000
R20819 n1_m1_312000_590400 n1_m4_312000_590400 15.000000
R20820 n1_m1_312000_595200 n1_m4_312000_595200 15.000000
R20821 n1_m1_340000_0 n1_m4_340000_0 15.000000
R20822 n1_m1_368000_0 n1_m4_368000_0 15.000000
R20823 n1_m1_396000_0 n1_m4_396000_0 15.000000
R20824 n1_m1_424000_0 n1_m4_424000_0 15.000000
R20825 n1_m1_424000_4800 n1_m4_424000_4800 15.000000
R20826 n1_m1_424000_9600 n1_m4_424000_9600 15.000000
R20827 n1_m1_424000_14400 n1_m4_424000_14400 15.000000
R20828 n1_m1_424000_19200 n1_m4_424000_19200 15.000000
R20829 n1_m1_424000_24000 n1_m4_424000_24000 15.000000
R20830 n1_m1_424000_28800 n1_m4_424000_28800 15.000000
R20831 n1_m1_424000_33600 n1_m4_424000_33600 15.000000
R20832 n1_m1_424000_38400 n1_m4_424000_38400 15.000000
R20833 n1_m1_424000_43200 n1_m4_424000_43200 15.000000
R20834 n1_m1_424000_48000 n1_m4_424000_48000 15.000000
R20835 n1_m1_424000_52800 n1_m4_424000_52800 15.000000
R20836 n1_m1_424000_57600 n1_m4_424000_57600 15.000000
R20837 n1_m1_424000_62400 n1_m4_424000_62400 15.000000
R20838 n1_m1_424000_67200 n1_m4_424000_67200 15.000000
R20839 n1_m1_424000_72000 n1_m4_424000_72000 15.000000
R20840 n1_m1_424000_76800 n1_m4_424000_76800 15.000000
R20841 n1_m1_424000_81600 n1_m4_424000_81600 15.000000
R20842 n1_m1_424000_86400 n1_m4_424000_86400 15.000000
R20843 n1_m1_424000_91200 n1_m4_424000_91200 15.000000
R20844 n1_m1_424000_96000 n1_m4_424000_96000 15.000000
R20845 n1_m1_424000_100800 n1_m4_424000_100800 15.000000
R20846 n1_m1_424000_105600 n1_m4_424000_105600 15.000000
R20847 n1_m1_424000_110400 n1_m4_424000_110400 15.000000
R20848 n1_m1_424000_115200 n1_m4_424000_115200 15.000000
R20849 n1_m1_424000_120000 n1_m4_424000_120000 15.000000
R20850 n1_m1_424000_124800 n1_m4_424000_124800 15.000000
R20851 n1_m1_424000_129600 n1_m4_424000_129600 15.000000
R20852 n1_m1_424000_134400 n1_m4_424000_134400 15.000000
R20853 n1_m1_424000_139200 n1_m4_424000_139200 15.000000
R20854 n1_m1_424000_144000 n1_m4_424000_144000 15.000000
R20855 n1_m1_424000_148800 n1_m4_424000_148800 15.000000
R20856 n1_m1_424000_153600 n1_m4_424000_153600 15.000000
R20857 n1_m1_424000_158400 n1_m4_424000_158400 15.000000
R20858 n1_m1_424000_163200 n1_m4_424000_163200 15.000000
R20859 n1_m1_424000_168000 n1_m4_424000_168000 15.000000
R20860 n1_m1_424000_172800 n1_m4_424000_172800 15.000000
R20861 n1_m1_424000_177600 n1_m4_424000_177600 15.000000
R20862 n1_m1_424000_182400 n1_m4_424000_182400 15.000000
R20863 n1_m1_424000_187200 n1_m4_424000_187200 15.000000
R20864 n1_m1_424000_192000 n1_m4_424000_192000 15.000000
R20865 n1_m1_424000_196800 n1_m4_424000_196800 15.000000
R20866 n1_m1_424000_201600 n1_m4_424000_201600 15.000000
R20867 n1_m1_424000_206400 n1_m4_424000_206400 15.000000
R20868 n1_m1_424000_211200 n1_m4_424000_211200 15.000000
R20869 n1_m1_424000_216000 n1_m4_424000_216000 15.000000
R20870 n1_m1_424000_220800 n1_m4_424000_220800 15.000000
R20871 n1_m1_424000_225600 n1_m4_424000_225600 15.000000
R20872 n1_m1_424000_230400 n1_m4_424000_230400 15.000000
R20873 n1_m1_424000_235200 n1_m4_424000_235200 15.000000
R20874 n1_m1_424000_240000 n1_m4_424000_240000 15.000000
R20875 n1_m1_424000_244800 n1_m4_424000_244800 15.000000
R20876 n1_m1_424000_249600 n1_m4_424000_249600 15.000000
R20877 n1_m1_424000_254400 n1_m4_424000_254400 15.000000
R20878 n1_m1_424000_259200 n1_m4_424000_259200 15.000000
R20879 n1_m1_424000_264000 n1_m4_424000_264000 15.000000
R20880 n1_m1_424000_268800 n1_m4_424000_268800 15.000000
R20881 n1_m1_424000_273600 n1_m4_424000_273600 15.000000
R20882 n1_m1_424000_278400 n1_m4_424000_278400 15.000000
R20883 n1_m1_424000_283200 n1_m4_424000_283200 15.000000
R20884 n1_m1_424000_288000 n1_m4_424000_288000 15.000000
R20885 n1_m1_424000_292800 n1_m4_424000_292800 15.000000
R20886 n1_m1_424000_297600 n1_m4_424000_297600 15.000000
R20887 n1_m1_424000_302400 n1_m4_424000_302400 15.000000
R20888 n1_m1_424000_307200 n1_m4_424000_307200 15.000000
R20889 n1_m1_424000_312000 n1_m4_424000_312000 15.000000
R20890 n1_m1_424000_316800 n1_m4_424000_316800 15.000000
R20891 n1_m1_424000_321600 n1_m4_424000_321600 15.000000
R20892 n1_m1_424000_326400 n1_m4_424000_326400 15.000000
R20893 n1_m1_424000_331200 n1_m4_424000_331200 15.000000
R20894 n1_m1_424000_336000 n1_m4_424000_336000 15.000000
R20895 n1_m1_424000_340800 n1_m4_424000_340800 15.000000
R20896 n1_m1_424000_345600 n1_m4_424000_345600 15.000000
R20897 n1_m1_424000_350400 n1_m4_424000_350400 15.000000
R20898 n1_m1_424000_355200 n1_m4_424000_355200 15.000000
R20899 n1_m1_424000_360000 n1_m4_424000_360000 15.000000
R20900 n1_m1_424000_364800 n1_m4_424000_364800 15.000000
R20901 n1_m1_424000_369600 n1_m4_424000_369600 15.000000
R20902 n1_m1_424000_374400 n1_m4_424000_374400 15.000000
R20903 n1_m1_424000_379200 n1_m4_424000_379200 15.000000
R20904 n1_m1_424000_384000 n1_m4_424000_384000 15.000000
R20905 n1_m1_424000_388800 n1_m4_424000_388800 15.000000
R20906 n1_m1_424000_393600 n1_m4_424000_393600 15.000000
R20907 n1_m1_424000_398400 n1_m4_424000_398400 15.000000
R20908 n1_m1_424000_403200 n1_m4_424000_403200 15.000000
R20909 n1_m1_424000_408000 n1_m4_424000_408000 15.000000
R20910 n1_m1_424000_412800 n1_m4_424000_412800 15.000000
R20911 n1_m1_424000_417600 n1_m4_424000_417600 15.000000
R20912 n1_m1_424000_422400 n1_m4_424000_422400 15.000000
R20913 n1_m1_424000_427200 n1_m4_424000_427200 15.000000
R20914 n1_m1_424000_432000 n1_m4_424000_432000 15.000000
R20915 n1_m1_424000_436800 n1_m4_424000_436800 15.000000
R20916 n1_m1_424000_441600 n1_m4_424000_441600 15.000000
R20917 n1_m1_424000_446400 n1_m4_424000_446400 15.000000
R20918 n1_m1_424000_451200 n1_m4_424000_451200 15.000000
R20919 n1_m1_424000_456000 n1_m4_424000_456000 15.000000
R20920 n1_m1_424000_460800 n1_m4_424000_460800 15.000000
R20921 n1_m1_424000_465600 n1_m4_424000_465600 15.000000
R20922 n1_m1_424000_470400 n1_m4_424000_470400 15.000000
R20923 n1_m1_424000_475200 n1_m4_424000_475200 15.000000
R20924 n1_m1_424000_480000 n1_m4_424000_480000 15.000000
R20925 n1_m1_424000_484800 n1_m4_424000_484800 15.000000
R20926 n1_m1_424000_489600 n1_m4_424000_489600 15.000000
R20927 n1_m1_424000_494400 n1_m4_424000_494400 15.000000
R20928 n1_m1_424000_499200 n1_m4_424000_499200 15.000000
R20929 n1_m1_424000_504000 n1_m4_424000_504000 15.000000
R20930 n1_m1_424000_508800 n1_m4_424000_508800 15.000000
R20931 n1_m1_424000_513600 n1_m4_424000_513600 15.000000
R20932 n1_m1_424000_518400 n1_m4_424000_518400 15.000000
R20933 n1_m1_424000_523200 n1_m4_424000_523200 15.000000
R20934 n1_m1_424000_528000 n1_m4_424000_528000 15.000000
R20935 n1_m1_424000_532800 n1_m4_424000_532800 15.000000
R20936 n1_m1_424000_537600 n1_m4_424000_537600 15.000000
R20937 n1_m1_424000_542400 n1_m4_424000_542400 15.000000
R20938 n1_m1_424000_547200 n1_m4_424000_547200 15.000000
R20939 n1_m1_424000_552000 n1_m4_424000_552000 15.000000
R20940 n1_m1_424000_556800 n1_m4_424000_556800 15.000000
R20941 n1_m1_424000_561600 n1_m4_424000_561600 15.000000
R20942 n1_m1_424000_566400 n1_m4_424000_566400 15.000000
R20943 n1_m1_424000_571200 n1_m4_424000_571200 15.000000
R20944 n1_m1_424000_576000 n1_m4_424000_576000 15.000000
R20945 n1_m1_424000_580800 n1_m4_424000_580800 15.000000
R20946 n1_m1_424000_585600 n1_m4_424000_585600 15.000000
R20947 n1_m1_424000_590400 n1_m4_424000_590400 15.000000
R20948 n1_m1_424000_595200 n1_m4_424000_595200 15.000000
R20949 n1_m1_452000_0 n1_m4_452000_0 15.000000
R20950 n1_m1_480000_0 n1_m4_480000_0 15.000000
R20951 n1_m1_508000_0 n1_m4_508000_0 15.000000
R20952 n1_m1_536000_0 n1_m4_536000_0 15.000000
R20953 n1_m1_536000_4800 n1_m4_536000_4800 15.000000
R20954 n1_m1_536000_9600 n1_m4_536000_9600 15.000000
R20955 n1_m1_536000_14400 n1_m4_536000_14400 15.000000
R20956 n1_m1_536000_19200 n1_m4_536000_19200 15.000000
R20957 n1_m1_536000_24000 n1_m4_536000_24000 15.000000
R20958 n1_m1_536000_28800 n1_m4_536000_28800 15.000000
R20959 n1_m1_536000_33600 n1_m4_536000_33600 15.000000
R20960 n1_m1_536000_38400 n1_m4_536000_38400 15.000000
R20961 n1_m1_536000_43200 n1_m4_536000_43200 15.000000
R20962 n1_m1_536000_48000 n1_m4_536000_48000 15.000000
R20963 n1_m1_536000_52800 n1_m4_536000_52800 15.000000
R20964 n1_m1_536000_57600 n1_m4_536000_57600 15.000000
R20965 n1_m1_536000_62400 n1_m4_536000_62400 15.000000
R20966 n1_m1_536000_67200 n1_m4_536000_67200 15.000000
R20967 n1_m1_536000_72000 n1_m4_536000_72000 15.000000
R20968 n1_m1_536000_76800 n1_m4_536000_76800 15.000000
R20969 n1_m1_536000_81600 n1_m4_536000_81600 15.000000
R20970 n1_m1_536000_86400 n1_m4_536000_86400 15.000000
R20971 n1_m1_536000_91200 n1_m4_536000_91200 15.000000
R20972 n1_m1_536000_96000 n1_m4_536000_96000 15.000000
R20973 n1_m1_536000_100800 n1_m4_536000_100800 15.000000
R20974 n1_m1_536000_105600 n1_m4_536000_105600 15.000000
R20975 n1_m1_536000_110400 n1_m4_536000_110400 15.000000
R20976 n1_m1_536000_115200 n1_m4_536000_115200 15.000000
R20977 n1_m1_536000_120000 n1_m4_536000_120000 15.000000
R20978 n1_m1_536000_124800 n1_m4_536000_124800 15.000000
R20979 n1_m1_536000_129600 n1_m4_536000_129600 15.000000
R20980 n1_m1_536000_134400 n1_m4_536000_134400 15.000000
R20981 n1_m1_536000_139200 n1_m4_536000_139200 15.000000
R20982 n1_m1_536000_144000 n1_m4_536000_144000 15.000000
R20983 n1_m1_536000_148800 n1_m4_536000_148800 15.000000
R20984 n1_m1_536000_153600 n1_m4_536000_153600 15.000000
R20985 n1_m1_536000_158400 n1_m4_536000_158400 15.000000
R20986 n1_m1_536000_163200 n1_m4_536000_163200 15.000000
R20987 n1_m1_536000_168000 n1_m4_536000_168000 15.000000
R20988 n1_m1_536000_172800 n1_m4_536000_172800 15.000000
R20989 n1_m1_536000_177600 n1_m4_536000_177600 15.000000
R20990 n1_m1_536000_182400 n1_m4_536000_182400 15.000000
R20991 n1_m1_536000_187200 n1_m4_536000_187200 15.000000
R20992 n1_m1_536000_192000 n1_m4_536000_192000 15.000000
R20993 n1_m1_536000_196800 n1_m4_536000_196800 15.000000
R20994 n1_m1_536000_201600 n1_m4_536000_201600 15.000000
R20995 n1_m1_536000_206400 n1_m4_536000_206400 15.000000
R20996 n1_m1_536000_211200 n1_m4_536000_211200 15.000000
R20997 n1_m1_536000_216000 n1_m4_536000_216000 15.000000
R20998 n1_m1_536000_220800 n1_m4_536000_220800 15.000000
R20999 n1_m1_536000_225600 n1_m4_536000_225600 15.000000
R21000 n1_m1_536000_230400 n1_m4_536000_230400 15.000000
R21001 n1_m1_536000_235200 n1_m4_536000_235200 15.000000
R21002 n1_m1_536000_240000 n1_m4_536000_240000 15.000000
R21003 n1_m1_536000_244800 n1_m4_536000_244800 15.000000
R21004 n1_m1_536000_249600 n1_m4_536000_249600 15.000000
R21005 n1_m1_536000_254400 n1_m4_536000_254400 15.000000
R21006 n1_m1_536000_259200 n1_m4_536000_259200 15.000000
R21007 n1_m1_536000_264000 n1_m4_536000_264000 15.000000
R21008 n1_m1_536000_268800 n1_m4_536000_268800 15.000000
R21009 n1_m1_536000_273600 n1_m4_536000_273600 15.000000
R21010 n1_m1_536000_278400 n1_m4_536000_278400 15.000000
R21011 n1_m1_536000_283200 n1_m4_536000_283200 15.000000
R21012 n1_m1_536000_288000 n1_m4_536000_288000 15.000000
R21013 n1_m1_536000_292800 n1_m4_536000_292800 15.000000
R21014 n1_m1_536000_297600 n1_m4_536000_297600 15.000000
R21015 n1_m1_536000_302400 n1_m4_536000_302400 15.000000
R21016 n1_m1_536000_307200 n1_m4_536000_307200 15.000000
R21017 n1_m1_536000_312000 n1_m4_536000_312000 15.000000
R21018 n1_m1_536000_316800 n1_m4_536000_316800 15.000000
R21019 n1_m1_536000_321600 n1_m4_536000_321600 15.000000
R21020 n1_m1_536000_326400 n1_m4_536000_326400 15.000000
R21021 n1_m1_536000_331200 n1_m4_536000_331200 15.000000
R21022 n1_m1_536000_336000 n1_m4_536000_336000 15.000000
R21023 n1_m1_536000_340800 n1_m4_536000_340800 15.000000
R21024 n1_m1_536000_345600 n1_m4_536000_345600 15.000000
R21025 n1_m1_536000_350400 n1_m4_536000_350400 15.000000
R21026 n1_m1_536000_355200 n1_m4_536000_355200 15.000000
R21027 n1_m1_536000_360000 n1_m4_536000_360000 15.000000
R21028 n1_m1_536000_364800 n1_m4_536000_364800 15.000000
R21029 n1_m1_536000_369600 n1_m4_536000_369600 15.000000
R21030 n1_m1_536000_374400 n1_m4_536000_374400 15.000000
R21031 n1_m1_536000_379200 n1_m4_536000_379200 15.000000
R21032 n1_m1_536000_384000 n1_m4_536000_384000 15.000000
R21033 n1_m1_536000_388800 n1_m4_536000_388800 15.000000
R21034 n1_m1_536000_393600 n1_m4_536000_393600 15.000000
R21035 n1_m1_536000_398400 n1_m4_536000_398400 15.000000
R21036 n1_m1_536000_403200 n1_m4_536000_403200 15.000000
R21037 n1_m1_536000_408000 n1_m4_536000_408000 15.000000
R21038 n1_m1_536000_412800 n1_m4_536000_412800 15.000000
R21039 n1_m1_536000_417600 n1_m4_536000_417600 15.000000
R21040 n1_m1_536000_422400 n1_m4_536000_422400 15.000000
R21041 n1_m1_536000_427200 n1_m4_536000_427200 15.000000
R21042 n1_m1_536000_432000 n1_m4_536000_432000 15.000000
R21043 n1_m1_536000_436800 n1_m4_536000_436800 15.000000
R21044 n1_m1_536000_441600 n1_m4_536000_441600 15.000000
R21045 n1_m1_536000_446400 n1_m4_536000_446400 15.000000
R21046 n1_m1_536000_451200 n1_m4_536000_451200 15.000000
R21047 n1_m1_536000_456000 n1_m4_536000_456000 15.000000
R21048 n1_m1_536000_460800 n1_m4_536000_460800 15.000000
R21049 n1_m1_536000_465600 n1_m4_536000_465600 15.000000
R21050 n1_m1_536000_470400 n1_m4_536000_470400 15.000000
R21051 n1_m1_536000_475200 n1_m4_536000_475200 15.000000
R21052 n1_m1_536000_480000 n1_m4_536000_480000 15.000000
R21053 n1_m1_536000_484800 n1_m4_536000_484800 15.000000
R21054 n1_m1_536000_489600 n1_m4_536000_489600 15.000000
R21055 n1_m1_536000_494400 n1_m4_536000_494400 15.000000
R21056 n1_m1_536000_499200 n1_m4_536000_499200 15.000000
R21057 n1_m1_536000_504000 n1_m4_536000_504000 15.000000
R21058 n1_m1_536000_508800 n1_m4_536000_508800 15.000000
R21059 n1_m1_536000_513600 n1_m4_536000_513600 15.000000
R21060 n1_m1_536000_518400 n1_m4_536000_518400 15.000000
R21061 n1_m1_536000_523200 n1_m4_536000_523200 15.000000
R21062 n1_m1_536000_528000 n1_m4_536000_528000 15.000000
R21063 n1_m1_536000_532800 n1_m4_536000_532800 15.000000
R21064 n1_m1_536000_537600 n1_m4_536000_537600 15.000000
R21065 n1_m1_536000_542400 n1_m4_536000_542400 15.000000
R21066 n1_m1_536000_547200 n1_m4_536000_547200 15.000000
R21067 n1_m1_536000_552000 n1_m4_536000_552000 15.000000
R21068 n1_m1_536000_556800 n1_m4_536000_556800 15.000000
R21069 n1_m1_536000_561600 n1_m4_536000_561600 15.000000
R21070 n1_m1_536000_566400 n1_m4_536000_566400 15.000000
R21071 n1_m1_536000_571200 n1_m4_536000_571200 15.000000
R21072 n1_m1_536000_576000 n1_m4_536000_576000 15.000000
R21073 n1_m1_536000_580800 n1_m4_536000_580800 15.000000
R21074 n1_m1_536000_585600 n1_m4_536000_585600 15.000000
R21075 n1_m1_536000_590400 n1_m4_536000_590400 15.000000
R21076 n1_m1_536000_595200 n1_m4_536000_595200 15.000000
R21077 n1_m1_564000_0 n1_m4_564000_0 15.000000
R21078 n1_m1_592000_0 n1_m4_592000_0 15.000000
R21079 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R21080 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R21081 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R21082 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R21083 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R21084 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R21085 n1_m4_4000_484000 n1_m7_4000_484000 9.000000
R21086 n1_m4_4000_564000 n1_m7_4000_564000 9.000000
R21087 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R21088 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R21089 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R21090 n1_m4_116000_244000 n1_m7_116000_244000 9.000000
R21091 n1_m4_116000_324000 n1_m7_116000_324000 9.000000
R21092 n1_m4_116000_404000 n1_m7_116000_404000 9.000000
R21093 n1_m4_116000_484000 n1_m7_116000_484000 9.000000
R21094 n1_m4_116000_564000 n1_m7_116000_564000 9.000000
R21095 n1_m4_312000_4000 n1_m7_312000_4000 9.000000
R21096 n1_m4_312000_84000 n1_m7_312000_84000 9.000000
R21097 n1_m4_312000_164000 n1_m7_312000_164000 9.000000
R21098 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R21099 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R21100 n1_m4_312000_404000 n1_m7_312000_404000 9.000000
R21101 n1_m4_312000_484000 n1_m7_312000_484000 9.000000
R21102 n1_m4_312000_564000 n1_m7_312000_564000 9.000000
R21103 n1_m4_424000_4000 n1_m7_424000_4000 9.000000
R21104 n1_m4_424000_84000 n1_m7_424000_84000 9.000000
R21105 n1_m4_424000_164000 n1_m7_424000_164000 9.000000
R21106 n1_m4_424000_244000 n1_m7_424000_244000 9.000000
R21107 n1_m4_424000_324000 n1_m7_424000_324000 9.000000
R21108 n1_m4_424000_404000 n1_m7_424000_404000 9.000000
R21109 n1_m4_424000_484000 n1_m7_424000_484000 9.000000
R21110 n1_m4_424000_564000 n1_m7_424000_564000 9.000000
R21111 n1_m4_536000_4000 n1_m7_536000_4000 9.000000
R21112 n1_m4_536000_84000 n1_m7_536000_84000 9.000000
R21113 n1_m4_536000_164000 n1_m7_536000_164000 9.000000
R21114 n1_m4_536000_244000 n1_m7_536000_244000 9.000000
R21115 n1_m4_536000_324000 n1_m7_536000_324000 9.000000
R21116 n1_m4_536000_404000 n1_m7_536000_404000 9.000000
R21117 n1_m4_536000_484000 n1_m7_536000_484000 9.000000
R21118 n1_m4_536000_564000 n1_m7_536000_564000 9.000000
R21119 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R21120 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R21121 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R21122 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R21123 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R21124 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R21125 n1_m7_4000_484000 n1_m8_4000_484000 1.000000
R21126 n1_m7_4000_564000 n1_m8_4000_564000 1.000000
R21127 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R21128 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R21129 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R21130 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R21131 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R21132 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R21133 n1_m7_26400_484000 n1_m8_26400_484000 1.000000
R21134 n1_m7_26400_564000 n1_m8_26400_564000 1.000000
R21135 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R21136 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R21137 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R21138 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R21139 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R21140 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R21141 n1_m7_48800_484000 n1_m8_48800_484000 1.000000
R21142 n1_m7_48800_564000 n1_m8_48800_564000 1.000000
R21143 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R21144 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R21145 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R21146 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R21147 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R21148 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R21149 n1_m7_71200_484000 n1_m8_71200_484000 1.000000
R21150 n1_m7_71200_564000 n1_m8_71200_564000 1.000000
R21151 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R21152 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R21153 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R21154 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R21155 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R21156 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R21157 n1_m7_93600_484000 n1_m8_93600_484000 1.000000
R21158 n1_m7_93600_564000 n1_m8_93600_564000 1.000000
R21159 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R21160 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R21161 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R21162 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R21163 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R21164 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R21165 n1_m7_116000_484000 n1_m8_116000_484000 1.000000
R21166 n1_m7_116000_564000 n1_m8_116000_564000 1.000000
R21167 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R21168 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R21169 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R21170 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R21171 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R21172 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R21173 n1_m7_138400_484000 n1_m8_138400_484000 1.000000
R21174 n1_m7_138400_564000 n1_m8_138400_564000 1.000000
R21175 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R21176 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R21177 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R21178 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R21179 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R21180 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R21181 n1_m7_160800_484000 n1_m8_160800_484000 1.000000
R21182 n1_m7_160800_564000 n1_m8_160800_564000 1.000000
R21183 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R21184 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R21185 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R21186 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R21187 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R21188 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R21189 n1_m7_183200_484000 n1_m8_183200_484000 1.000000
R21190 n1_m7_183200_564000 n1_m8_183200_564000 1.000000
R21191 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R21192 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R21193 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R21194 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R21195 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R21196 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R21197 n1_m7_205600_484000 n1_m8_205600_484000 1.000000
R21198 n1_m7_205600_564000 n1_m8_205600_564000 1.000000
R21199 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R21200 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R21201 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R21202 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R21203 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R21204 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R21205 n1_m7_228000_484000 n1_m8_228000_484000 1.000000
R21206 n1_m7_228000_564000 n1_m8_228000_564000 1.000000
R21207 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R21208 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R21209 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R21210 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R21211 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R21212 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R21213 n1_m7_250400_484000 n1_m8_250400_484000 1.000000
R21214 n1_m7_250400_564000 n1_m8_250400_564000 1.000000
R21215 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R21216 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R21217 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R21218 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R21219 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R21220 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R21221 n1_m7_272800_484000 n1_m8_272800_484000 1.000000
R21222 n1_m7_272800_564000 n1_m8_272800_564000 1.000000
R21223 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R21224 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R21225 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R21226 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R21227 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R21228 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R21229 n1_m7_295200_484000 n1_m8_295200_484000 1.000000
R21230 n1_m7_295200_564000 n1_m8_295200_564000 1.000000
R21231 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R21232 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R21233 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R21234 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R21235 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R21236 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R21237 n1_m7_317600_484000 n1_m8_317600_484000 1.000000
R21238 n1_m7_317600_564000 n1_m8_317600_564000 1.000000
R21239 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R21240 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R21241 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R21242 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R21243 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R21244 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R21245 n1_m7_340000_484000 n1_m8_340000_484000 1.000000
R21246 n1_m7_340000_564000 n1_m8_340000_564000 1.000000
R21247 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R21248 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R21249 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R21250 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R21251 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R21252 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R21253 n1_m7_362400_484000 n1_m8_362400_484000 1.000000
R21254 n1_m7_362400_564000 n1_m8_362400_564000 1.000000
R21255 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R21256 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R21257 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R21258 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R21259 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R21260 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R21261 n1_m7_384800_484000 n1_m8_384800_484000 1.000000
R21262 n1_m7_384800_564000 n1_m8_384800_564000 1.000000
R21263 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R21264 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R21265 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R21266 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R21267 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R21268 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R21269 n1_m7_407200_484000 n1_m8_407200_484000 1.000000
R21270 n1_m7_407200_564000 n1_m8_407200_564000 1.000000
R21271 n1_m7_429600_4000 n1_m8_429600_4000 1.000000
R21272 n1_m7_429600_84000 n1_m8_429600_84000 1.000000
R21273 n1_m7_429600_164000 n1_m8_429600_164000 1.000000
R21274 n1_m7_429600_244000 n1_m8_429600_244000 1.000000
R21275 n1_m7_429600_324000 n1_m8_429600_324000 1.000000
R21276 n1_m7_429600_404000 n1_m8_429600_404000 1.000000
R21277 n1_m7_429600_484000 n1_m8_429600_484000 1.000000
R21278 n1_m7_429600_564000 n1_m8_429600_564000 1.000000
R21279 n1_m7_452000_4000 n1_m8_452000_4000 1.000000
R21280 n1_m7_452000_84000 n1_m8_452000_84000 1.000000
R21281 n1_m7_452000_164000 n1_m8_452000_164000 1.000000
R21282 n1_m7_452000_244000 n1_m8_452000_244000 1.000000
R21283 n1_m7_452000_324000 n1_m8_452000_324000 1.000000
R21284 n1_m7_452000_404000 n1_m8_452000_404000 1.000000
R21285 n1_m7_452000_484000 n1_m8_452000_484000 1.000000
R21286 n1_m7_452000_564000 n1_m8_452000_564000 1.000000
R21287 n1_m7_474400_4000 n1_m8_474400_4000 1.000000
R21288 n1_m7_474400_84000 n1_m8_474400_84000 1.000000
R21289 n1_m7_474400_164000 n1_m8_474400_164000 1.000000
R21290 n1_m7_474400_244000 n1_m8_474400_244000 1.000000
R21291 n1_m7_474400_324000 n1_m8_474400_324000 1.000000
R21292 n1_m7_474400_404000 n1_m8_474400_404000 1.000000
R21293 n1_m7_474400_484000 n1_m8_474400_484000 1.000000
R21294 n1_m7_474400_564000 n1_m8_474400_564000 1.000000
R21295 n1_m7_496800_4000 n1_m8_496800_4000 1.000000
R21296 n1_m7_496800_84000 n1_m8_496800_84000 1.000000
R21297 n1_m7_496800_164000 n1_m8_496800_164000 1.000000
R21298 n1_m7_496800_244000 n1_m8_496800_244000 1.000000
R21299 n1_m7_496800_324000 n1_m8_496800_324000 1.000000
R21300 n1_m7_496800_404000 n1_m8_496800_404000 1.000000
R21301 n1_m7_496800_484000 n1_m8_496800_484000 1.000000
R21302 n1_m7_496800_564000 n1_m8_496800_564000 1.000000
R21303 n1_m7_519200_4000 n1_m8_519200_4000 1.000000
R21304 n1_m7_519200_84000 n1_m8_519200_84000 1.000000
R21305 n1_m7_519200_164000 n1_m8_519200_164000 1.000000
R21306 n1_m7_519200_244000 n1_m8_519200_244000 1.000000
R21307 n1_m7_519200_324000 n1_m8_519200_324000 1.000000
R21308 n1_m7_519200_404000 n1_m8_519200_404000 1.000000
R21309 n1_m7_519200_484000 n1_m8_519200_484000 1.000000
R21310 n1_m7_519200_564000 n1_m8_519200_564000 1.000000
R21311 n1_m7_541600_4000 n1_m8_541600_4000 1.000000
R21312 n1_m7_541600_84000 n1_m8_541600_84000 1.000000
R21313 n1_m7_541600_164000 n1_m8_541600_164000 1.000000
R21314 n1_m7_541600_244000 n1_m8_541600_244000 1.000000
R21315 n1_m7_541600_324000 n1_m8_541600_324000 1.000000
R21316 n1_m7_541600_404000 n1_m8_541600_404000 1.000000
R21317 n1_m7_541600_484000 n1_m8_541600_484000 1.000000
R21318 n1_m7_541600_564000 n1_m8_541600_564000 1.000000
R21319 n1_m7_564000_4000 n1_m8_564000_4000 1.000000
R21320 n1_m7_564000_84000 n1_m8_564000_84000 1.000000
R21321 n1_m7_564000_164000 n1_m8_564000_164000 1.000000
R21322 n1_m7_564000_244000 n1_m8_564000_244000 1.000000
R21323 n1_m7_564000_324000 n1_m8_564000_324000 1.000000
R21324 n1_m7_564000_404000 n1_m8_564000_404000 1.000000
R21325 n1_m7_564000_484000 n1_m8_564000_484000 1.000000
R21326 n1_m7_564000_564000 n1_m8_564000_564000 1.000000
R21327 n1_m7_586400_4000 n1_m8_586400_4000 1.000000
R21328 n1_m7_586400_84000 n1_m8_586400_84000 1.000000
R21329 n1_m7_586400_164000 n1_m8_586400_164000 1.000000
R21330 n1_m7_586400_244000 n1_m8_586400_244000 1.000000
R21331 n1_m7_586400_324000 n1_m8_586400_324000 1.000000
R21332 n1_m7_586400_404000 n1_m8_586400_404000 1.000000
R21333 n1_m7_586400_484000 n1_m8_586400_484000 1.000000
R21334 n1_m7_586400_564000 n1_m8_586400_564000 1.000000
R21335 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R21336 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R21337 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R21338 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R21339 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R21340 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R21341 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R21342 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R21343 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R21344 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R21345 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R21346 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R21347 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R21348 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R21349 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R21350 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R21351 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R21352 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R21353 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R21354 n1_m8_4000_429600 n1_m9_4000_429600 1.000000
R21355 n1_m8_4000_452000 n1_m9_4000_452000 1.000000
R21356 n1_m8_4000_474400 n1_m9_4000_474400 1.000000
R21357 n1_m8_4000_496800 n1_m9_4000_496800 1.000000
R21358 n1_m8_4000_519200 n1_m9_4000_519200 1.000000
R21359 n1_m8_4000_541600 n1_m9_4000_541600 1.000000
R21360 n1_m8_4000_564000 n1_m9_4000_564000 1.000000
R21361 n1_m8_4000_586400 n1_m9_4000_586400 1.000000
R21362 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R21363 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R21364 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R21365 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R21366 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R21367 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R21368 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R21369 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R21370 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R21371 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R21372 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R21373 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R21374 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R21375 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R21376 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R21377 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R21378 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R21379 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R21380 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R21381 n1_m8_26400_429600 n1_m9_26400_429600 1.000000
R21382 n1_m8_26400_452000 n1_m9_26400_452000 1.000000
R21383 n1_m8_26400_474400 n1_m9_26400_474400 1.000000
R21384 n1_m8_26400_496800 n1_m9_26400_496800 1.000000
R21385 n1_m8_26400_519200 n1_m9_26400_519200 1.000000
R21386 n1_m8_26400_541600 n1_m9_26400_541600 1.000000
R21387 n1_m8_26400_564000 n1_m9_26400_564000 1.000000
R21388 n1_m8_26400_586400 n1_m9_26400_586400 1.000000
R21389 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R21390 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R21391 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R21392 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R21393 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R21394 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R21395 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R21396 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R21397 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R21398 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R21399 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R21400 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R21401 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R21402 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R21403 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R21404 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R21405 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R21406 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R21407 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R21408 n1_m8_48800_429600 n1_m9_48800_429600 1.000000
R21409 n1_m8_48800_452000 n1_m9_48800_452000 1.000000
R21410 n1_m8_48800_474400 n1_m9_48800_474400 1.000000
R21411 n1_m8_48800_496800 n1_m9_48800_496800 1.000000
R21412 n1_m8_48800_519200 n1_m9_48800_519200 1.000000
R21413 n1_m8_48800_541600 n1_m9_48800_541600 1.000000
R21414 n1_m8_48800_564000 n1_m9_48800_564000 1.000000
R21415 n1_m8_48800_586400 n1_m9_48800_586400 1.000000
R21416 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R21417 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R21418 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R21419 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R21420 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R21421 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R21422 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R21423 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R21424 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R21425 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R21426 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R21427 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R21428 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R21429 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R21430 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R21431 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R21432 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R21433 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R21434 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R21435 n1_m8_71200_429600 n1_m9_71200_429600 1.000000
R21436 n1_m8_71200_452000 n1_m9_71200_452000 1.000000
R21437 n1_m8_71200_474400 n1_m9_71200_474400 1.000000
R21438 n1_m8_71200_496800 n1_m9_71200_496800 1.000000
R21439 n1_m8_71200_519200 n1_m9_71200_519200 1.000000
R21440 n1_m8_71200_541600 n1_m9_71200_541600 1.000000
R21441 n1_m8_71200_564000 n1_m9_71200_564000 1.000000
R21442 n1_m8_71200_586400 n1_m9_71200_586400 1.000000
R21443 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R21444 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R21445 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R21446 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R21447 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R21448 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R21449 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R21450 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R21451 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R21452 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R21453 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R21454 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R21455 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R21456 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R21457 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R21458 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R21459 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R21460 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R21461 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R21462 n1_m8_93600_429600 n1_m9_93600_429600 1.000000
R21463 n1_m8_93600_452000 n1_m9_93600_452000 1.000000
R21464 n1_m8_93600_474400 n1_m9_93600_474400 1.000000
R21465 n1_m8_93600_496800 n1_m9_93600_496800 1.000000
R21466 n1_m8_93600_519200 n1_m9_93600_519200 1.000000
R21467 n1_m8_93600_541600 n1_m9_93600_541600 1.000000
R21468 n1_m8_93600_564000 n1_m9_93600_564000 1.000000
R21469 n1_m8_93600_586400 n1_m9_93600_586400 1.000000
R21470 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R21471 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R21472 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R21473 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R21474 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R21475 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R21476 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R21477 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R21478 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R21479 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R21480 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R21481 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R21482 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R21483 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R21484 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R21485 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R21486 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R21487 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R21488 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R21489 n1_m8_116000_429600 n1_m9_116000_429600 1.000000
R21490 n1_m8_116000_452000 n1_m9_116000_452000 1.000000
R21491 n1_m8_116000_474400 n1_m9_116000_474400 1.000000
R21492 n1_m8_116000_496800 n1_m9_116000_496800 1.000000
R21493 n1_m8_116000_519200 n1_m9_116000_519200 1.000000
R21494 n1_m8_116000_541600 n1_m9_116000_541600 1.000000
R21495 n1_m8_116000_564000 n1_m9_116000_564000 1.000000
R21496 n1_m8_116000_586400 n1_m9_116000_586400 1.000000
R21497 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R21498 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R21499 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R21500 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R21501 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R21502 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R21503 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R21504 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R21505 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R21506 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R21507 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R21508 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R21509 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R21510 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R21511 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R21512 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R21513 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R21514 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R21515 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R21516 n1_m8_138400_429600 n1_m9_138400_429600 1.000000
R21517 n1_m8_138400_452000 n1_m9_138400_452000 1.000000
R21518 n1_m8_138400_474400 n1_m9_138400_474400 1.000000
R21519 n1_m8_138400_496800 n1_m9_138400_496800 1.000000
R21520 n1_m8_138400_519200 n1_m9_138400_519200 1.000000
R21521 n1_m8_138400_541600 n1_m9_138400_541600 1.000000
R21522 n1_m8_138400_564000 n1_m9_138400_564000 1.000000
R21523 n1_m8_138400_586400 n1_m9_138400_586400 1.000000
R21524 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R21525 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R21526 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R21527 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R21528 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R21529 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R21530 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R21531 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R21532 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R21533 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R21534 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R21535 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R21536 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R21537 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R21538 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R21539 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R21540 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R21541 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R21542 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R21543 n1_m8_160800_429600 n1_m9_160800_429600 1.000000
R21544 n1_m8_160800_452000 n1_m9_160800_452000 1.000000
R21545 n1_m8_160800_474400 n1_m9_160800_474400 1.000000
R21546 n1_m8_160800_496800 n1_m9_160800_496800 1.000000
R21547 n1_m8_160800_519200 n1_m9_160800_519200 1.000000
R21548 n1_m8_160800_541600 n1_m9_160800_541600 1.000000
R21549 n1_m8_160800_564000 n1_m9_160800_564000 1.000000
R21550 n1_m8_160800_586400 n1_m9_160800_586400 1.000000
R21551 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R21552 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R21553 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R21554 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R21555 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R21556 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R21557 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R21558 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R21559 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R21560 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R21561 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R21562 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R21563 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R21564 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R21565 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R21566 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R21567 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R21568 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R21569 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R21570 n1_m8_183200_429600 n1_m9_183200_429600 1.000000
R21571 n1_m8_183200_452000 n1_m9_183200_452000 1.000000
R21572 n1_m8_183200_474400 n1_m9_183200_474400 1.000000
R21573 n1_m8_183200_496800 n1_m9_183200_496800 1.000000
R21574 n1_m8_183200_519200 n1_m9_183200_519200 1.000000
R21575 n1_m8_183200_541600 n1_m9_183200_541600 1.000000
R21576 n1_m8_183200_564000 n1_m9_183200_564000 1.000000
R21577 n1_m8_183200_586400 n1_m9_183200_586400 1.000000
R21578 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R21579 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R21580 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R21581 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R21582 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R21583 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R21584 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R21585 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R21586 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R21587 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R21588 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R21589 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R21590 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R21591 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R21592 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R21593 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R21594 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R21595 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R21596 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R21597 n1_m8_205600_429600 n1_m9_205600_429600 1.000000
R21598 n1_m8_205600_452000 n1_m9_205600_452000 1.000000
R21599 n1_m8_205600_474400 n1_m9_205600_474400 1.000000
R21600 n1_m8_205600_496800 n1_m9_205600_496800 1.000000
R21601 n1_m8_205600_519200 n1_m9_205600_519200 1.000000
R21602 n1_m8_205600_541600 n1_m9_205600_541600 1.000000
R21603 n1_m8_205600_564000 n1_m9_205600_564000 1.000000
R21604 n1_m8_205600_586400 n1_m9_205600_586400 1.000000
R21605 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R21606 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R21607 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R21608 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R21609 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R21610 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R21611 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R21612 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R21613 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R21614 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R21615 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R21616 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R21617 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R21618 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R21619 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R21620 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R21621 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R21622 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R21623 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R21624 n1_m8_228000_429600 n1_m9_228000_429600 1.000000
R21625 n1_m8_228000_452000 n1_m9_228000_452000 1.000000
R21626 n1_m8_228000_474400 n1_m9_228000_474400 1.000000
R21627 n1_m8_228000_496800 n1_m9_228000_496800 1.000000
R21628 n1_m8_228000_519200 n1_m9_228000_519200 1.000000
R21629 n1_m8_228000_541600 n1_m9_228000_541600 1.000000
R21630 n1_m8_228000_564000 n1_m9_228000_564000 1.000000
R21631 n1_m8_228000_586400 n1_m9_228000_586400 1.000000
R21632 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R21633 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R21634 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R21635 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R21636 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R21637 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R21638 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R21639 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R21640 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R21641 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R21642 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R21643 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R21644 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R21645 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R21646 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R21647 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R21648 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R21649 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R21650 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R21651 n1_m8_250400_429600 n1_m9_250400_429600 1.000000
R21652 n1_m8_250400_452000 n1_m9_250400_452000 1.000000
R21653 n1_m8_250400_474400 n1_m9_250400_474400 1.000000
R21654 n1_m8_250400_496800 n1_m9_250400_496800 1.000000
R21655 n1_m8_250400_519200 n1_m9_250400_519200 1.000000
R21656 n1_m8_250400_541600 n1_m9_250400_541600 1.000000
R21657 n1_m8_250400_564000 n1_m9_250400_564000 1.000000
R21658 n1_m8_250400_586400 n1_m9_250400_586400 1.000000
R21659 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R21660 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R21661 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R21662 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R21663 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R21664 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R21665 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R21666 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R21667 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R21668 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R21669 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R21670 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R21671 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R21672 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R21673 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R21674 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R21675 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R21676 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R21677 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R21678 n1_m8_272800_429600 n1_m9_272800_429600 1.000000
R21679 n1_m8_272800_452000 n1_m9_272800_452000 1.000000
R21680 n1_m8_272800_474400 n1_m9_272800_474400 1.000000
R21681 n1_m8_272800_496800 n1_m9_272800_496800 1.000000
R21682 n1_m8_272800_519200 n1_m9_272800_519200 1.000000
R21683 n1_m8_272800_541600 n1_m9_272800_541600 1.000000
R21684 n1_m8_272800_564000 n1_m9_272800_564000 1.000000
R21685 n1_m8_272800_586400 n1_m9_272800_586400 1.000000
R21686 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R21687 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R21688 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R21689 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R21690 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R21691 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R21692 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R21693 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R21694 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R21695 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R21696 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R21697 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R21698 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R21699 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R21700 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R21701 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R21702 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R21703 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R21704 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R21705 n1_m8_295200_429600 n1_m9_295200_429600 1.000000
R21706 n1_m8_295200_452000 n1_m9_295200_452000 1.000000
R21707 n1_m8_295200_474400 n1_m9_295200_474400 1.000000
R21708 n1_m8_295200_496800 n1_m9_295200_496800 1.000000
R21709 n1_m8_295200_519200 n1_m9_295200_519200 1.000000
R21710 n1_m8_295200_541600 n1_m9_295200_541600 1.000000
R21711 n1_m8_295200_564000 n1_m9_295200_564000 1.000000
R21712 n1_m8_295200_586400 n1_m9_295200_586400 1.000000
R21713 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R21714 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R21715 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R21716 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R21717 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R21718 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R21719 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R21720 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R21721 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R21722 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R21723 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R21724 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R21725 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R21726 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R21727 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R21728 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R21729 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R21730 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R21731 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R21732 n1_m8_317600_429600 n1_m9_317600_429600 1.000000
R21733 n1_m8_317600_452000 n1_m9_317600_452000 1.000000
R21734 n1_m8_317600_474400 n1_m9_317600_474400 1.000000
R21735 n1_m8_317600_496800 n1_m9_317600_496800 1.000000
R21736 n1_m8_317600_519200 n1_m9_317600_519200 1.000000
R21737 n1_m8_317600_541600 n1_m9_317600_541600 1.000000
R21738 n1_m8_317600_564000 n1_m9_317600_564000 1.000000
R21739 n1_m8_317600_586400 n1_m9_317600_586400 1.000000
R21740 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R21741 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R21742 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R21743 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R21744 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R21745 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R21746 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R21747 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R21748 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R21749 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R21750 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R21751 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R21752 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R21753 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R21754 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R21755 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R21756 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R21757 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R21758 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R21759 n1_m8_340000_429600 n1_m9_340000_429600 1.000000
R21760 n1_m8_340000_452000 n1_m9_340000_452000 1.000000
R21761 n1_m8_340000_474400 n1_m9_340000_474400 1.000000
R21762 n1_m8_340000_496800 n1_m9_340000_496800 1.000000
R21763 n1_m8_340000_519200 n1_m9_340000_519200 1.000000
R21764 n1_m8_340000_541600 n1_m9_340000_541600 1.000000
R21765 n1_m8_340000_564000 n1_m9_340000_564000 1.000000
R21766 n1_m8_340000_586400 n1_m9_340000_586400 1.000000
R21767 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R21768 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R21769 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R21770 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R21771 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R21772 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R21773 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R21774 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R21775 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R21776 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R21777 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R21778 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R21779 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R21780 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R21781 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R21782 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R21783 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R21784 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R21785 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R21786 n1_m8_362400_429600 n1_m9_362400_429600 1.000000
R21787 n1_m8_362400_452000 n1_m9_362400_452000 1.000000
R21788 n1_m8_362400_474400 n1_m9_362400_474400 1.000000
R21789 n1_m8_362400_496800 n1_m9_362400_496800 1.000000
R21790 n1_m8_362400_519200 n1_m9_362400_519200 1.000000
R21791 n1_m8_362400_541600 n1_m9_362400_541600 1.000000
R21792 n1_m8_362400_564000 n1_m9_362400_564000 1.000000
R21793 n1_m8_362400_586400 n1_m9_362400_586400 1.000000
R21794 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R21795 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R21796 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R21797 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R21798 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R21799 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R21800 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R21801 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R21802 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R21803 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R21804 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R21805 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R21806 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R21807 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R21808 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R21809 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R21810 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R21811 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R21812 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R21813 n1_m8_384800_429600 n1_m9_384800_429600 1.000000
R21814 n1_m8_384800_452000 n1_m9_384800_452000 1.000000
R21815 n1_m8_384800_474400 n1_m9_384800_474400 1.000000
R21816 n1_m8_384800_496800 n1_m9_384800_496800 1.000000
R21817 n1_m8_384800_519200 n1_m9_384800_519200 1.000000
R21818 n1_m8_384800_541600 n1_m9_384800_541600 1.000000
R21819 n1_m8_384800_564000 n1_m9_384800_564000 1.000000
R21820 n1_m8_384800_586400 n1_m9_384800_586400 1.000000
R21821 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R21822 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R21823 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R21824 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R21825 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R21826 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R21827 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R21828 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R21829 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R21830 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R21831 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R21832 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R21833 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R21834 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R21835 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R21836 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R21837 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R21838 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R21839 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
R21840 n1_m8_407200_429600 n1_m9_407200_429600 1.000000
R21841 n1_m8_407200_452000 n1_m9_407200_452000 1.000000
R21842 n1_m8_407200_474400 n1_m9_407200_474400 1.000000
R21843 n1_m8_407200_496800 n1_m9_407200_496800 1.000000
R21844 n1_m8_407200_519200 n1_m9_407200_519200 1.000000
R21845 n1_m8_407200_541600 n1_m9_407200_541600 1.000000
R21846 n1_m8_407200_564000 n1_m9_407200_564000 1.000000
R21847 n1_m8_407200_586400 n1_m9_407200_586400 1.000000
R21848 n1_m8_429600_4000 n1_m9_429600_4000 1.000000
R21849 n1_m8_429600_26400 n1_m9_429600_26400 1.000000
R21850 n1_m8_429600_48800 n1_m9_429600_48800 1.000000
R21851 n1_m8_429600_71200 n1_m9_429600_71200 1.000000
R21852 n1_m8_429600_93600 n1_m9_429600_93600 1.000000
R21853 n1_m8_429600_116000 n1_m9_429600_116000 1.000000
R21854 n1_m8_429600_138400 n1_m9_429600_138400 1.000000
R21855 n1_m8_429600_160800 n1_m9_429600_160800 1.000000
R21856 n1_m8_429600_183200 n1_m9_429600_183200 1.000000
R21857 n1_m8_429600_205600 n1_m9_429600_205600 1.000000
R21858 n1_m8_429600_228000 n1_m9_429600_228000 1.000000
R21859 n1_m8_429600_250400 n1_m9_429600_250400 1.000000
R21860 n1_m8_429600_272800 n1_m9_429600_272800 1.000000
R21861 n1_m8_429600_295200 n1_m9_429600_295200 1.000000
R21862 n1_m8_429600_317600 n1_m9_429600_317600 1.000000
R21863 n1_m8_429600_340000 n1_m9_429600_340000 1.000000
R21864 n1_m8_429600_362400 n1_m9_429600_362400 1.000000
R21865 n1_m8_429600_384800 n1_m9_429600_384800 1.000000
R21866 n1_m8_429600_407200 n1_m9_429600_407200 1.000000
R21867 n1_m8_429600_429600 n1_m9_429600_429600 1.000000
R21868 n1_m8_429600_452000 n1_m9_429600_452000 1.000000
R21869 n1_m8_429600_474400 n1_m9_429600_474400 1.000000
R21870 n1_m8_429600_496800 n1_m9_429600_496800 1.000000
R21871 n1_m8_429600_519200 n1_m9_429600_519200 1.000000
R21872 n1_m8_429600_541600 n1_m9_429600_541600 1.000000
R21873 n1_m8_429600_564000 n1_m9_429600_564000 1.000000
R21874 n1_m8_429600_586400 n1_m9_429600_586400 1.000000
R21875 n1_m8_452000_4000 n1_m9_452000_4000 1.000000
R21876 n1_m8_452000_26400 n1_m9_452000_26400 1.000000
R21877 n1_m8_452000_48800 n1_m9_452000_48800 1.000000
R21878 n1_m8_452000_71200 n1_m9_452000_71200 1.000000
R21879 n1_m8_452000_93600 n1_m9_452000_93600 1.000000
R21880 n1_m8_452000_116000 n1_m9_452000_116000 1.000000
R21881 n1_m8_452000_138400 n1_m9_452000_138400 1.000000
R21882 n1_m8_452000_160800 n1_m9_452000_160800 1.000000
R21883 n1_m8_452000_183200 n1_m9_452000_183200 1.000000
R21884 n1_m8_452000_205600 n1_m9_452000_205600 1.000000
R21885 n1_m8_452000_228000 n1_m9_452000_228000 1.000000
R21886 n1_m8_452000_250400 n1_m9_452000_250400 1.000000
R21887 n1_m8_452000_272800 n1_m9_452000_272800 1.000000
R21888 n1_m8_452000_295200 n1_m9_452000_295200 1.000000
R21889 n1_m8_452000_317600 n1_m9_452000_317600 1.000000
R21890 n1_m8_452000_340000 n1_m9_452000_340000 1.000000
R21891 n1_m8_452000_362400 n1_m9_452000_362400 1.000000
R21892 n1_m8_452000_384800 n1_m9_452000_384800 1.000000
R21893 n1_m8_452000_407200 n1_m9_452000_407200 1.000000
R21894 n1_m8_452000_429600 n1_m9_452000_429600 1.000000
R21895 n1_m8_452000_452000 n1_m9_452000_452000 1.000000
R21896 n1_m8_452000_474400 n1_m9_452000_474400 1.000000
R21897 n1_m8_452000_496800 n1_m9_452000_496800 1.000000
R21898 n1_m8_452000_519200 n1_m9_452000_519200 1.000000
R21899 n1_m8_452000_541600 n1_m9_452000_541600 1.000000
R21900 n1_m8_452000_564000 n1_m9_452000_564000 1.000000
R21901 n1_m8_452000_586400 n1_m9_452000_586400 1.000000
R21902 n1_m8_474400_4000 n1_m9_474400_4000 1.000000
R21903 n1_m8_474400_26400 n1_m9_474400_26400 1.000000
R21904 n1_m8_474400_48800 n1_m9_474400_48800 1.000000
R21905 n1_m8_474400_71200 n1_m9_474400_71200 1.000000
R21906 n1_m8_474400_93600 n1_m9_474400_93600 1.000000
R21907 n1_m8_474400_116000 n1_m9_474400_116000 1.000000
R21908 n1_m8_474400_138400 n1_m9_474400_138400 1.000000
R21909 n1_m8_474400_160800 n1_m9_474400_160800 1.000000
R21910 n1_m8_474400_183200 n1_m9_474400_183200 1.000000
R21911 n1_m8_474400_205600 n1_m9_474400_205600 1.000000
R21912 n1_m8_474400_228000 n1_m9_474400_228000 1.000000
R21913 n1_m8_474400_250400 n1_m9_474400_250400 1.000000
R21914 n1_m8_474400_272800 n1_m9_474400_272800 1.000000
R21915 n1_m8_474400_295200 n1_m9_474400_295200 1.000000
R21916 n1_m8_474400_317600 n1_m9_474400_317600 1.000000
R21917 n1_m8_474400_340000 n1_m9_474400_340000 1.000000
R21918 n1_m8_474400_362400 n1_m9_474400_362400 1.000000
R21919 n1_m8_474400_384800 n1_m9_474400_384800 1.000000
R21920 n1_m8_474400_407200 n1_m9_474400_407200 1.000000
R21921 n1_m8_474400_429600 n1_m9_474400_429600 1.000000
R21922 n1_m8_474400_452000 n1_m9_474400_452000 1.000000
R21923 n1_m8_474400_474400 n1_m9_474400_474400 1.000000
R21924 n1_m8_474400_496800 n1_m9_474400_496800 1.000000
R21925 n1_m8_474400_519200 n1_m9_474400_519200 1.000000
R21926 n1_m8_474400_541600 n1_m9_474400_541600 1.000000
R21927 n1_m8_474400_564000 n1_m9_474400_564000 1.000000
R21928 n1_m8_474400_586400 n1_m9_474400_586400 1.000000
R21929 n1_m8_496800_4000 n1_m9_496800_4000 1.000000
R21930 n1_m8_496800_26400 n1_m9_496800_26400 1.000000
R21931 n1_m8_496800_48800 n1_m9_496800_48800 1.000000
R21932 n1_m8_496800_71200 n1_m9_496800_71200 1.000000
R21933 n1_m8_496800_93600 n1_m9_496800_93600 1.000000
R21934 n1_m8_496800_116000 n1_m9_496800_116000 1.000000
R21935 n1_m8_496800_138400 n1_m9_496800_138400 1.000000
R21936 n1_m8_496800_160800 n1_m9_496800_160800 1.000000
R21937 n1_m8_496800_183200 n1_m9_496800_183200 1.000000
R21938 n1_m8_496800_205600 n1_m9_496800_205600 1.000000
R21939 n1_m8_496800_228000 n1_m9_496800_228000 1.000000
R21940 n1_m8_496800_250400 n1_m9_496800_250400 1.000000
R21941 n1_m8_496800_272800 n1_m9_496800_272800 1.000000
R21942 n1_m8_496800_295200 n1_m9_496800_295200 1.000000
R21943 n1_m8_496800_317600 n1_m9_496800_317600 1.000000
R21944 n1_m8_496800_340000 n1_m9_496800_340000 1.000000
R21945 n1_m8_496800_362400 n1_m9_496800_362400 1.000000
R21946 n1_m8_496800_384800 n1_m9_496800_384800 1.000000
R21947 n1_m8_496800_407200 n1_m9_496800_407200 1.000000
R21948 n1_m8_496800_429600 n1_m9_496800_429600 1.000000
R21949 n1_m8_496800_452000 n1_m9_496800_452000 1.000000
R21950 n1_m8_496800_474400 n1_m9_496800_474400 1.000000
R21951 n1_m8_496800_496800 n1_m9_496800_496800 1.000000
R21952 n1_m8_496800_519200 n1_m9_496800_519200 1.000000
R21953 n1_m8_496800_541600 n1_m9_496800_541600 1.000000
R21954 n1_m8_496800_564000 n1_m9_496800_564000 1.000000
R21955 n1_m8_496800_586400 n1_m9_496800_586400 1.000000
R21956 n1_m8_519200_4000 n1_m9_519200_4000 1.000000
R21957 n1_m8_519200_26400 n1_m9_519200_26400 1.000000
R21958 n1_m8_519200_48800 n1_m9_519200_48800 1.000000
R21959 n1_m8_519200_71200 n1_m9_519200_71200 1.000000
R21960 n1_m8_519200_93600 n1_m9_519200_93600 1.000000
R21961 n1_m8_519200_116000 n1_m9_519200_116000 1.000000
R21962 n1_m8_519200_138400 n1_m9_519200_138400 1.000000
R21963 n1_m8_519200_160800 n1_m9_519200_160800 1.000000
R21964 n1_m8_519200_183200 n1_m9_519200_183200 1.000000
R21965 n1_m8_519200_205600 n1_m9_519200_205600 1.000000
R21966 n1_m8_519200_228000 n1_m9_519200_228000 1.000000
R21967 n1_m8_519200_250400 n1_m9_519200_250400 1.000000
R21968 n1_m8_519200_272800 n1_m9_519200_272800 1.000000
R21969 n1_m8_519200_295200 n1_m9_519200_295200 1.000000
R21970 n1_m8_519200_317600 n1_m9_519200_317600 1.000000
R21971 n1_m8_519200_340000 n1_m9_519200_340000 1.000000
R21972 n1_m8_519200_362400 n1_m9_519200_362400 1.000000
R21973 n1_m8_519200_384800 n1_m9_519200_384800 1.000000
R21974 n1_m8_519200_407200 n1_m9_519200_407200 1.000000
R21975 n1_m8_519200_429600 n1_m9_519200_429600 1.000000
R21976 n1_m8_519200_452000 n1_m9_519200_452000 1.000000
R21977 n1_m8_519200_474400 n1_m9_519200_474400 1.000000
R21978 n1_m8_519200_496800 n1_m9_519200_496800 1.000000
R21979 n1_m8_519200_519200 n1_m9_519200_519200 1.000000
R21980 n1_m8_519200_541600 n1_m9_519200_541600 1.000000
R21981 n1_m8_519200_564000 n1_m9_519200_564000 1.000000
R21982 n1_m8_519200_586400 n1_m9_519200_586400 1.000000
R21983 n1_m8_541600_4000 n1_m9_541600_4000 1.000000
R21984 n1_m8_541600_26400 n1_m9_541600_26400 1.000000
R21985 n1_m8_541600_48800 n1_m9_541600_48800 1.000000
R21986 n1_m8_541600_71200 n1_m9_541600_71200 1.000000
R21987 n1_m8_541600_93600 n1_m9_541600_93600 1.000000
R21988 n1_m8_541600_116000 n1_m9_541600_116000 1.000000
R21989 n1_m8_541600_138400 n1_m9_541600_138400 1.000000
R21990 n1_m8_541600_160800 n1_m9_541600_160800 1.000000
R21991 n1_m8_541600_183200 n1_m9_541600_183200 1.000000
R21992 n1_m8_541600_205600 n1_m9_541600_205600 1.000000
R21993 n1_m8_541600_228000 n1_m9_541600_228000 1.000000
R21994 n1_m8_541600_250400 n1_m9_541600_250400 1.000000
R21995 n1_m8_541600_272800 n1_m9_541600_272800 1.000000
R21996 n1_m8_541600_295200 n1_m9_541600_295200 1.000000
R21997 n1_m8_541600_317600 n1_m9_541600_317600 1.000000
R21998 n1_m8_541600_340000 n1_m9_541600_340000 1.000000
R21999 n1_m8_541600_362400 n1_m9_541600_362400 1.000000
R22000 n1_m8_541600_384800 n1_m9_541600_384800 1.000000
R22001 n1_m8_541600_407200 n1_m9_541600_407200 1.000000
R22002 n1_m8_541600_429600 n1_m9_541600_429600 1.000000
R22003 n1_m8_541600_452000 n1_m9_541600_452000 1.000000
R22004 n1_m8_541600_474400 n1_m9_541600_474400 1.000000
R22005 n1_m8_541600_496800 n1_m9_541600_496800 1.000000
R22006 n1_m8_541600_519200 n1_m9_541600_519200 1.000000
R22007 n1_m8_541600_541600 n1_m9_541600_541600 1.000000
R22008 n1_m8_541600_564000 n1_m9_541600_564000 1.000000
R22009 n1_m8_541600_586400 n1_m9_541600_586400 1.000000
R22010 n1_m8_564000_4000 n1_m9_564000_4000 1.000000
R22011 n1_m8_564000_26400 n1_m9_564000_26400 1.000000
R22012 n1_m8_564000_48800 n1_m9_564000_48800 1.000000
R22013 n1_m8_564000_71200 n1_m9_564000_71200 1.000000
R22014 n1_m8_564000_93600 n1_m9_564000_93600 1.000000
R22015 n1_m8_564000_116000 n1_m9_564000_116000 1.000000
R22016 n1_m8_564000_138400 n1_m9_564000_138400 1.000000
R22017 n1_m8_564000_160800 n1_m9_564000_160800 1.000000
R22018 n1_m8_564000_183200 n1_m9_564000_183200 1.000000
R22019 n1_m8_564000_205600 n1_m9_564000_205600 1.000000
R22020 n1_m8_564000_228000 n1_m9_564000_228000 1.000000
R22021 n1_m8_564000_250400 n1_m9_564000_250400 1.000000
R22022 n1_m8_564000_272800 n1_m9_564000_272800 1.000000
R22023 n1_m8_564000_295200 n1_m9_564000_295200 1.000000
R22024 n1_m8_564000_317600 n1_m9_564000_317600 1.000000
R22025 n1_m8_564000_340000 n1_m9_564000_340000 1.000000
R22026 n1_m8_564000_362400 n1_m9_564000_362400 1.000000
R22027 n1_m8_564000_384800 n1_m9_564000_384800 1.000000
R22028 n1_m8_564000_407200 n1_m9_564000_407200 1.000000
R22029 n1_m8_564000_429600 n1_m9_564000_429600 1.000000
R22030 n1_m8_564000_452000 n1_m9_564000_452000 1.000000
R22031 n1_m8_564000_474400 n1_m9_564000_474400 1.000000
R22032 n1_m8_564000_496800 n1_m9_564000_496800 1.000000
R22033 n1_m8_564000_519200 n1_m9_564000_519200 1.000000
R22034 n1_m8_564000_541600 n1_m9_564000_541600 1.000000
R22035 n1_m8_564000_564000 n1_m9_564000_564000 1.000000
R22036 n1_m8_564000_586400 n1_m9_564000_586400 1.000000
R22037 n1_m8_586400_4000 n1_m9_586400_4000 1.000000
R22038 n1_m8_586400_26400 n1_m9_586400_26400 1.000000
R22039 n1_m8_586400_48800 n1_m9_586400_48800 1.000000
R22040 n1_m8_586400_71200 n1_m9_586400_71200 1.000000
R22041 n1_m8_586400_93600 n1_m9_586400_93600 1.000000
R22042 n1_m8_586400_116000 n1_m9_586400_116000 1.000000
R22043 n1_m8_586400_138400 n1_m9_586400_138400 1.000000
R22044 n1_m8_586400_160800 n1_m9_586400_160800 1.000000
R22045 n1_m8_586400_183200 n1_m9_586400_183200 1.000000
R22046 n1_m8_586400_205600 n1_m9_586400_205600 1.000000
R22047 n1_m8_586400_228000 n1_m9_586400_228000 1.000000
R22048 n1_m8_586400_250400 n1_m9_586400_250400 1.000000
R22049 n1_m8_586400_272800 n1_m9_586400_272800 1.000000
R22050 n1_m8_586400_295200 n1_m9_586400_295200 1.000000
R22051 n1_m8_586400_317600 n1_m9_586400_317600 1.000000
R22052 n1_m8_586400_340000 n1_m9_586400_340000 1.000000
R22053 n1_m8_586400_362400 n1_m9_586400_362400 1.000000
R22054 n1_m8_586400_384800 n1_m9_586400_384800 1.000000
R22055 n1_m8_586400_407200 n1_m9_586400_407200 1.000000
R22056 n1_m8_586400_429600 n1_m9_586400_429600 1.000000
R22057 n1_m8_586400_452000 n1_m9_586400_452000 1.000000
R22058 n1_m8_586400_474400 n1_m9_586400_474400 1.000000
R22059 n1_m8_586400_496800 n1_m9_586400_496800 1.000000
R22060 n1_m8_586400_519200 n1_m9_586400_519200 1.000000
R22061 n1_m8_586400_541600 n1_m9_586400_541600 1.000000
R22062 n1_m8_586400_564000 n1_m9_586400_564000 1.000000
R22063 n1_m8_586400_586400 n1_m9_586400_586400 1.000000
V0 n1_m9_160800_160800 0 1.100000
V1 n1_m9_452000_160800 0 1.100000
V2 n1_m9_250400_340000 0 1.100000
V3 n1_m9_541600_541600 0 1.100000
R22064 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R22065 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R22066 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R22067 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R22068 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R22069 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R22070 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R22071 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R22072 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R22073 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R22074 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R22075 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R22076 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R22077 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R22078 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R22079 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R22080 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R22081 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R22082 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R22083 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R22084 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R22085 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R22086 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R22087 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R22088 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R22089 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R22090 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R22091 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R22092 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R22093 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R22094 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R22095 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R22096 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R22097 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R22098 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R22099 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R22100 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R22101 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R22102 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R22103 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R22104 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R22105 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R22106 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R22107 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R22108 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R22109 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R22110 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R22111 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R22112 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R22113 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R22114 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R22115 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R22116 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R22117 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R22118 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R22119 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R22120 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R22121 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R22122 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R22123 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R22124 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R22125 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R22126 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R22127 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R22128 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R22129 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R22130 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R22131 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R22132 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R22133 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R22134 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R22135 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R22136 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R22137 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R22138 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R22139 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R22140 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R22141 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R22142 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R22143 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R22144 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R22145 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R22146 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R22147 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R22148 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R22149 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R22150 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R22151 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R22152 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R22153 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R22154 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R22155 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R22156 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R22157 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R22158 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R22159 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R22160 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R22161 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R22162 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R22163 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R22164 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R22165 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R22166 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R22167 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R22168 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R22169 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R22170 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R22171 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R22172 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R22173 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R22174 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R22175 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R22176 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R22177 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R22178 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R22179 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R22180 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R22181 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R22182 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R22183 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R22184 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R22185 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R22186 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R22187 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R22188 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R22189 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R22190 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R22191 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R22192 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R22193 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R22194 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R22195 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R22196 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R22197 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R22198 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R22199 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R22200 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R22201 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R22202 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R22203 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R22204 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R22205 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R22206 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R22207 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R22208 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R22209 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R22210 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R22211 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R22212 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R22213 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R22214 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R22215 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R22216 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R22217 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R22218 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R22219 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R22220 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R22221 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R22222 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R22223 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R22224 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R22225 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R22226 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R22227 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R22228 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R22229 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R22230 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R22231 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R22232 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R22233 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R22234 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R22235 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R22236 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R22237 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R22238 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R22239 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
R22240 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R22241 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R22242 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R22243 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
R22244 n1_m4_200000_408000 n1_m4_200000_404000 1.166667
R22245 n1_m1_200000_408000 n1_m4_200000_408000 15.000000
R22246 n1_m4_200000_408000 n1_m4_200000_412800 1.400000
R22247 n1_m1_200000_412800 n1_m4_200000_412800 15.000000
R22248 n1_m4_200000_412800 n1_m4_200000_417600 1.400000
R22249 n1_m1_200000_417600 n1_m4_200000_417600 15.000000
R22250 n1_m4_200000_417600 n1_m4_200000_422400 1.400000
R22251 n1_m1_200000_422400 n1_m4_200000_422400 15.000000
R22252 n1_m4_200000_422400 n1_m4_200000_427200 1.400000
R22253 n1_m1_200000_427200 n1_m4_200000_427200 15.000000
R22254 n1_m4_200000_427200 n1_m4_200000_432000 1.400000
R22255 n1_m1_200000_432000 n1_m4_200000_432000 15.000000
R22256 n1_m4_200000_432000 n1_m4_200000_436800 1.400000
R22257 n1_m1_200000_436800 n1_m4_200000_436800 15.000000
R22258 n1_m4_200000_436800 n1_m4_200000_441600 1.400000
R22259 n1_m1_200000_441600 n1_m4_200000_441600 15.000000
R22260 n1_m4_200000_441600 n1_m4_200000_446400 1.400000
R22261 n1_m1_200000_446400 n1_m4_200000_446400 15.000000
R22262 n1_m4_200000_446400 n1_m4_200000_451200 1.400000
R22263 n1_m1_200000_451200 n1_m4_200000_451200 15.000000
R22264 n1_m4_200000_451200 n1_m4_200000_456000 1.400000
R22265 n1_m1_200000_456000 n1_m4_200000_456000 15.000000
R22266 n1_m4_200000_456000 n1_m4_200000_460800 1.400000
R22267 n1_m1_200000_460800 n1_m4_200000_460800 15.000000
R22268 n1_m4_200000_460800 n1_m4_200000_465600 1.400000
R22269 n1_m1_200000_465600 n1_m4_200000_465600 15.000000
R22270 n1_m4_200000_465600 n1_m4_200000_470400 1.400000
R22271 n1_m1_200000_470400 n1_m4_200000_470400 15.000000
R22272 n1_m4_200000_470400 n1_m4_200000_475200 1.400000
R22273 n1_m1_200000_475200 n1_m4_200000_475200 15.000000
R22274 n1_m4_200000_475200 n1_m4_200000_480000 1.400000
R22275 n1_m1_200000_480000 n1_m4_200000_480000 15.000000
R22276 n1_m4_200000_480000 n1_m4_200000_484000 1.166667
R22277 n1_m4_200000_484000 n1_m7_200000_484000 9.000000
R22278 n1_m4_200000_484800 n1_m4_200000_484000 0.233333
R22279 n1_m1_200000_484800 n1_m4_200000_484800 15.000000
R22280 n1_m4_200000_484800 n1_m4_200000_489600 1.400000
R22281 n1_m1_200000_489600 n1_m4_200000_489600 15.000000
R22282 n1_m4_200000_489600 n1_m4_200000_494400 1.400000
R22283 n1_m1_200000_494400 n1_m4_200000_494400 15.000000
R22284 n1_m4_200000_494400 n1_m4_200000_499200 1.400000
R22285 n1_m1_200000_499200 n1_m4_200000_499200 15.000000
R22286 n1_m4_200000_499200 n1_m4_200000_504000 1.400000
R22287 n1_m1_200000_504000 n1_m4_200000_504000 15.000000
R22288 n1_m4_200000_504000 n1_m4_200000_508800 1.400000
R22289 n1_m1_200000_508800 n1_m4_200000_508800 15.000000
R22290 n1_m4_200000_508800 n1_m4_200000_513600 1.400000
R22291 n1_m1_200000_513600 n1_m4_200000_513600 15.000000
R22292 n1_m4_200000_513600 n1_m4_200000_518400 1.400000
R22293 n1_m1_200000_518400 n1_m4_200000_518400 15.000000
R22294 n1_m4_200000_518400 n1_m4_200000_523200 1.400000
R22295 n1_m1_200000_523200 n1_m4_200000_523200 15.000000
R22296 n1_m4_200000_523200 n1_m4_200000_528000 1.400000
R22297 n1_m1_200000_528000 n1_m4_200000_528000 15.000000
R22298 n1_m4_200000_528000 n1_m4_200000_532800 1.400000
R22299 n1_m1_200000_532800 n1_m4_200000_532800 15.000000
R22300 n1_m4_200000_532800 n1_m4_200000_537600 1.400000
R22301 n1_m1_200000_537600 n1_m4_200000_537600 15.000000
R22302 n1_m4_200000_537600 n1_m4_200000_542400 1.400000
R22303 n1_m1_200000_542400 n1_m4_200000_542400 15.000000
R22304 n1_m4_200000_542400 n1_m4_200000_547200 1.400000
R22305 n1_m1_200000_547200 n1_m4_200000_547200 15.000000
R22306 n1_m4_200000_547200 n1_m4_200000_552000 1.400000
R22307 n1_m1_200000_552000 n1_m4_200000_552000 15.000000
R22308 n1_m4_200000_552000 n1_m4_200000_556800 1.400000
R22309 n1_m1_200000_556800 n1_m4_200000_556800 15.000000
R22310 n1_m4_200000_556800 n1_m4_200000_561600 1.400000
R22311 n1_m1_200000_561600 n1_m4_200000_561600 15.000000
R22312 n1_m4_200000_561600 n1_m4_200000_564000 0.700000
R22313 n1_m4_200000_564000 n1_m7_200000_564000 9.000000
R22314 n1_m4_200000_566400 n1_m4_200000_564000 0.700000
R22315 n1_m1_200000_566400 n1_m4_200000_566400 15.000000
R22316 n1_m4_200000_566400 n1_m4_200000_571200 1.400000
R22317 n1_m1_200000_571200 n1_m4_200000_571200 15.000000
R22318 n1_m4_200000_571200 n1_m4_200000_576000 1.400000
R22319 n1_m1_200000_576000 n1_m4_200000_576000 15.000000
R22320 n1_m4_200000_576000 n1_m4_200000_580800 1.400000
R22321 n1_m1_200000_580800 n1_m4_200000_580800 15.000000
R22322 n1_m4_200000_580800 n1_m4_200000_585600 1.400000
R22323 n1_m1_200000_585600 n1_m4_200000_585600 15.000000
R22324 n1_m4_200000_585600 n1_m4_200000_590400 1.400000
R22325 n1_m1_200000_590400 n1_m4_200000_590400 15.000000
R22326 n1_m4_200000_590400 n1_m4_200000_595200 1.400000
R22327 n1_m1_200000_595200 n1_m4_200000_595200 15.000000
I0 n1_m1_9600_9600 0 2.140000e-08
I1 n1_m1_9600_28800 0 4.397143e-08
I2 n1_m1_9600_33600 0 2.539780e-08
I3 n1_m1_9600_38400 0 3.693077e-08
I4 n1_m1_9600_57600 0 5.620000e-08
I5 n1_m1_9600_72000 0 8.636993e-07
I6 n1_m1_9600_76800 0 4.167473e-08
I7 n1_m1_9600_81600 0 7.186476e-07
I8 n1_m1_9600_86400 0 2.244520e-07
I9 n1_m1_9600_91200 0 5.037579e-07
I10 n1_m1_9600_96000 0 9.266597e-07
I11 n1_m1_9600_100800 0 3.907455e-07
I12 n1_m1_9600_105600 0 7.594987e-07
I13 n1_m1_9600_110400 0 1.562857e-07
I14 n1_m1_9600_115200 0 9.113349e-07
I15 n1_m1_9600_120000 0 7.479679e-07
I16 n1_m1_9600_124800 0 7.750000e-08
I17 n1_m1_9600_129600 0 3.880000e-08
I18 n1_m1_9600_134400 0 7.934848e-07
I19 n1_m1_9600_139200 0 5.207143e-08
I20 n1_m1_9600_144000 0 8.028232e-07
I21 n1_m1_9600_148800 0 3.904750e-07
I22 n1_m1_9600_153600 0 7.173899e-07
I23 n1_m1_9600_158400 0 1.082286e-07
I24 n1_m1_9600_163200 0 3.817500e-07
I25 n1_m1_9600_168000 0 6.369464e-07
I26 n1_m1_9600_172800 0 6.012679e-07
I27 n1_m1_9600_177600 0 6.310232e-07
I28 n1_m1_9600_182400 0 1.472714e-07
I29 n1_m1_9600_187200 0 3.119740e-07
I30 n1_m1_9600_192000 0 7.108364e-07
I31 n1_m1_9600_196800 0 9.171429e-09
I32 n1_m1_9600_201600 0 9.333195e-07
I33 n1_m1_9600_206400 0 4.303818e-07
I34 n1_m1_9600_211200 0 4.688161e-07
I35 n1_m1_9600_216000 0 5.030214e-07
I36 n1_m1_9600_220800 0 8.226500e-07
I37 n1_m1_9600_225600 0 8.820000e-08
I38 n1_m1_9600_230400 0 5.613214e-07
I39 n1_m1_9600_235200 0 4.435411e-07
I40 n1_m1_9600_240000 0 7.454499e-07
I41 n1_m1_9600_244800 0 7.612417e-07
I42 n1_m1_9600_249600 0 1.450276e-06
I43 n1_m1_9600_254400 0 2.720610e-07
I44 n1_m1_9600_259200 0 4.925532e-07
I45 n1_m1_9600_264000 0 1.258487e-06
I46 n1_m1_9600_268800 0 1.149980e-06
I47 n1_m1_9600_273600 0 5.801554e-07
I48 n1_m1_9600_278400 0 8.557143e-08
I49 n1_m1_9600_283200 0 6.272857e-08
I50 n1_m1_9600_288000 0 6.762857e-08
I51 n1_m1_9600_292800 0 6.371429e-08
I52 n1_m1_9600_297600 0 1.109286e-07
I53 n1_m1_9600_302400 0 2.732381e-08
I54 n1_m1_9600_307200 0 1.186190e-07
I55 n1_m1_9600_312000 0 7.584368e-07
I56 n1_m1_9600_316800 0 1.105299e-06
I57 n1_m1_9600_321600 0 4.386214e-07
I58 n1_m1_9600_326400 0 5.647143e-07
I59 n1_m1_9600_331200 0 2.968260e-07
I60 n1_m1_9600_336000 0 1.115519e-06
I61 n1_m1_9600_340800 0 1.054682e-06
I62 n1_m1_9600_345600 0 8.357262e-07
I63 n1_m1_9600_350400 0 1.111774e-06
I64 n1_m1_9600_355200 0 5.509571e-07
I65 n1_m1_9600_360000 0 8.896926e-07
I66 n1_m1_9600_364800 0 8.408104e-07
I67 n1_m1_9600_369600 0 8.835812e-07
I68 n1_m1_9600_374400 0 7.442048e-07
I69 n1_m1_9600_379200 0 4.133851e-07
I70 n1_m1_9600_384000 0 8.340552e-07
I71 n1_m1_9600_388800 0 4.109896e-07
I72 n1_m1_9600_393600 0 1.037194e-06
I73 n1_m1_9600_398400 0 1.913854e-06
I74 n1_m1_9600_403200 0 3.860727e-07
I75 n1_m1_9600_408000 0 1.366468e-07
I76 n1_m1_9600_412800 0 7.455377e-07
I77 n1_m1_9600_417600 0 8.869714e-07
I78 n1_m1_9600_422400 0 1.507911e-07
I79 n1_m1_9600_427200 0 6.398893e-07
I80 n1_m1_9600_432000 0 6.396883e-07
I81 n1_m1_9600_436800 0 2.983468e-07
I82 n1_m1_9600_441600 0 4.099179e-07
I83 n1_m1_9600_446400 0 5.369375e-07
I84 n1_m1_9600_451200 0 6.114286e-09
I85 n1_m1_9600_456000 0 5.620000e-08
I86 n1_m1_9600_460800 0 4.820268e-07
I87 n1_m1_9600_465600 0 3.974964e-07
I88 n1_m1_9600_470400 0 5.411429e-08
I89 n1_m1_9600_475200 0 4.922054e-07
I90 n1_m1_9600_480000 0 9.152666e-07
I91 n1_m1_9600_484800 0 8.889221e-07
I92 n1_m1_9600_489600 0 6.418649e-07
I93 n1_m1_9600_494400 0 1.222857e-08
I94 n1_m1_9600_504000 0 5.057143e-08
I95 n1_m1_9600_508800 0 5.956429e-07
I96 n1_m1_9600_513600 0 1.268357e-07
I97 n1_m1_9600_518400 0 2.593846e-08
I98 n1_m1_9600_523200 0 4.860440e-08
I99 n1_m1_9600_528000 0 3.057143e-09
I100 n1_m1_9600_532800 0 1.606154e-08
I101 n1_m1_9600_537600 0 4.013846e-08
I102 n1_m1_9600_552000 0 5.010000e-08
I103 n1_m1_14400_72000 0 1.794545e-07
I104 n1_m1_14400_81600 0 5.880952e-07
I105 n1_m1_14400_86400 0 2.352381e-07
I106 n1_m1_14400_91200 0 1.023377e-07
I107 n1_m1_14400_96000 0 2.011688e-07
I108 n1_m1_14400_100800 0 7.545455e-08
I109 n1_m1_14400_105600 0 1.541299e-07
I110 n1_m1_14400_115200 0 7.697222e-07
I111 n1_m1_14400_120000 0 2.733750e-07
I112 n1_m1_14400_134400 0 2.163437e-07
I113 n1_m1_14400_144000 0 2.840625e-07
I114 n1_m1_14400_148800 0 1.427679e-07
I115 n1_m1_14400_153600 0 7.652173e-07
I116 n1_m1_14400_158400 0 4.392857e-07
I117 n1_m1_14400_163200 0 1.462500e-07
I118 n1_m1_14400_168000 0 3.656250e-07
I119 n1_m1_14400_172800 0 5.418750e-07
I120 n1_m1_14400_177600 0 7.790625e-07
I121 n1_m1_14400_182400 0 3.792857e-08
I122 n1_m1_14400_187200 0 6.583636e-07
I123 n1_m1_14400_192000 0 8.588745e-07
I124 n1_m1_14400_201600 0 8.465455e-07
I125 n1_m1_14400_206400 0 7.581818e-08
I126 n1_m1_14400_211200 0 2.528982e-07
I127 n1_m1_14400_216000 0 3.294643e-07
I128 n1_m1_14400_220800 0 5.037500e-07
I129 n1_m1_14400_225600 0 1.967857e-08
I130 n1_m1_14400_230400 0 3.166071e-07
I131 n1_m1_14400_235200 0 2.434018e-07
I132 n1_m1_14400_240000 0 8.092721e-07
I133 n1_m1_14400_244800 0 4.532726e-07
I134 n1_m1_14400_249600 0 6.343242e-07
I135 n1_m1_14400_254400 0 8.471515e-08
I136 n1_m1_14400_259200 0 9.953247e-08
I137 n1_m1_14400_264000 0 3.252158e-07
I138 n1_m1_14400_268800 0 6.056767e-07
I139 n1_m1_14400_273600 0 4.029018e-07
I140 n1_m1_14400_278400 0 6.715476e-08
I141 n1_m1_14400_283200 0 1.356643e-07
I142 n1_m1_14400_288000 0 2.813095e-07
I143 n1_m1_14400_292800 0 3.631429e-07
I144 n1_m1_14400_297600 0 2.869000e-07
I145 n1_m1_14400_302400 0 4.423810e-08
I146 n1_m1_14400_307200 0 1.178452e-07
I147 n1_m1_14400_312000 0 2.167656e-07
I148 n1_m1_14400_316800 0 3.025203e-07
I149 n1_m1_14400_321600 0 6.556214e-07
I150 n1_m1_14400_326400 0 2.878571e-07
I151 n1_m1_14400_331200 0 5.111688e-08
I152 n1_m1_14400_336000 0 3.747238e-07
I153 n1_m1_14400_340800 0 7.436607e-07
I154 n1_m1_14400_345600 0 5.525452e-07
I155 n1_m1_14400_350400 0 4.868977e-07
I156 n1_m1_14400_355200 0 3.772429e-07
I157 n1_m1_14400_360000 0 2.699693e-07
I158 n1_m1_14400_364800 0 1.818182e-07
I159 n1_m1_14400_369600 0 2.436473e-07
I160 n1_m1_14400_374400 0 8.861825e-07
I161 n1_m1_14400_379200 0 3.476149e-07
I162 n1_m1_14400_384000 0 5.612019e-07
I163 n1_m1_14400_388800 0 7.675325e-08
I164 n1_m1_14400_393600 0 1.476949e-06
I165 n1_m1_14400_398400 0 7.932603e-06
I166 n1_m1_14400_403200 0 7.472727e-08
I167 n1_m1_14400_408000 0 7.957289e-08
I168 n1_m1_14400_412800 0 3.812659e-07
I169 n1_m1_14400_417600 0 1.861714e-07
I170 n1_m1_14400_422400 0 3.929464e-08
I171 n1_m1_14400_427200 0 2.357679e-07
I172 n1_m1_14400_432000 0 1.311688e-07
I173 n1_m1_14400_436800 0 5.246753e-08
I174 n1_m1_14400_441600 0 1.427679e-07
I175 n1_m1_14400_446400 0 3.569196e-07
I176 n1_m1_14400_460800 0 4.118304e-07
I177 n1_m1_14400_465600 0 1.647321e-07
I178 n1_m1_14400_475200 0 5.216518e-07
I179 n1_m1_14400_480000 0 3.627906e-07
I180 n1_m1_14400_484800 0 8.228312e-07
I181 n1_m1_14400_489600 0 6.060779e-07
I182 n1_m1_14400_494400 0 8.914286e-08
I183 n1_m1_14400_508800 0 5.138571e-07
I184 n1_m1_14400_513600 0 8.564286e-08
I185 n1_m1_19200_153600 0 4.526786e-07
I186 n1_m1_19200_158400 0 2.635714e-07
I187 n1_m1_19200_177600 0 4.460000e-07
I188 n1_m1_19200_182400 0 6.257143e-08
I189 n1_m1_19200_187200 0 4.676623e-07
I190 n1_m1_19200_192000 0 3.059177e-07
I191 n1_m1_19200_196800 0 1.118571e-07
I192 n1_m1_19200_201600 0 4.337922e-07
I193 n1_m1_19200_206400 0 7.371429e-08
I194 n1_m1_19200_211200 0 2.670000e-07
I195 n1_m1_19200_225600 0 2.244714e-07
I196 n1_m1_19200_230400 0 7.825714e-07
I197 n1_m1_19200_235200 0 4.198571e-07
I198 n1_m1_19200_240000 0 4.263636e-07
I199 n1_m1_19200_249600 0 2.005714e-07
I200 n1_m1_19200_254400 0 8.550952e-08
I201 n1_m1_19200_259200 0 8.258095e-08
I202 n1_m1_19200_264000 0 1.963405e-07
I203 n1_m1_19200_268800 0 3.515643e-07
I204 n1_m1_19200_273600 0 1.296905e-07
I205 n1_m1_19200_278400 0 1.004881e-07
I206 n1_m1_19200_283200 0 2.322143e-08
I207 n1_m1_19200_288000 0 8.441905e-08
I208 n1_m1_19200_292800 0 4.671429e-08
I209 n1_m1_19200_297600 0 6.002000e-07
I210 n1_m1_19200_302400 0 2.386714e-07
I211 n1_m1_19200_307200 0 2.203929e-07
I212 n1_m1_19200_312000 0 3.168405e-07
I213 n1_m1_19200_316800 0 1.649048e-07
I214 n1_m1_19200_321600 0 1.275571e-07
I215 n1_m1_19200_326400 0 5.000000e-08
I216 n1_m1_19200_331200 0 7.400000e-09
I217 n1_m1_19200_340800 0 2.768571e-07
I218 n1_m1_19200_345600 0 4.614286e-08
I219 n1_m1_19200_355200 0 3.057143e-09
I220 n1_m1_19200_360000 0 3.295095e-07
I221 n1_m1_19200_374400 0 4.305556e-08
I222 n1_m1_19200_408000 0 2.224643e-07
I223 n1_m1_19200_412800 0 8.025000e-07
I224 n1_m1_19200_417600 0 2.517857e-07
I225 n1_m1_19200_441600 0 3.370000e-07
I226 n1_m1_19200_460800 0 1.914286e-07
I227 n1_m1_19200_465600 0 7.657143e-08
I228 n1_m1_19200_470400 0 7.542857e-08
I229 n1_m1_19200_475200 0 1.885714e-07
I230 n1_m1_19200_480000 0 2.365714e-07
I231 n1_m1_19200_484800 0 1.512468e-07
I232 n1_m1_19200_489600 0 7.505974e-07
I233 n1_m1_19200_494400 0 6.857143e-09
I234 n1_m1_19200_508800 0 1.433571e-07
I235 n1_m1_19200_513600 0 2.389286e-08
I236 n1_m1_19200_580800 0 7.353846e-08
I237 n1_m1_19200_585600 0 4.596154e-08
I238 n1_m1_24000_158400 0 3.077143e-07
I239 n1_m1_24000_163200 0 5.128571e-08
I240 n1_m1_24000_192000 0 1.020000e-07
I241 n1_m1_24000_201600 0 4.914286e-08
I242 n1_m1_24000_206400 0 3.685714e-08
I243 n1_m1_24000_225600 0 7.782143e-08
I244 n1_m1_24000_230400 0 6.360714e-07
I245 n1_m1_24000_235200 0 1.268571e-07
I246 n1_m1_24000_249600 0 5.474286e-08
I247 n1_m1_24000_254400 0 1.276571e-07
I248 n1_m1_24000_259200 0 1.453333e-07
I249 n1_m1_24000_264000 0 3.255381e-07
I250 n1_m1_24000_268800 0 1.121595e-07
I251 n1_m1_24000_273600 0 3.101571e-07
I252 n1_m1_24000_278400 0 9.403571e-08
I253 n1_m1_24000_283200 0 2.367964e-07
I254 n1_m1_24000_288000 0 9.099286e-08
I255 n1_m1_24000_292800 0 1.140714e-07
I256 n1_m1_24000_297600 0 3.459857e-07
I257 n1_m1_24000_302400 0 1.263702e-07
I258 n1_m1_24000_307200 0 9.507143e-08
I259 n1_m1_24000_312000 0 4.230571e-07
I260 n1_m1_24000_316800 0 1.178571e-07
I261 n1_m1_24000_321600 0 1.813238e-07
I262 n1_m1_24000_326400 0 3.614286e-08
I263 n1_m1_24000_331200 0 1.347571e-07
I264 n1_m1_24000_340800 0 1.234286e-08
I265 n1_m1_24000_345600 0 2.057143e-09
I266 n1_m1_24000_408000 0 6.325893e-08
I267 n1_m1_24000_412800 0 9.066964e-07
I268 n1_m1_24000_417600 0 4.433571e-07
I269 n1_m1_24000_475200 0 1.842857e-07
I270 n1_m1_24000_480000 0 1.328571e-07
I271 n1_m1_24000_484800 0 9.857143e-09
I272 n1_m1_24000_489600 0 7.454545e-08
I273 n1_m1_24000_518400 0 5.353846e-09
I274 n1_m1_24000_523200 0 6.246154e-09
I275 n1_m1_24000_580800 0 5.147692e-07
I276 n1_m1_24000_585600 0 3.387308e-07
I277 n1_m1_28800_249600 0 5.825000e-08
I278 n1_m1_28800_254400 0 1.031357e-07
I279 n1_m1_28800_259200 0 6.691429e-08
I280 n1_m1_28800_264000 0 7.516190e-08
I281 n1_m1_28800_268800 0 9.169048e-08
I282 n1_m1_28800_273600 0 1.397119e-07
I283 n1_m1_28800_278400 0 3.625000e-08
I284 n1_m1_28800_283200 0 8.524643e-08
I285 n1_m1_28800_288000 0 4.827857e-08
I286 n1_m1_28800_292800 0 1.139107e-07
I287 n1_m1_28800_297600 0 1.334155e-07
I288 n1_m1_28800_302400 0 5.914107e-08
I289 n1_m1_28800_307200 0 1.158214e-07
I290 n1_m1_28800_312000 0 1.220000e-07
I291 n1_m1_28800_316800 0 8.263810e-08
I292 n1_m1_28800_321600 0 1.334286e-07
I293 n1_m1_28800_326400 0 9.902381e-08
I294 n1_m1_28800_331200 0 9.718810e-08
I295 n1_m1_28800_336000 0 1.671429e-08
I296 n1_m1_28800_408000 0 3.528571e-08
I297 n1_m1_28800_412800 0 2.117143e-07
I298 n1_m1_28800_513600 0 1.180000e-07
I299 n1_m1_28800_518400 0 7.276769e-07
I300 n1_m1_28800_523200 0 3.123077e-09
I301 n1_m1_28800_585600 0 3.400000e-08
I302 n1_m1_33600_144000 0 3.469451e-06
I303 n1_m1_33600_148800 0 5.782418e-07
I304 n1_m1_33600_244800 0 6.544571e-07
I305 n1_m1_33600_249600 0 7.407057e-07
I306 n1_m1_33600_254400 0 2.037200e-07
I307 n1_m1_33600_259200 0 1.642057e-07
I308 n1_m1_33600_264000 0 1.353714e-07
I309 n1_m1_33600_268800 0 1.683000e-08
I310 n1_m1_33600_273600 0 1.146082e-07
I311 n1_m1_33600_278400 0 1.912347e-07
I312 n1_m1_33600_283200 0 1.335543e-07
I313 n1_m1_33600_288000 0 5.273095e-07
I314 n1_m1_33600_292800 0 1.835952e-07
I315 n1_m1_33600_297600 0 8.258095e-07
I316 n1_m1_33600_302400 0 3.277608e-07
I317 n1_m1_33600_307200 0 1.913980e-07
I318 n1_m1_33600_312000 0 7.007429e-08
I319 n1_m1_33600_316800 0 6.757143e-08
I320 n1_m1_33600_321600 0 7.445556e-08
I321 n1_m1_33600_326400 0 3.081143e-08
I322 n1_m1_33600_331200 0 6.435429e-08
I323 n1_m1_33600_336000 0 2.802286e-07
I324 n1_m1_33600_360000 0 1.440000e-08
I325 n1_m1_33600_470400 0 3.040000e-07
I326 n1_m1_33600_518400 0 2.395000e-07
I327 n1_m1_38400_4800 0 1.975385e-08
I328 n1_m1_38400_9600 0 3.644615e-08
I329 n1_m1_38400_240000 0 1.084286e-08
I330 n1_m1_38400_244800 0 3.604486e-06
I331 n1_m1_38400_249600 0 2.752929e-06
I332 n1_m1_38400_254400 0 8.032286e-08
I333 n1_m1_38400_259200 0 2.760000e-08
I334 n1_m1_38400_264000 0 4.901857e-07
I335 n1_m1_38400_268800 0 3.173429e-07
I336 n1_m1_38400_273600 0 2.445061e-07
I337 n1_m1_38400_278400 0 6.792245e-08
I338 n1_m1_38400_283200 0 9.390571e-08
I339 n1_m1_38400_288000 0 1.159762e-07
I340 n1_m1_38400_292800 0 1.370476e-07
I341 n1_m1_38400_297600 0 9.818248e-07
I342 n1_m1_38400_302400 0 1.750535e-07
I343 n1_m1_38400_307200 0 1.178163e-07
I344 n1_m1_38400_312000 0 3.759600e-07
I345 n1_m1_38400_316800 0 1.357714e-07
I346 n1_m1_38400_321600 0 1.510397e-07
I347 n1_m1_38400_326400 0 6.410286e-08
I348 n1_m1_38400_331200 0 1.175686e-07
I349 n1_m1_38400_336000 0 4.005943e-07
I350 n1_m1_38400_340800 0 1.485714e-07
I351 n1_m1_43200_244800 0 1.765714e-08
I352 n1_m1_43200_249600 0 4.564286e-08
I353 n1_m1_43200_254400 0 5.892000e-08
I354 n1_m1_43200_259200 0 3.800952e-08
I355 n1_m1_43200_264000 0 4.472239e-07
I356 n1_m1_43200_268800 0 3.601825e-07
I357 n1_m1_43200_273600 0 1.696333e-07
I358 n1_m1_43200_278400 0 4.313878e-08
I359 n1_m1_43200_283200 0 1.443882e-07
I360 n1_m1_43200_288000 0 1.827388e-07
I361 n1_m1_43200_292800 0 7.814286e-08
I362 n1_m1_43200_297600 0 1.253314e-07
I363 n1_m1_43200_302400 0 1.673657e-07
I364 n1_m1_43200_307200 0 3.170306e-07
I365 n1_m1_43200_312000 0 3.329024e-07
I366 n1_m1_43200_316800 0 9.929765e-08
I367 n1_m1_43200_321600 0 6.926482e-07
I368 n1_m1_43200_326400 0 7.700000e-08
I369 n1_m1_43200_331200 0 1.100200e-07
I370 n1_m1_43200_336000 0 2.469914e-07
I371 n1_m1_43200_340800 0 5.209524e-08
I372 n1_m1_48000_96000 0 1.740000e-08
I373 n1_m1_48000_240000 0 7.333333e-09
I374 n1_m1_48000_244800 0 1.145714e-07
I375 n1_m1_48000_249600 0 1.734143e-07
I376 n1_m1_48000_254400 0 5.766000e-07
I377 n1_m1_48000_259200 0 8.725048e-07
I378 n1_m1_48000_264000 0 2.062237e-07
I379 n1_m1_48000_268800 0 1.635413e-07
I380 n1_m1_48000_273600 0 4.325238e-07
I381 n1_m1_48000_278400 0 1.527755e-07
I382 n1_m1_48000_283200 0 2.907490e-07
I383 n1_m1_48000_288000 0 1.973850e-07
I384 n1_m1_48000_292800 0 8.525000e-08
I385 n1_m1_48000_297600 0 3.009629e-07
I386 n1_m1_48000_302400 0 3.547914e-07
I387 n1_m1_48000_307200 0 1.524694e-07
I388 n1_m1_48000_312000 0 1.946490e-07
I389 n1_m1_48000_316800 0 1.354023e-07
I390 n1_m1_48000_321600 0 2.432375e-07
I391 n1_m1_48000_326400 0 1.230571e-07
I392 n1_m1_48000_331200 0 7.054286e-08
I393 n1_m1_48000_336000 0 4.102143e-07
I394 n1_m1_48000_340800 0 3.571619e-07
I395 n1_m1_48000_350400 0 6.171429e-09
I396 n1_m1_48000_355200 0 8.228571e-09
I397 n1_m1_48000_580800 0 2.400000e-07
I398 n1_m1_48000_585600 0 1.500000e-07
I399 n1_m1_52800_240000 0 5.338095e-09
I400 n1_m1_52800_244800 0 6.771429e-08
I401 n1_m1_52800_249600 0 1.164357e-07
I402 n1_m1_52800_254400 0 9.217143e-08
I403 n1_m1_52800_259200 0 7.697143e-08
I404 n1_m1_52800_264000 0 1.532952e-07
I405 n1_m1_52800_268800 0 9.320238e-08
I406 n1_m1_52800_273600 0 1.479738e-07
I407 n1_m1_52800_278400 0 7.635714e-08
I408 n1_m1_52800_283200 0 1.731571e-07
I409 n1_m1_52800_288000 0 3.673833e-07
I410 n1_m1_52800_292800 0 3.148393e-07
I411 n1_m1_52800_297600 0 5.312857e-07
I412 n1_m1_52800_302400 0 5.830095e-07
I413 n1_m1_52800_307200 0 1.845952e-07
I414 n1_m1_52800_312000 0 1.977857e-07
I415 n1_m1_52800_316800 0 3.325429e-07
I416 n1_m1_52800_321600 0 2.224857e-07
I417 n1_m1_52800_326400 0 1.377714e-07
I418 n1_m1_52800_331200 0 1.907571e-07
I419 n1_m1_52800_336000 0 1.556790e-06
I420 n1_m1_52800_340800 0 1.800672e-06
I421 n1_m1_52800_364800 0 1.462500e-08
I422 n1_m1_52800_369600 0 1.229857e-07
I423 n1_m1_52800_374400 0 3.016143e-07
I424 n1_m1_52800_379200 0 1.108333e-08
I425 n1_m1_52800_388800 0 1.885000e-07
I426 n1_m1_52800_393600 0 1.008750e-08
I427 n1_m1_52800_398400 0 7.711548e-08
I428 n1_m1_52800_403200 0 5.479286e-08
I429 n1_m1_52800_408000 0 4.440952e-08
I430 n1_m1_52800_412800 0 1.296857e-07
I431 n1_m1_52800_417600 0 8.421429e-09
I432 n1_m1_52800_422400 0 7.511667e-08
I433 n1_m1_52800_580800 0 3.507692e-07
I434 n1_m1_52800_585600 0 2.277474e-07
I435 n1_m1_57600_192000 0 8.980000e-08
I436 n1_m1_57600_196800 0 1.296143e-07
I437 n1_m1_57600_201600 0 1.174857e-07
I438 n1_m1_57600_206400 0 3.240000e-08
I439 n1_m1_57600_211200 0 2.164286e-07
I440 n1_m1_57600_216000 0 2.885714e-07
I441 n1_m1_57600_220800 0 1.655000e-08
I442 n1_m1_57600_240000 0 1.519048e-09
I443 n1_m1_57600_244800 0 5.731429e-08
I444 n1_m1_57600_249600 0 1.201024e-07
I445 n1_m1_57600_254400 0 9.166190e-08
I446 n1_m1_57600_259200 0 1.066286e-07
I447 n1_m1_57600_264000 0 3.694857e-07
I448 n1_m1_57600_268800 0 6.507381e-08
I449 n1_m1_57600_273600 0 2.396119e-07
I450 n1_m1_57600_278400 0 2.741429e-07
I451 n1_m1_57600_283200 0 1.522286e-07
I452 n1_m1_57600_288000 0 1.330929e-07
I453 n1_m1_57600_292800 0 5.519643e-08
I454 n1_m1_57600_297600 0 1.821714e-07
I455 n1_m1_57600_302400 0 2.602667e-07
I456 n1_m1_57600_307200 0 7.959048e-07
I457 n1_m1_57600_312000 0 1.989905e-07
I458 n1_m1_57600_316800 0 5.754127e-08
I459 n1_m1_57600_321600 0 1.500143e-07
I460 n1_m1_57600_326400 0 1.925714e-07
I461 n1_m1_57600_331200 0 1.264429e-07
I462 n1_m1_57600_336000 0 1.769067e-06
I463 n1_m1_57600_340800 0 1.481042e-06
I464 n1_m1_57600_350400 0 9.471429e-09
I465 n1_m1_57600_355200 0 3.662857e-08
I466 n1_m1_57600_360000 0 1.204000e-07
I467 n1_m1_57600_364800 0 8.341786e-08
I468 n1_m1_57600_369600 0 1.674048e-07
I469 n1_m1_57600_374400 0 2.985857e-07
I470 n1_m1_57600_379200 0 1.129976e-07
I471 n1_m1_57600_384000 0 9.718095e-08
I472 n1_m1_57600_388800 0 1.208048e-07
I473 n1_m1_57600_393600 0 1.101268e-07
I474 n1_m1_57600_398400 0 1.205036e-07
I475 n1_m1_57600_403200 0 6.230714e-08
I476 n1_m1_57600_408000 0 2.516667e-07
I477 n1_m1_57600_412800 0 2.139429e-07
I478 n1_m1_57600_417600 0 1.721595e-07
I479 n1_m1_57600_422400 0 1.510139e-07
I480 n1_m1_57600_427200 0 1.578218e-07
I481 n1_m1_57600_432000 0 4.366429e-07
I482 n1_m1_57600_585600 0 4.258333e-08
I483 n1_m1_62400_4800 0 1.646154e-08
I484 n1_m1_62400_9600 0 1.371795e-09
I485 n1_m1_62400_48000 0 2.436000e-08
I486 n1_m1_62400_153600 0 2.532857e-08
I487 n1_m1_62400_158400 0 1.003200e-07
I488 n1_m1_62400_163200 0 6.963429e-08
I489 n1_m1_62400_168000 0 1.063214e-07
I490 n1_m1_62400_172800 0 1.879429e-07
I491 n1_m1_62400_177600 0 4.106262e-07
I492 n1_m1_62400_182400 0 1.010357e-07
I493 n1_m1_62400_187200 0 9.748571e-08
I494 n1_m1_62400_192000 0 1.297119e-07
I495 n1_m1_62400_196800 0 6.372857e-08
I496 n1_m1_62400_201600 0 3.596571e-07
I497 n1_m1_62400_206400 0 1.781643e-07
I498 n1_m1_62400_211200 0 1.217000e-07
I499 n1_m1_62400_216000 0 9.754286e-08
I500 n1_m1_62400_220800 0 7.439048e-08
I501 n1_m1_62400_225600 0 1.684071e-07
I502 n1_m1_62400_230400 0 8.365714e-08
I503 n1_m1_62400_235200 0 1.508571e-08
I504 n1_m1_62400_244800 0 5.772143e-08
I505 n1_m1_62400_249600 0 1.273530e-07
I506 n1_m1_62400_254400 0 7.392381e-08
I507 n1_m1_62400_259200 0 1.260286e-07
I508 n1_m1_62400_264000 0 1.512429e-07
I509 n1_m1_62400_268800 0 2.189197e-07
I510 n1_m1_62400_273600 0 2.056612e-07
I511 n1_m1_62400_278400 0 2.670238e-07
I512 n1_m1_62400_283200 0 1.470177e-07
I513 n1_m1_62400_288000 0 2.996776e-07
I514 n1_m1_62400_292800 0 3.801548e-07
I515 n1_m1_62400_297600 0 6.369452e-07
I516 n1_m1_62400_302400 0 1.404887e-07
I517 n1_m1_62400_307200 0 6.947619e-08
I518 n1_m1_62400_312000 0 3.143429e-07
I519 n1_m1_62400_316800 0 6.183832e-07
I520 n1_m1_62400_321600 0 9.351048e-07
I521 n1_m1_62400_326400 0 2.006857e-07
I522 n1_m1_62400_331200 0 4.414286e-07
I523 n1_m1_62400_336000 0 2.960857e-07
I524 n1_m1_62400_350400 0 2.498571e-08
I525 n1_m1_62400_355200 0 1.011143e-07
I526 n1_m1_62400_360000 0 9.716667e-08
I527 n1_m1_62400_364800 0 1.034929e-07
I528 n1_m1_62400_369600 0 1.356179e-07
I529 n1_m1_62400_374400 0 1.821429e-08
I530 n1_m1_62400_379200 0 2.809524e-08
I531 n1_m1_62400_384000 0 8.356667e-08
I532 n1_m1_62400_388800 0 5.662143e-08
I533 n1_m1_62400_393600 0 8.919643e-08
I534 n1_m1_62400_398400 0 1.356452e-07
I535 n1_m1_62400_403200 0 1.447000e-07
I536 n1_m1_62400_408000 0 2.365107e-07
I537 n1_m1_62400_412800 0 6.867143e-08
I538 n1_m1_62400_417600 0 7.797500e-08
I539 n1_m1_62400_422400 0 7.647857e-08
I540 n1_m1_62400_427200 0 4.123571e-07
I541 n1_m1_62400_432000 0 1.279571e-06
I542 n1_m1_62400_436800 0 6.477143e-08
I543 n1_m1_62400_441600 0 6.141429e-08
I544 n1_m1_62400_460800 0 2.485714e-08
I545 n1_m1_62400_465600 0 7.444286e-08
I546 n1_m1_67200_4800 0 1.975385e-08
I547 n1_m1_67200_9600 0 3.257949e-08
I548 n1_m1_67200_148800 0 7.942857e-08
I549 n1_m1_67200_153600 0 2.607000e-07
I550 n1_m1_67200_158400 0 1.449467e-07
I551 n1_m1_67200_163200 0 7.615143e-08
I552 n1_m1_67200_168000 0 2.810571e-07
I553 n1_m1_67200_172800 0 7.354286e-08
I554 n1_m1_67200_177600 0 1.803667e-07
I555 n1_m1_67200_182400 0 5.859000e-08
I556 n1_m1_67200_187200 0 1.329771e-07
I557 n1_m1_67200_192000 0 4.644286e-08
I558 n1_m1_67200_196800 0 1.530214e-07
I559 n1_m1_67200_201600 0 3.938286e-07
I560 n1_m1_67200_206400 0 1.728500e-07
I561 n1_m1_67200_211200 0 1.019905e-07
I562 n1_m1_67200_216000 0 8.176667e-08
I563 n1_m1_67200_220800 0 1.325095e-07
I564 n1_m1_67200_225600 0 4.861429e-08
I565 n1_m1_67200_230400 0 7.628571e-08
I566 n1_m1_67200_235200 0 4.716667e-08
I567 n1_m1_67200_240000 0 1.720929e-07
I568 n1_m1_67200_244800 0 6.015714e-08
I569 n1_m1_67200_249600 0 4.610000e-08
I570 n1_m1_67200_254400 0 5.642381e-08
I571 n1_m1_67200_259200 0 1.114000e-07
I572 n1_m1_67200_264000 0 3.025310e-07
I573 n1_m1_67200_268800 0 2.292357e-07
I574 n1_m1_67200_273600 0 7.266190e-08
I575 n1_m1_67200_278400 0 1.203690e-07
I576 n1_m1_67200_283200 0 1.528119e-07
I577 n1_m1_67200_288000 0 3.325476e-07
I578 n1_m1_67200_292800 0 2.489762e-07
I579 n1_m1_67200_297600 0 2.009821e-07
I580 n1_m1_67200_302400 0 3.173024e-07
I581 n1_m1_67200_307200 0 4.638095e-07
I582 n1_m1_67200_312000 0 2.798000e-07
I583 n1_m1_67200_316800 0 1.172864e-06
I584 n1_m1_67200_321600 0 6.373571e-07
I585 n1_m1_67200_326400 0 2.247714e-07
I586 n1_m1_67200_331200 0 7.845406e-08
I587 n1_m1_67200_336000 0 9.002979e-07
I588 n1_m1_67200_340800 0 3.142857e-08
I589 n1_m1_67200_345600 0 1.735000e-08
I590 n1_m1_67200_350400 0 6.955357e-08
I591 n1_m1_67200_355200 0 2.697143e-08
I592 n1_m1_67200_360000 0 1.689833e-07
I593 n1_m1_67200_364800 0 6.428571e-08
I594 n1_m1_67200_369600 0 3.346619e-07
I595 n1_m1_67200_374400 0 3.873571e-08
I596 n1_m1_67200_379200 0 1.115929e-07
I597 n1_m1_67200_384000 0 1.985905e-07
I598 n1_m1_67200_388800 0 8.650000e-08
I599 n1_m1_67200_393600 0 2.889190e-07
I600 n1_m1_67200_398400 0 5.458333e-08
I601 n1_m1_67200_403200 0 2.011429e-08
I602 n1_m1_67200_408000 0 2.012179e-07
I603 n1_m1_67200_412800 0 1.796571e-07
I604 n1_m1_67200_417600 0 8.250714e-08
I605 n1_m1_67200_422400 0 1.140690e-07
I606 n1_m1_67200_427200 0 8.071429e-08
I607 n1_m1_67200_432000 0 2.983929e-07
I608 n1_m1_67200_436800 0 8.355714e-08
I609 n1_m1_67200_441600 0 1.850262e-07
I610 n1_m1_67200_465600 0 1.075000e-07
I611 n1_m1_72000_4800 0 7.901538e-09
I612 n1_m1_72000_9600 0 4.437559e-07
I613 n1_m1_72000_105600 0 1.803571e-08
I614 n1_m1_72000_110400 0 4.508929e-08
I615 n1_m1_72000_148800 0 7.285429e-08
I616 n1_m1_72000_153600 0 1.722629e-07
I617 n1_m1_72000_158400 0 1.471905e-07
I618 n1_m1_72000_163200 0 1.161486e-07
I619 n1_m1_72000_168000 0 3.052000e-07
I620 n1_m1_72000_172800 0 4.760000e-08
I621 n1_m1_72000_177600 0 1.468286e-07
I622 n1_m1_72000_182400 0 1.002986e-07
I623 n1_m1_72000_187200 0 2.566743e-07
I624 n1_m1_72000_192000 0 1.707571e-07
I625 n1_m1_72000_196800 0 2.336414e-07
I626 n1_m1_72000_201600 0 5.510990e-07
I627 n1_m1_72000_206400 0 2.457629e-07
I628 n1_m1_72000_211200 0 1.233000e-07
I629 n1_m1_72000_216000 0 1.956476e-07
I630 n1_m1_72000_220800 0 1.679190e-07
I631 n1_m1_72000_225600 0 1.554029e-07
I632 n1_m1_72000_230400 0 1.812743e-07
I633 n1_m1_72000_235200 0 1.224095e-07
I634 n1_m1_72000_240000 0 1.428357e-07
I635 n1_m1_72000_244800 0 1.975686e-07
I636 n1_m1_72000_249600 0 1.275800e-07
I637 n1_m1_72000_254400 0 1.258895e-07
I638 n1_m1_72000_259200 0 3.429600e-07
I639 n1_m1_72000_264000 0 3.732005e-07
I640 n1_m1_72000_268800 0 5.359476e-08
I641 n1_m1_72000_273600 0 1.974657e-07
I642 n1_m1_72000_278400 0 4.203929e-07
I643 n1_m1_72000_283200 0 4.447452e-07
I644 n1_m1_72000_288000 0 2.331095e-07
I645 n1_m1_72000_292800 0 2.975238e-07
I646 n1_m1_72000_297600 0 3.177036e-07
I647 n1_m1_72000_302400 0 9.211429e-07
I648 n1_m1_72000_307200 0 7.154762e-07
I649 n1_m1_72000_312000 0 5.589006e-07
I650 n1_m1_72000_316800 0 6.697003e-07
I651 n1_m1_72000_321600 0 3.043000e-07
I652 n1_m1_72000_326400 0 4.215714e-07
I653 n1_m1_72000_331200 0 8.351514e-07
I654 n1_m1_72000_336000 0 3.559593e-06
I655 n1_m1_72000_340800 0 4.880000e-07
I656 n1_m1_72000_345600 0 2.071500e-07
I657 n1_m1_72000_350400 0 1.541083e-07
I658 n1_m1_72000_355200 0 1.029347e-07
I659 n1_m1_72000_360000 0 1.632391e-07
I660 n1_m1_72000_364800 0 8.326429e-08
I661 n1_m1_72000_369600 0 1.543067e-07
I662 n1_m1_72000_374400 0 1.085157e-07
I663 n1_m1_72000_379200 0 1.335119e-07
I664 n1_m1_72000_384000 0 1.509286e-07
I665 n1_m1_72000_388800 0 1.993429e-07
I666 n1_m1_72000_393600 0 1.611417e-07
I667 n1_m1_72000_398400 0 9.462857e-08
I668 n1_m1_72000_403200 0 1.249571e-07
I669 n1_m1_72000_408000 0 1.427571e-07
I670 n1_m1_72000_412800 0 2.611429e-07
I671 n1_m1_72000_417600 0 2.970571e-07
I672 n1_m1_72000_422400 0 1.869900e-07
I673 n1_m1_72000_427200 0 1.526571e-07
I674 n1_m1_72000_432000 0 3.699357e-07
I675 n1_m1_72000_436800 0 1.563051e-07
I676 n1_m1_72000_441600 0 4.369901e-07
I677 n1_m1_72000_446400 0 1.885714e-08
I678 n1_m1_72000_561600 0 7.828571e-07
I679 n1_m1_72000_566400 0 4.697143e-06
I680 n1_m1_76800_4800 0 1.185231e-08
I681 n1_m1_76800_9600 0 8.147569e-07
I682 n1_m1_76800_105600 0 1.803571e-07
I683 n1_m1_76800_110400 0 4.508929e-07
I684 n1_m1_76800_148800 0 5.578000e-08
I685 n1_m1_76800_153600 0 1.696229e-07
I686 n1_m1_76800_158400 0 9.292571e-08
I687 n1_m1_76800_163200 0 2.152000e-08
I688 n1_m1_76800_168000 0 2.194371e-07
I689 n1_m1_76800_172800 0 1.686857e-07
I690 n1_m1_76800_177600 0 6.815714e-08
I691 n1_m1_76800_182400 0 4.481143e-08
I692 n1_m1_76800_187200 0 2.208914e-07
I693 n1_m1_76800_192000 0 4.847714e-08
I694 n1_m1_76800_196800 0 1.383514e-07
I695 n1_m1_76800_201600 0 1.210010e-07
I696 n1_m1_76800_206400 0 4.379429e-08
I697 n1_m1_76800_211200 0 1.224571e-07
I698 n1_m1_76800_216000 0 1.761000e-07
I699 n1_m1_76800_220800 0 1.441429e-07
I700 n1_m1_76800_225600 0 1.955686e-07
I701 n1_m1_76800_230400 0 3.204686e-07
I702 n1_m1_76800_235200 0 8.172952e-08
I703 n1_m1_76800_240000 0 1.950571e-07
I704 n1_m1_76800_244800 0 2.519600e-07
I705 n1_m1_76800_249600 0 1.435914e-07
I706 n1_m1_76800_254400 0 2.579143e-08
I707 n1_m1_76800_259200 0 1.169429e-07
I708 n1_m1_76800_264000 0 1.819267e-07
I709 n1_m1_76800_268800 0 3.661238e-08
I710 n1_m1_76800_273600 0 2.208895e-07
I711 n1_m1_76800_278400 0 2.557095e-07
I712 n1_m1_76800_283200 0 2.607429e-07
I713 n1_m1_76800_288000 0 4.835286e-07
I714 n1_m1_76800_292800 0 5.251429e-07
I715 n1_m1_76800_297600 0 9.914286e-08
I716 n1_m1_76800_302400 0 2.414694e-07
I717 n1_m1_76800_307200 0 2.269116e-07
I718 n1_m1_76800_312000 0 1.227842e-06
I719 n1_m1_76800_316800 0 3.429256e-07
I720 n1_m1_76800_321600 0 8.049922e-07
I721 n1_m1_76800_326400 0 2.062971e-07
I722 n1_m1_76800_331200 0 5.544578e-07
I723 n1_m1_76800_336000 0 1.209660e-06
I724 n1_m1_76800_340800 0 7.491429e-07
I725 n1_m1_76800_345600 0 1.866571e-07
I726 n1_m1_76800_350400 0 1.587238e-07
I727 n1_m1_76800_355200 0 2.291796e-07
I728 n1_m1_76800_360000 0 2.239061e-07
I729 n1_m1_76800_364800 0 4.374857e-08
I730 n1_m1_76800_369600 0 6.033143e-08
I731 n1_m1_76800_374400 0 1.263800e-07
I732 n1_m1_76800_379200 0 5.384286e-08
I733 n1_m1_76800_384000 0 1.465000e-07
I734 n1_m1_76800_388800 0 5.625714e-08
I735 n1_m1_76800_393600 0 1.647114e-07
I736 n1_m1_76800_398400 0 6.668490e-08
I737 n1_m1_76800_403200 0 1.666694e-07
I738 n1_m1_76800_408000 0 1.898429e-07
I739 n1_m1_76800_412800 0 9.154286e-08
I740 n1_m1_76800_417600 0 8.544286e-08
I741 n1_m1_76800_422400 0 9.231714e-08
I742 n1_m1_76800_427200 0 8.737143e-08
I743 n1_m1_76800_432000 0 1.097143e-07
I744 n1_m1_76800_436800 0 3.930776e-08
I745 n1_m1_76800_441600 0 1.351751e-07
I746 n1_m1_81600_9600 0 1.550000e-07
I747 n1_m1_81600_105600 0 9.017857e-08
I748 n1_m1_81600_110400 0 2.254464e-07
I749 n1_m1_81600_134400 0 4.240000e-07
I750 n1_m1_81600_139200 0 6.375000e-07
I751 n1_m1_81600_144000 0 3.576000e-07
I752 n1_m1_81600_148800 0 1.901514e-07
I753 n1_m1_81600_153600 0 1.052500e-07
I754 n1_m1_81600_158400 0 1.373886e-07
I755 n1_m1_81600_163200 0 8.636952e-08
I756 n1_m1_81600_168000 0 2.165819e-07
I757 n1_m1_81600_172800 0 1.800034e-07
I758 n1_m1_81600_177600 0 3.389958e-07
I759 n1_m1_81600_182400 0 2.409214e-07
I760 n1_m1_81600_187200 0 1.652429e-07
I761 n1_m1_81600_192000 0 1.870157e-07
I762 n1_m1_81600_196800 0 2.062833e-07
I763 n1_m1_81600_201600 0 3.454500e-07
I764 n1_m1_81600_206400 0 1.073125e-07
I765 n1_m1_81600_211200 0 1.045000e-07
I766 n1_m1_81600_216000 0 2.221714e-07
I767 n1_m1_81600_220800 0 1.446119e-07
I768 n1_m1_81600_225600 0 5.753964e-07
I769 n1_m1_81600_230400 0 7.765476e-08
I770 n1_m1_81600_235200 0 1.334746e-07
I771 n1_m1_81600_240000 0 2.005714e-07
I772 n1_m1_81600_244800 0 6.771429e-08
I773 n1_m1_81600_249600 0 1.365548e-07
I774 n1_m1_81600_254400 0 1.071548e-07
I775 n1_m1_81600_259200 0 1.971448e-07
I776 n1_m1_81600_264000 0 2.990919e-07
I777 n1_m1_81600_268800 0 1.467048e-07
I778 n1_m1_81600_273600 0 3.611257e-07
I779 n1_m1_81600_278400 0 6.291714e-07
I780 n1_m1_81600_283200 0 5.941571e-07
I781 n1_m1_81600_288000 0 3.123381e-07
I782 n1_m1_81600_292800 0 8.116667e-08
I783 n1_m1_81600_297600 0 3.496857e-07
I784 n1_m1_81600_302400 0 4.451693e-07
I785 n1_m1_81600_307200 0 2.293265e-07
I786 n1_m1_81600_312000 0 5.693143e-07
I787 n1_m1_81600_316800 0 1.790980e-07
I788 n1_m1_81600_321600 0 1.997351e-06
I789 n1_m1_81600_326400 0 7.715314e-07
I790 n1_m1_81600_331200 0 1.742180e-06
I791 n1_m1_81600_336000 0 1.435306e-06
I792 n1_m1_81600_340800 0 1.050429e-06
I793 n1_m1_81600_345600 0 4.563333e-07
I794 n1_m1_81600_350400 0 1.019911e-07
I795 n1_m1_81600_355200 0 7.620000e-08
I796 n1_m1_81600_360000 0 2.774714e-07
I797 n1_m1_81600_364800 0 2.527109e-06
I798 n1_m1_81600_369600 0 1.825286e-07
I799 n1_m1_81600_374400 0 2.748829e-07
I800 n1_m1_81600_379200 0 1.468286e-07
I801 n1_m1_81600_384000 0 1.463095e-07
I802 n1_m1_81600_388800 0 1.616286e-07
I803 n1_m1_81600_393600 0 4.480648e-07
I804 n1_m1_81600_398400 0 1.683151e-07
I805 n1_m1_81600_403200 0 6.824020e-07
I806 n1_m1_81600_408000 0 3.383690e-07
I807 n1_m1_81600_412800 0 1.076143e-07
I808 n1_m1_81600_417600 0 2.588119e-07
I809 n1_m1_81600_422400 0 2.166821e-07
I810 n1_m1_81600_427200 0 1.315048e-07
I811 n1_m1_81600_432000 0 2.560214e-07
I812 n1_m1_81600_436800 0 1.779205e-07
I813 n1_m1_81600_441600 0 8.896943e-07
I814 n1_m1_86400_134400 0 8.500000e-08
I815 n1_m1_86400_139200 0 2.125000e-07
I816 n1_m1_86400_144000 0 2.100000e-07
I817 n1_m1_86400_148800 0 1.259543e-07
I818 n1_m1_86400_153600 0 2.435357e-07
I819 n1_m1_86400_158400 0 1.549388e-07
I820 n1_m1_86400_163200 0 8.238027e-08
I821 n1_m1_86400_168000 0 1.810095e-07
I822 n1_m1_86400_172800 0 1.996639e-07
I823 n1_m1_86400_177600 0 3.327731e-08
I824 n1_m1_86400_182400 0 4.735000e-08
I825 n1_m1_86400_187200 0 4.867143e-08
I826 n1_m1_86400_192000 0 3.026786e-07
I827 n1_m1_86400_196800 0 6.061667e-08
I828 n1_m1_86400_201600 0 1.185300e-07
I829 n1_m1_86400_206400 0 2.634750e-08
I830 n1_m1_86400_211200 0 9.434286e-08
I831 n1_m1_86400_216000 0 9.598095e-08
I832 n1_m1_86400_220800 0 7.344524e-08
I833 n1_m1_86400_225600 0 3.038988e-07
I834 n1_m1_86400_230400 0 4.995476e-08
I835 n1_m1_86400_235200 0 4.553393e-08
I836 n1_m1_86400_240000 0 2.322857e-08
I837 n1_m1_86400_244800 0 1.205714e-08
I838 n1_m1_86400_249600 0 3.695952e-08
I839 n1_m1_86400_254400 0 4.096429e-08
I840 n1_m1_86400_259200 0 9.720136e-08
I841 n1_m1_86400_264000 0 3.025340e-08
I842 n1_m1_86400_268800 0 1.428571e-08
I843 n1_m1_86400_273600 0 1.272143e-07
I844 n1_m1_86400_278400 0 6.592857e-07
I845 n1_m1_86400_283200 0 2.766429e-07
I846 n1_m1_86400_288000 0 1.386333e-07
I847 n1_m1_86400_292800 0 8.159864e-08
I848 n1_m1_86400_297600 0 7.946531e-08
I849 n1_m1_86400_302400 0 1.890379e-07
I850 n1_m1_86400_307200 0 4.685714e-08
I851 n1_m1_86400_312000 0 1.829429e-07
I852 n1_m1_86400_316800 0 7.609143e-08
I853 n1_m1_86400_321600 0 3.181143e-07
I854 n1_m1_86400_326400 0 1.005714e-08
I855 n1_m1_86400_331200 0 4.747937e-07
I856 n1_m1_86400_336000 0 1.564286e-07
I857 n1_m1_86400_340800 0 1.593429e-07
I858 n1_m1_86400_345600 0 2.582238e-07
I859 n1_m1_86400_350400 0 4.448036e-08
I860 n1_m1_86400_355200 0 1.052381e-08
I861 n1_m1_86400_360000 0 1.215000e-07
I862 n1_m1_86400_364800 0 3.940000e-07
I863 n1_m1_86400_369600 0 4.161224e-08
I864 n1_m1_86400_374400 0 9.305918e-08
I865 n1_m1_86400_379200 0 2.738776e-07
I866 n1_m1_86400_384000 0 2.588796e-07
I867 n1_m1_86400_388800 0 5.187143e-08
I868 n1_m1_86400_393600 0 5.260544e-09
I869 n1_m1_86400_398400 0 4.853469e-08
I870 n1_m1_86400_403200 0 1.272857e-08
I871 n1_m1_86400_408000 0 7.033595e-08
I872 n1_m1_86400_412800 0 4.555714e-08
I873 n1_m1_86400_417600 0 9.661381e-08
I874 n1_m1_86400_422400 0 5.324643e-08
I875 n1_m1_86400_427200 0 3.152381e-09
I876 n1_m1_86400_432000 0 1.334357e-07
I877 n1_m1_86400_436800 0 6.168810e-08
I878 n1_m1_86400_441600 0 5.785714e-08
I879 n1_m1_91200_4800 0 1.975385e-08
I880 n1_m1_91200_9600 0 8.796077e-07
I881 n1_m1_91200_139200 0 4.285714e-08
I882 n1_m1_91200_144000 0 7.908571e-08
I883 n1_m1_91200_148800 0 9.806905e-08
I884 n1_m1_91200_153600 0 2.835143e-07
I885 n1_m1_91200_158400 0 6.092857e-08
I886 n1_m1_91200_163200 0 1.184881e-07
I887 n1_m1_91200_168000 0 1.886095e-07
I888 n1_m1_91200_172800 0 5.767347e-08
I889 n1_m1_91200_177600 0 9.482653e-08
I890 n1_m1_91200_182400 0 2.834786e-07
I891 n1_m1_91200_187200 0 1.951238e-07
I892 n1_m1_91200_192000 0 2.251254e-07
I893 n1_m1_91200_196800 0 2.368429e-07
I894 n1_m1_91200_201600 0 1.294943e-06
I895 n1_m1_91200_206400 0 1.916143e-07
I896 n1_m1_91200_211200 0 1.392000e-07
I897 n1_m1_91200_216000 0 1.313143e-07
I898 n1_m1_91200_220800 0 6.975238e-08
I899 n1_m1_91200_225600 0 2.829786e-07
I900 n1_m1_91200_230400 0 1.179810e-07
I901 n1_m1_91200_235200 0 1.248071e-07
I902 n1_m1_91200_240000 0 6.155429e-07
I903 n1_m1_91200_244800 0 1.401714e-07
I904 n1_m1_91200_249600 0 8.218571e-08
I905 n1_m1_91200_254400 0 6.168810e-08
I906 n1_m1_91200_259200 0 6.357143e-08
I907 n1_m1_91200_264000 0 1.797571e-07
I908 n1_m1_91200_268800 0 3.028571e-07
I909 n1_m1_91200_273600 0 1.462857e-07
I910 n1_m1_91200_278400 0 1.591429e-07
I911 n1_m1_91200_283200 0 9.218071e-08
I912 n1_m1_91200_288000 0 9.866286e-08
I913 n1_m1_91200_292800 0 2.128571e-07
I914 n1_m1_91200_297600 0 1.171143e-07
I915 n1_m1_91200_302400 0 1.061776e-06
I916 n1_m1_91200_307200 0 1.926536e-06
I917 n1_m1_91200_312000 0 3.604452e-07
I918 n1_m1_91200_316800 0 1.937778e-07
I919 n1_m1_91200_321600 0 6.175633e-07
I920 n1_m1_91200_326400 0 5.288101e-07
I921 n1_m1_91200_331200 0 8.833020e-07
I922 n1_m1_91200_336000 0 1.022413e-06
I923 n1_m1_91200_340800 0 1.810714e-07
I924 n1_m1_91200_345600 0 2.643881e-07
I925 n1_m1_91200_350400 0 6.207143e-08
I926 n1_m1_91200_355200 0 3.820000e-08
I927 n1_m1_91200_360000 0 9.612857e-08
I928 n1_m1_91200_364800 0 1.110548e-07
I929 n1_m1_91200_369600 0 7.984762e-08
I930 n1_m1_91200_374400 0 1.279214e-07
I931 n1_m1_91200_379200 0 1.184714e-07
I932 n1_m1_91200_384000 0 1.618589e-07
I933 n1_m1_91200_388800 0 7.846905e-07
I934 n1_m1_91200_393600 0 3.930088e-07
I935 n1_m1_91200_398400 0 7.862418e-08
I936 n1_m1_91200_403200 0 4.420357e-08
I937 n1_m1_91200_408000 0 1.070119e-07
I938 n1_m1_91200_412800 0 2.070714e-07
I939 n1_m1_91200_417600 0 1.338667e-07
I940 n1_m1_91200_422400 0 2.088762e-07
I941 n1_m1_91200_427200 0 1.046952e-07
I942 n1_m1_91200_432000 0 1.620976e-07
I943 n1_m1_91200_436800 0 2.790905e-07
I944 n1_m1_91200_441600 0 1.201571e-07
I945 n1_m1_91200_446400 0 2.350000e-08
I946 n1_m1_91200_542400 0 1.740000e-08
I947 n1_m1_91200_585600 0 2.140000e-08
I948 n1_m1_96000_4800 0 1.975385e-08
I949 n1_m1_96000_9600 0 3.514462e-07
I950 n1_m1_96000_144000 0 5.627929e-07
I951 n1_m1_96000_148800 0 1.648619e-07
I952 n1_m1_96000_153600 0 2.012833e-07
I953 n1_m1_96000_158400 0 3.096143e-07
I954 n1_m1_96000_163200 0 1.102786e-07
I955 n1_m1_96000_168000 0 4.062286e-07
I956 n1_m1_96000_172800 0 1.650082e-07
I957 n1_m1_96000_177600 0 2.076752e-07
I958 n1_m1_96000_182400 0 1.185714e-06
I959 n1_m1_96000_187200 0 5.013905e-07
I960 n1_m1_96000_192000 0 2.083675e-07
I961 n1_m1_96000_196800 0 2.947857e-07
I962 n1_m1_96000_201600 0 3.089429e-07
I963 n1_m1_96000_206400 0 1.102571e-06
I964 n1_m1_96000_211200 0 6.600714e-08
I965 n1_m1_96000_216000 0 5.294345e-07
I966 n1_m1_96000_220800 0 6.920000e-08
I967 n1_m1_96000_225600 0 1.780071e-07
I968 n1_m1_96000_230400 0 1.960571e-07
I969 n1_m1_96000_235200 0 1.307357e-07
I970 n1_m1_96000_240000 0 1.109046e-06
I971 n1_m1_96000_244800 0 9.319714e-07
I972 n1_m1_96000_249600 0 1.665357e-07
I973 n1_m1_96000_254400 0 7.570714e-08
I974 n1_m1_96000_259200 0 1.232286e-07
I975 n1_m1_96000_264000 0 1.076310e-07
I976 n1_m1_96000_268800 0 9.713810e-08
I977 n1_m1_96000_273600 0 1.434619e-07
I978 n1_m1_96000_278400 0 1.184048e-07
I979 n1_m1_96000_283200 0 2.082405e-07
I980 n1_m1_96000_288000 0 3.575571e-07
I981 n1_m1_96000_292800 0 7.434580e-07
I982 n1_m1_96000_297600 0 2.999261e-07
I983 n1_m1_96000_302400 0 7.851214e-07
I984 n1_m1_96000_307200 0 1.842583e-06
I985 n1_m1_96000_312000 0 9.713333e-07
I986 n1_m1_96000_316800 0 1.155365e-06
I987 n1_m1_96000_321600 0 3.232674e-06
I988 n1_m1_96000_326400 0 1.147317e-06
I989 n1_m1_96000_331200 0 1.358818e-06
I990 n1_m1_96000_336000 0 7.838810e-07
I991 n1_m1_96000_340800 0 1.437000e-07
I992 n1_m1_96000_345600 0 2.619929e-07
I993 n1_m1_96000_350400 0 1.741286e-07
I994 n1_m1_96000_355200 0 8.691429e-08
I995 n1_m1_96000_360000 0 1.943071e-07
I996 n1_m1_96000_364800 0 2.361179e-07
I997 n1_m1_96000_369600 0 4.123952e-07
I998 n1_m1_96000_374400 0 1.688679e-06
I999 n1_m1_96000_379200 0 2.106250e-07
I1000 n1_m1_96000_384000 0 3.208911e-07
I1001 n1_m1_96000_388800 0 4.142423e-07
I1002 n1_m1_96000_393600 0 4.319619e-07
I1003 n1_m1_96000_398400 0 2.270000e-07
I1004 n1_m1_96000_403200 0 1.979964e-07
I1005 n1_m1_96000_408000 0 1.342571e-07
I1006 n1_m1_96000_412800 0 1.132429e-07
I1007 n1_m1_96000_417600 0 1.874458e-07
I1008 n1_m1_96000_422400 0 1.827440e-07
I1009 n1_m1_96000_427200 0 1.661333e-07
I1010 n1_m1_96000_432000 0 1.812875e-07
I1011 n1_m1_96000_436800 0 1.615583e-07
I1012 n1_m1_96000_441600 0 3.530476e-07
I1013 n1_m1_96000_446400 0 1.843333e-07
I1014 n1_m1_96000_580800 0 2.633846e-07
I1015 n1_m1_96000_585600 0 1.681821e-07
I1016 n1_m1_100800_14400 0 1.524000e-07
I1017 n1_m1_100800_96000 0 3.733214e-07
I1018 n1_m1_100800_100800 0 1.139286e-07
I1019 n1_m1_100800_144000 0 7.048332e-07
I1020 n1_m1_100800_148800 0 1.434929e-07
I1021 n1_m1_100800_153600 0 8.663139e-07
I1022 n1_m1_100800_158400 0 2.709143e-07
I1023 n1_m1_100800_163200 0 1.210000e-07
I1024 n1_m1_100800_168000 0 4.323571e-07
I1025 n1_m1_100800_172800 0 5.927184e-07
I1026 n1_m1_100800_177600 0 1.133554e-07
I1027 n1_m1_100800_182400 0 1.660286e-07
I1028 n1_m1_100800_187200 0 6.257143e-08
I1029 n1_m1_100800_192000 0 1.337500e-07
I1030 n1_m1_100800_196800 0 5.464286e-08
I1031 n1_m1_100800_201600 0 1.269571e-07
I1032 n1_m1_100800_206400 0 1.041333e-07
I1033 n1_m1_100800_211200 0 4.677857e-08
I1034 n1_m1_100800_216000 0 2.435131e-07
I1035 n1_m1_100800_220800 0 1.628500e-07
I1036 n1_m1_100800_225600 0 4.692857e-08
I1037 n1_m1_100800_230400 0 8.311429e-08
I1038 n1_m1_100800_235200 0 9.435714e-08
I1039 n1_m1_100800_240000 0 4.672369e-07
I1040 n1_m1_100800_244800 0 3.765714e-07
I1041 n1_m1_100800_249600 0 9.014881e-07
I1042 n1_m1_100800_254400 0 3.554095e-07
I1043 n1_m1_100800_259200 0 3.560286e-07
I1044 n1_m1_100800_264000 0 3.624119e-07
I1045 n1_m1_100800_268800 0 6.360905e-07
I1046 n1_m1_100800_273600 0 3.005667e-07
I1047 n1_m1_100800_278400 0 4.494881e-07
I1048 n1_m1_100800_283200 0 1.811310e-07
I1049 n1_m1_100800_288000 0 5.152952e-07
I1050 n1_m1_100800_292800 0 7.028992e-07
I1051 n1_m1_100800_297600 0 1.150017e-06
I1052 n1_m1_100800_302400 0 2.330929e-07
I1053 n1_m1_100800_307200 0 7.822024e-07
I1054 n1_m1_100800_312000 0 9.048571e-07
I1055 n1_m1_100800_316800 0 7.239048e-07
I1056 n1_m1_100800_321600 0 8.784916e-07
I1057 n1_m1_100800_326400 0 1.015759e-06
I1058 n1_m1_100800_331200 0 7.402129e-07
I1059 n1_m1_100800_336000 0 1.201333e-06
I1060 n1_m1_100800_340800 0 3.102714e-07
I1061 n1_m1_100800_345600 0 2.006500e-07
I1062 n1_m1_100800_350400 0 9.682857e-08
I1063 n1_m1_100800_355200 0 5.825714e-08
I1064 n1_m1_100800_360000 0 8.976429e-08
I1065 n1_m1_100800_364800 0 6.123214e-08
I1066 n1_m1_100800_369600 0 9.372857e-08
I1067 n1_m1_100800_374400 0 1.826571e-07
I1068 n1_m1_100800_379200 0 2.406750e-07
I1069 n1_m1_100800_384000 0 1.479500e-07
I1070 n1_m1_100800_388800 0 6.492917e-08
I1071 n1_m1_100800_393600 0 1.924512e-07
I1072 n1_m1_100800_398400 0 1.691643e-07
I1073 n1_m1_100800_403200 0 9.084286e-08
I1074 n1_m1_100800_408000 0 1.844833e-07
I1075 n1_m1_100800_412800 0 2.214857e-07
I1076 n1_m1_100800_417600 0 4.156208e-07
I1077 n1_m1_100800_422400 0 1.194226e-07
I1078 n1_m1_100800_427200 0 4.219048e-08
I1079 n1_m1_100800_432000 0 1.353625e-07
I1080 n1_m1_100800_436800 0 9.649405e-08
I1081 n1_m1_100800_441600 0 2.357190e-07
I1082 n1_m1_100800_446400 0 2.277857e-07
I1083 n1_m1_100800_451200 0 5.295238e-08
I1084 n1_m1_100800_576000 0 5.163750e-07
I1085 n1_m1_100800_580800 0 5.333333e-07
I1086 n1_m1_100800_585600 0 3.511667e-07
I1087 n1_m1_105600_14400 0 1.016000e-07
I1088 n1_m1_105600_43200 0 2.852308e-06
I1089 n1_m1_105600_48000 0 3.327692e-06
I1090 n1_m1_105600_96000 0 7.268214e-07
I1091 n1_m1_105600_100800 0 2.789286e-07
I1092 n1_m1_105600_139200 0 1.788889e-06
I1093 n1_m1_105600_144000 0 2.767332e-06
I1094 n1_m1_105600_148800 0 3.365304e-07
I1095 n1_m1_105600_153600 0 9.619288e-07
I1096 n1_m1_105600_158400 0 4.079849e-07
I1097 n1_m1_105600_163200 0 2.325218e-07
I1098 n1_m1_105600_168000 0 1.310230e-06
I1099 n1_m1_105600_172800 0 8.265429e-07
I1100 n1_m1_105600_177600 0 5.868571e-07
I1101 n1_m1_105600_182400 0 2.750714e-07
I1102 n1_m1_105600_187200 0 1.122286e-07
I1103 n1_m1_105600_192000 0 2.346875e-07
I1104 n1_m1_105600_196800 0 1.697286e-07
I1105 n1_m1_105600_201600 0 1.913102e-07
I1106 n1_m1_105600_206400 0 2.161707e-07
I1107 n1_m1_105600_211200 0 2.843000e-07
I1108 n1_m1_105600_216000 0 3.979505e-07
I1109 n1_m1_105600_220800 0 1.633929e-07
I1110 n1_m1_105600_225600 0 5.546429e-07
I1111 n1_m1_105600_230400 0 3.308857e-07
I1112 n1_m1_105600_235200 0 2.431714e-07
I1113 n1_m1_105600_240000 0 5.589586e-07
I1114 n1_m1_105600_244800 0 6.385714e-07
I1115 n1_m1_105600_249600 0 2.644929e-06
I1116 n1_m1_105600_254400 0 2.084252e-06
I1117 n1_m1_105600_259200 0 1.749143e-06
I1118 n1_m1_105600_264000 0 2.624333e-06
I1119 n1_m1_105600_268800 0 5.200114e-06
I1120 n1_m1_105600_273600 0 1.021729e-06
I1121 n1_m1_105600_278400 0 1.337464e-06
I1122 n1_m1_105600_283200 0 3.149000e-06
I1123 n1_m1_105600_288000 0 3.982190e-06
I1124 n1_m1_105600_292800 0 3.716429e-06
I1125 n1_m1_105600_297600 0 2.859600e-06
I1126 n1_m1_105600_302400 0 1.067619e-06
I1127 n1_m1_105600_307200 0 3.980952e-07
I1128 n1_m1_105600_312000 0 2.138277e-06
I1129 n1_m1_105600_316800 0 1.401280e-06
I1130 n1_m1_105600_321600 0 2.400083e-06
I1131 n1_m1_105600_326400 0 1.684615e-06
I1132 n1_m1_105600_331200 0 7.855485e-07
I1133 n1_m1_105600_336000 0 3.977000e-06
I1134 n1_m1_105600_340800 0 5.997214e-07
I1135 n1_m1_105600_345600 0 1.290964e-07
I1136 n1_m1_105600_350400 0 1.515143e-07
I1137 n1_m1_105600_355200 0 1.141224e-07
I1138 n1_m1_105600_360000 0 2.064061e-07
I1139 n1_m1_105600_364800 0 6.359571e-07
I1140 n1_m1_105600_369600 0 7.359619e-07
I1141 n1_m1_105600_374400 0 5.080000e-07
I1142 n1_m1_105600_379200 0 3.998857e-07
I1143 n1_m1_105600_384000 0 3.996857e-07
I1144 n1_m1_105600_388800 0 2.275000e-07
I1145 n1_m1_105600_393600 0 3.418393e-07
I1146 n1_m1_105600_398400 0 2.686235e-07
I1147 n1_m1_105600_403200 0 2.004408e-07
I1148 n1_m1_105600_408000 0 2.108362e-07
I1149 n1_m1_105600_412800 0 1.237906e-07
I1150 n1_m1_105600_417600 0 9.031768e-07
I1151 n1_m1_105600_422400 0 5.826112e-07
I1152 n1_m1_105600_427200 0 2.428177e-07
I1153 n1_m1_105600_432000 0 1.879714e-07
I1154 n1_m1_105600_436800 0 2.242476e-07
I1155 n1_m1_105600_441600 0 4.539476e-07
I1156 n1_m1_105600_446400 0 1.223810e-07
I1157 n1_m1_105600_451200 0 2.647619e-08
I1158 n1_m1_105600_518400 0 2.334066e-08
I1159 n1_m1_105600_523200 0 3.868772e-07
I1160 n1_m1_105600_528000 0 5.994107e-08
I1161 n1_m1_105600_576000 0 4.556250e-07
I1162 n1_m1_105600_580800 0 5.340793e-07
I1163 n1_m1_105600_585600 0 3.862195e-07
I1164 n1_m1_110400_139200 0 7.282540e-07
I1165 n1_m1_110400_144000 0 1.986831e-06
I1166 n1_m1_110400_148800 0 7.204351e-07
I1167 n1_m1_110400_153600 0 6.779808e-07
I1168 n1_m1_110400_158400 0 9.946723e-07
I1169 n1_m1_110400_163200 0 8.510772e-07
I1170 n1_m1_110400_168000 0 1.638127e-07
I1171 n1_m1_110400_172800 0 3.843429e-07
I1172 n1_m1_110400_177600 0 1.455571e-07
I1173 n1_m1_110400_182400 0 1.872286e-07
I1174 n1_m1_110400_187200 0 1.333714e-07
I1175 n1_m1_110400_192000 0 9.251250e-08
I1176 n1_m1_110400_196800 0 1.211143e-07
I1177 n1_m1_110400_201600 0 2.204327e-07
I1178 n1_m1_110400_206400 0 6.971020e-08
I1179 n1_m1_110400_211200 0 3.704971e-07
I1180 n1_m1_110400_216000 0 9.330286e-08
I1181 n1_m1_110400_220800 0 7.550000e-08
I1182 n1_m1_110400_225600 0 1.270600e-06
I1183 n1_m1_110400_230400 0 6.668571e-08
I1184 n1_m1_110400_235200 0 8.215143e-07
I1185 n1_m1_110400_240000 0 7.683867e-07
I1186 n1_m1_110400_244800 0 2.987714e-06
I1187 n1_m1_110400_249600 0 1.955282e-06
I1188 n1_m1_110400_254400 0 1.871918e-06
I1189 n1_m1_110400_259200 0 2.445714e-07
I1190 n1_m1_110400_264000 0 1.390381e-06
I1191 n1_m1_110400_268800 0 8.342571e-07
I1192 n1_m1_110400_273600 0 1.417257e-06
I1193 n1_m1_110400_278400 0 6.510000e-07
I1194 n1_m1_110400_283200 0 1.926257e-06
I1195 n1_m1_110400_288000 0 1.625353e-06
I1196 n1_m1_110400_292800 0 3.028571e-07
I1197 n1_m1_110400_297600 0 4.817067e-06
I1198 n1_m1_110400_302400 0 1.274683e-06
I1199 n1_m1_110400_307200 0 1.171667e-06
I1200 n1_m1_110400_312000 0 1.249437e-06
I1201 n1_m1_110400_316800 0 1.284942e-06
I1202 n1_m1_110400_321600 0 1.445977e-06
I1203 n1_m1_110400_326400 0 1.249900e-06
I1204 n1_m1_110400_331200 0 1.392773e-06
I1205 n1_m1_110400_336000 0 2.775429e-06
I1206 n1_m1_110400_340800 0 3.124700e-07
I1207 n1_m1_110400_345600 0 1.069445e-06
I1208 n1_m1_110400_350400 0 4.571000e-07
I1209 n1_m1_110400_355200 0 9.470612e-08
I1210 n1_m1_110400_360000 0 1.413939e-07
I1211 n1_m1_110400_364800 0 1.202000e-07
I1212 n1_m1_110400_369600 0 2.921143e-07
I1213 n1_m1_110400_374400 0 1.933000e-07
I1214 n1_m1_110400_379200 0 1.243714e-07
I1215 n1_m1_110400_384000 0 2.534857e-07
I1216 n1_m1_110400_388800 0 1.822714e-07
I1217 n1_m1_110400_393600 0 1.420000e-07
I1218 n1_m1_110400_398400 0 2.310694e-07
I1219 n1_m1_110400_403200 0 9.130204e-08
I1220 n1_m1_110400_408000 0 1.543551e-07
I1221 n1_m1_110400_412800 0 2.332829e-07
I1222 n1_m1_110400_417600 0 4.387681e-07
I1223 n1_m1_110400_422400 0 4.739956e-07
I1224 n1_m1_110400_427200 0 9.767755e-08
I1225 n1_m1_110400_432000 0 7.367143e-08
I1226 n1_m1_110400_436800 0 2.710114e-07
I1227 n1_m1_110400_441600 0 2.489020e-06
I1228 n1_m1_110400_446400 0 7.142857e-07
I1229 n1_m1_110400_518400 0 7.481319e-08
I1230 n1_m1_110400_523200 0 7.140678e-07
I1231 n1_m1_110400_528000 0 1.044643e-07
I1232 n1_m1_110400_580800 0 3.208951e-07
I1233 n1_m1_110400_585600 0 2.416394e-07
I1234 n1_m1_115200_144000 0 8.471866e-07
I1235 n1_m1_115200_148800 0 4.675731e-07
I1236 n1_m1_115200_153600 0 8.219863e-08
I1237 n1_m1_115200_158400 0 1.413929e-07
I1238 n1_m1_115200_163200 0 1.125129e-07
I1239 n1_m1_115200_168000 0 4.512619e-08
I1240 n1_m1_115200_172800 0 6.535357e-08
I1241 n1_m1_115200_177600 0 4.687500e-09
I1242 n1_m1_115200_182400 0 1.276262e-06
I1243 n1_m1_115200_187200 0 1.628571e-06
I1244 n1_m1_115200_192000 0 4.275000e-08
I1245 n1_m1_115200_196800 0 2.897143e-08
I1246 n1_m1_115200_201600 0 2.280571e-07
I1247 n1_m1_115200_206400 0 1.126714e-07
I1248 n1_m1_115200_211200 0 1.947124e-07
I1249 n1_m1_115200_216000 0 2.190776e-07
I1250 n1_m1_115200_220800 0 7.936250e-08
I1251 n1_m1_115200_225600 0 3.806214e-07
I1252 n1_m1_115200_230400 0 6.431429e-08
I1253 n1_m1_115200_235200 0 4.747679e-08
I1254 n1_m1_115200_240000 0 3.010357e-07
I1255 n1_m1_115200_244800 0 1.249714e-06
I1256 n1_m1_115200_249600 0 7.881224e-07
I1257 n1_m1_115200_254400 0 1.620175e-06
I1258 n1_m1_115200_259200 0 2.448095e-06
I1259 n1_m1_115200_264000 0 1.527000e-06
I1260 n1_m1_115200_268800 0 8.761038e-07
I1261 n1_m1_115200_273600 0 1.336051e-06
I1262 n1_m1_115200_278400 0 6.459643e-07
I1263 n1_m1_115200_283200 0 2.583857e-07
I1264 n1_m1_115200_288000 0 4.391228e-07
I1265 n1_m1_115200_292800 0 3.028571e-07
I1266 n1_m1_115200_297600 0 9.687619e-07
I1267 n1_m1_115200_302400 0 5.544841e-07
I1268 n1_m1_115200_307200 0 7.261905e-07
I1269 n1_m1_115200_312000 0 1.339286e-06
I1270 n1_m1_115200_316800 0 1.986633e-07
I1271 n1_m1_115200_321600 0 4.851111e-07
I1272 n1_m1_115200_326400 0 6.542857e-07
I1273 n1_m1_115200_331200 0 1.199143e-06
I1274 n1_m1_115200_336000 0 1.520286e-06
I1275 n1_m1_115200_340800 0 2.362229e-07
I1276 n1_m1_115200_345600 0 2.466645e-07
I1277 n1_m1_115200_350400 0 6.220000e-08
I1278 n1_m1_115200_355200 0 3.831429e-08
I1279 n1_m1_115200_360000 0 6.134286e-08
I1280 n1_m1_115200_364800 0 2.707143e-08
I1281 n1_m1_115200_369600 0 8.877619e-08
I1282 n1_m1_115200_374400 0 4.326071e-08
I1283 n1_m1_115200_379200 0 2.956250e-08
I1284 n1_m1_115200_384000 0 7.277798e-08
I1285 n1_m1_115200_388800 0 5.107619e-08
I1286 n1_m1_115200_393600 0 3.155589e-07
I1287 n1_m1_115200_398400 0 4.018214e-08
I1288 n1_m1_115200_403200 0 4.197143e-08
I1289 n1_m1_115200_408000 0 2.064385e-07
I1290 n1_m1_115200_412800 0 2.699082e-08
I1291 n1_m1_115200_417600 0 3.373370e-07
I1292 n1_m1_115200_422400 0 1.526711e-07
I1293 n1_m1_115200_427200 0 6.500000e-08
I1294 n1_m1_115200_432000 0 1.154250e-07
I1295 n1_m1_115200_436800 0 7.257429e-08
I1296 n1_m1_115200_441600 0 2.611481e-06
I1297 n1_m1_115200_465600 0 8.357143e-08
I1298 n1_m1_115200_470400 0 1.392857e-08
I1299 n1_m1_115200_518400 0 2.184615e-08
I1300 n1_m1_115200_523200 0 5.682647e-08
I1301 n1_m1_115200_528000 0 5.223214e-09
I1302 n1_m1_115200_585600 0 3.060000e-08
I1303 n1_m1_120000_4800 0 5.960000e-08
I1304 n1_m1_120000_9600 0 6.168417e-07
I1305 n1_m1_120000_14400 0 5.613750e-07
I1306 n1_m1_120000_24000 0 8.738000e-07
I1307 n1_m1_120000_67200 0 4.584375e-07
I1308 n1_m1_120000_144000 0 5.531000e-07
I1309 n1_m1_120000_148800 0 1.364193e-07
I1310 n1_m1_120000_153600 0 3.190983e-07
I1311 n1_m1_120000_158400 0 1.539143e-07
I1312 n1_m1_120000_163200 0 7.897143e-08
I1313 n1_m1_120000_168000 0 3.390857e-07
I1314 n1_m1_120000_172800 0 6.133095e-08
I1315 n1_m1_120000_177600 0 2.586143e-07
I1316 n1_m1_120000_182400 0 1.626238e-07
I1317 n1_m1_120000_187200 0 2.221714e-07
I1318 n1_m1_120000_192000 0 1.800964e-07
I1319 n1_m1_120000_196800 0 1.389464e-07
I1320 n1_m1_120000_201600 0 1.960381e-07
I1321 n1_m1_120000_206400 0 2.890714e-08
I1322 n1_m1_120000_211200 0 6.669762e-08
I1323 n1_m1_120000_216000 0 8.511905e-08
I1324 n1_m1_120000_220800 0 5.926667e-08
I1325 n1_m1_120000_225600 0 2.468929e-07
I1326 n1_m1_120000_230400 0 2.164571e-07
I1327 n1_m1_120000_235200 0 2.157000e-07
I1328 n1_m1_120000_240000 0 1.145286e-06
I1329 n1_m1_120000_244800 0 2.247857e-06
I1330 n1_m1_120000_249600 0 1.625940e-06
I1331 n1_m1_120000_254400 0 2.383476e-06
I1332 n1_m1_120000_259200 0 2.478000e-06
I1333 n1_m1_120000_264000 0 5.473143e-06
I1334 n1_m1_120000_268800 0 3.664619e-06
I1335 n1_m1_120000_273600 0 2.664424e-06
I1336 n1_m1_120000_278400 0 1.977845e-06
I1337 n1_m1_120000_283200 0 2.015288e-06
I1338 n1_m1_120000_288000 0 3.629714e-06
I1339 n1_m1_120000_292800 0 2.627976e-06
I1340 n1_m1_120000_297600 0 2.879405e-06
I1341 n1_m1_120000_302400 0 2.709286e-06
I1342 n1_m1_120000_307200 0 1.418214e-06
I1343 n1_m1_120000_312000 0 9.019004e-07
I1344 n1_m1_120000_316800 0 1.714698e-06
I1345 n1_m1_120000_321600 0 1.373672e-06
I1346 n1_m1_120000_326400 0 1.179802e-06
I1347 n1_m1_120000_331200 0 3.803720e-06
I1348 n1_m1_120000_336000 0 1.874181e-06
I1349 n1_m1_120000_340800 0 1.009143e-06
I1350 n1_m1_120000_345600 0 2.458500e-07
I1351 n1_m1_120000_350400 0 1.076696e-07
I1352 n1_m1_120000_355200 0 5.157143e-08
I1353 n1_m1_120000_360000 0 1.397714e-07
I1354 n1_m1_120000_364800 0 7.668286e-07
I1355 n1_m1_120000_369600 0 3.922857e-07
I1356 n1_m1_120000_374400 0 1.433357e-07
I1357 n1_m1_120000_379200 0 2.707238e-07
I1358 n1_m1_120000_384000 0 1.495137e-07
I1359 n1_m1_120000_388800 0 2.641667e-08
I1360 n1_m1_120000_393600 0 9.688304e-07
I1361 n1_m1_120000_398400 0 2.937393e-07
I1362 n1_m1_120000_403200 0 2.457929e-07
I1363 n1_m1_120000_408000 0 1.476786e-07
I1364 n1_m1_120000_412800 0 1.745619e-07
I1365 n1_m1_120000_417600 0 7.571345e-07
I1366 n1_m1_120000_422400 0 3.535259e-07
I1367 n1_m1_120000_427200 0 1.083619e-07
I1368 n1_m1_120000_432000 0 1.929857e-07
I1369 n1_m1_120000_436800 0 1.382476e-07
I1370 n1_m1_120000_441600 0 1.630000e-07
I1371 n1_m1_120000_504000 0 4.985000e-07
I1372 n1_m1_120000_576000 0 1.661538e-08
I1373 n1_m1_120000_580800 0 6.296068e-07
I1374 n1_m1_120000_585600 0 3.525966e-07
I1375 n1_m1_124800_4800 0 4.356923e-08
I1376 n1_m1_124800_9600 0 3.707558e-07
I1377 n1_m1_124800_14400 0 4.366250e-07
I1378 n1_m1_124800_24000 0 7.800000e-07
I1379 n1_m1_124800_120000 0 1.950000e-07
I1380 n1_m1_124800_139200 0 2.164286e-07
I1381 n1_m1_124800_144000 0 1.510311e-06
I1382 n1_m1_124800_148800 0 7.634958e-07
I1383 n1_m1_124800_153600 0 1.788452e-06
I1384 n1_m1_124800_158400 0 4.452857e-07
I1385 n1_m1_124800_163200 0 2.579365e-07
I1386 n1_m1_124800_168000 0 6.981746e-07
I1387 n1_m1_124800_172800 0 2.901619e-07
I1388 n1_m1_124800_177600 0 2.855679e-07
I1389 n1_m1_124800_182400 0 1.348857e-07
I1390 n1_m1_124800_187200 0 5.849143e-07
I1391 n1_m1_124800_192000 0 1.892000e-07
I1392 n1_m1_124800_196800 0 1.386250e-07
I1393 n1_m1_124800_201600 0 1.816048e-07
I1394 n1_m1_124800_206400 0 1.183702e-07
I1395 n1_m1_124800_211200 0 2.580595e-07
I1396 n1_m1_124800_216000 0 5.559238e-07
I1397 n1_m1_124800_220800 0 1.099000e-07
I1398 n1_m1_124800_225600 0 6.064000e-07
I1399 n1_m1_124800_230400 0 2.061429e-07
I1400 n1_m1_124800_235200 0 1.289571e-07
I1401 n1_m1_124800_240000 0 1.008857e-06
I1402 n1_m1_124800_244800 0 1.854429e-06
I1403 n1_m1_124800_249600 0 4.957060e-06
I1404 n1_m1_124800_254400 0 2.575238e-06
I1405 n1_m1_124800_259200 0 2.782476e-06
I1406 n1_m1_124800_264000 0 2.739429e-06
I1407 n1_m1_124800_268800 0 3.374810e-06
I1408 n1_m1_124800_273600 0 2.932806e-06
I1409 n1_m1_124800_278400 0 3.457703e-06
I1410 n1_m1_124800_283200 0 2.684832e-06
I1411 n1_m1_124800_288000 0 2.936195e-06
I1412 n1_m1_124800_292800 0 2.572262e-06
I1413 n1_m1_124800_297600 0 1.299333e-06
I1414 n1_m1_124800_302400 0 1.818048e-06
I1415 n1_m1_124800_307200 0 2.702500e-06
I1416 n1_m1_124800_312000 0 2.005623e-06
I1417 n1_m1_124800_316800 0 2.350794e-06
I1418 n1_m1_124800_321600 0 4.131424e-06
I1419 n1_m1_124800_326400 0 7.452786e-07
I1420 n1_m1_124800_331200 0 1.264408e-06
I1421 n1_m1_124800_336000 0 2.181353e-06
I1422 n1_m1_124800_340800 0 1.428000e-06
I1423 n1_m1_124800_345600 0 5.481905e-07
I1424 n1_m1_124800_350400 0 2.939542e-07
I1425 n1_m1_124800_355200 0 4.900000e-08
I1426 n1_m1_124800_360000 0 1.686667e-07
I1427 n1_m1_124800_364800 0 1.047986e-06
I1428 n1_m1_124800_369600 0 5.815143e-07
I1429 n1_m1_124800_374400 0 2.442500e-07
I1430 n1_m1_124800_379200 0 5.551429e-08
I1431 n1_m1_124800_384000 0 1.740244e-07
I1432 n1_m1_124800_388800 0 3.808738e-07
I1433 n1_m1_124800_393600 0 1.856054e-07
I1434 n1_m1_124800_398400 0 4.848321e-07
I1435 n1_m1_124800_403200 0 8.185000e-08
I1436 n1_m1_124800_408000 0 2.288071e-07
I1437 n1_m1_124800_412800 0 5.806700e-07
I1438 n1_m1_124800_417600 0 1.657202e-06
I1439 n1_m1_124800_422400 0 3.211947e-07
I1440 n1_m1_124800_427200 0 1.037143e-07
I1441 n1_m1_124800_432000 0 1.789464e-07
I1442 n1_m1_124800_436800 0 2.202881e-07
I1443 n1_m1_124800_441600 0 3.566429e-07
I1444 n1_m1_124800_460800 0 1.164286e-07
I1445 n1_m1_124800_465600 0 1.953214e-07
I1446 n1_m1_124800_504000 0 4.985000e-07
I1447 n1_m1_124800_576000 0 1.104762e-09
I1448 n1_m1_124800_580800 0 3.775687e-07
I1449 n1_m1_124800_585600 0 2.318376e-07
I1450 n1_m1_129600_4800 0 4.661538e-08
I1451 n1_m1_129600_9600 0 3.884615e-09
I1452 n1_m1_129600_120000 0 8.450000e-07
I1453 n1_m1_129600_134400 0 1.854286e-07
I1454 n1_m1_129600_139200 0 1.656849e-06
I1455 n1_m1_129600_144000 0 1.837966e-06
I1456 n1_m1_129600_148800 0 1.547111e-06
I1457 n1_m1_129600_153600 0 1.385945e-06
I1458 n1_m1_129600_158400 0 9.715714e-07
I1459 n1_m1_129600_163200 0 1.056131e-06
I1460 n1_m1_129600_168000 0 1.359240e-06
I1461 n1_m1_129600_172800 0 2.800286e-07
I1462 n1_m1_129600_177600 0 2.720857e-07
I1463 n1_m1_129600_182400 0 1.914429e-07
I1464 n1_m1_129600_187200 0 9.171429e-08
I1465 n1_m1_129600_192000 0 1.937429e-07
I1466 n1_m1_129600_196800 0 1.540429e-07
I1467 n1_m1_129600_201600 0 7.497286e-07
I1468 n1_m1_129600_206400 0 5.295369e-07
I1469 n1_m1_129600_211200 0 5.528571e-08
I1470 n1_m1_129600_216000 0 4.032857e-07
I1471 n1_m1_129600_220800 0 1.558286e-07
I1472 n1_m1_129600_225600 0 7.410286e-07
I1473 n1_m1_129600_230400 0 9.582857e-08
I1474 n1_m1_129600_235200 0 2.997429e-07
I1475 n1_m1_129600_240000 0 1.068000e-06
I1476 n1_m1_129600_244800 0 2.233347e-06
I1477 n1_m1_129600_249600 0 3.617224e-06
I1478 n1_m1_129600_254400 0 4.693714e-06
I1479 n1_m1_129600_259200 0 4.831810e-06
I1480 n1_m1_129600_264000 0 7.882582e-06
I1481 n1_m1_129600_268800 0 2.569000e-06
I1482 n1_m1_129600_273600 0 1.337961e-06
I1483 n1_m1_129600_278400 0 2.633024e-06
I1484 n1_m1_129600_283200 0 2.818930e-06
I1485 n1_m1_129600_288000 0 5.151805e-06
I1486 n1_m1_129600_292800 0 4.750476e-06
I1487 n1_m1_129600_297600 0 2.867619e-06
I1488 n1_m1_129600_302400 0 3.395238e-06
I1489 n1_m1_129600_307200 0 4.141429e-06
I1490 n1_m1_129600_312000 0 2.734833e-06
I1491 n1_m1_129600_316800 0 1.504917e-06
I1492 n1_m1_129600_321600 0 1.280903e-06
I1493 n1_m1_129600_326400 0 8.954903e-07
I1494 n1_m1_129600_331200 0 1.274794e-06
I1495 n1_m1_129600_336000 0 2.997222e-06
I1496 n1_m1_129600_340800 0 2.372095e-06
I1497 n1_m1_129600_345600 0 1.209883e-06
I1498 n1_m1_129600_350400 0 2.598905e-07
I1499 n1_m1_129600_355200 0 2.040571e-07
I1500 n1_m1_129600_360000 0 7.157622e-07
I1501 n1_m1_129600_364800 0 3.341454e-07
I1502 n1_m1_129600_369600 0 3.296429e-07
I1503 n1_m1_129600_374400 0 8.860000e-07
I1504 n1_m1_129600_379200 0 2.883571e-07
I1505 n1_m1_129600_384000 0 4.764952e-07
I1506 n1_m1_129600_388800 0 2.706810e-07
I1507 n1_m1_129600_393600 0 3.287143e-07
I1508 n1_m1_129600_398400 0 1.250038e-06
I1509 n1_m1_129600_403200 0 4.543476e-07
I1510 n1_m1_129600_408000 0 9.702471e-07
I1511 n1_m1_129600_412800 0 3.000157e-07
I1512 n1_m1_129600_417600 0 1.554566e-06
I1513 n1_m1_129600_422400 0 4.399672e-07
I1514 n1_m1_129600_427200 0 1.630857e-07
I1515 n1_m1_129600_432000 0 3.105821e-07
I1516 n1_m1_129600_436800 0 2.083714e-07
I1517 n1_m1_129600_460800 0 1.221429e-07
I1518 n1_m1_129600_465600 0 1.090107e-06
I1519 n1_m1_129600_561600 0 1.392000e-08
I1520 n1_m1_129600_576000 0 3.866667e-09
I1521 n1_m1_129600_580800 0 2.320000e-08
I1522 n1_m1_129600_585600 0 8.586667e-08
I1523 n1_m1_134400_4800 0 3.292308e-09
I1524 n1_m1_134400_9600 0 4.852744e-07
I1525 n1_m1_134400_43200 0 4.818462e-09
I1526 n1_m1_134400_48000 0 5.621538e-09
I1527 n1_m1_134400_139200 0 6.331513e-07
I1528 n1_m1_134400_144000 0 1.991664e-06
I1529 n1_m1_134400_148800 0 1.150969e-06
I1530 n1_m1_134400_153600 0 1.929735e-06
I1531 n1_m1_134400_158400 0 7.701412e-07
I1532 n1_m1_134400_163200 0 3.572471e-07
I1533 n1_m1_134400_168000 0 4.806393e-07
I1534 n1_m1_134400_172800 0 1.406000e-07
I1535 n1_m1_134400_177600 0 2.647357e-07
I1536 n1_m1_134400_182400 0 8.215952e-08
I1537 n1_m1_134400_187200 0 3.951429e-08
I1538 n1_m1_134400_192000 0 7.944286e-08
I1539 n1_m1_134400_196800 0 1.512857e-07
I1540 n1_m1_134400_201600 0 5.255143e-07
I1541 n1_m1_134400_206400 0 1.770000e-07
I1542 n1_m1_134400_211200 0 1.160357e-07
I1543 n1_m1_134400_216000 0 1.046857e-07
I1544 n1_m1_134400_220800 0 3.910786e-07
I1545 n1_m1_134400_225600 0 3.057310e-07
I1546 n1_m1_134400_230400 0 1.732286e-07
I1547 n1_m1_134400_235200 0 2.868571e-07
I1548 n1_m1_134400_240000 0 1.296548e-06
I1549 n1_m1_134400_244800 0 3.749224e-06
I1550 n1_m1_134400_249600 0 3.623994e-06
I1551 n1_m1_134400_254400 0 1.679952e-06
I1552 n1_m1_134400_259200 0 2.782857e-06
I1553 n1_m1_134400_264000 0 3.155989e-06
I1554 n1_m1_134400_268800 0 2.196714e-06
I1555 n1_m1_134400_273600 0 1.657429e-06
I1556 n1_m1_134400_278400 0 9.870130e-07
I1557 n1_m1_134400_283200 0 9.567851e-07
I1558 n1_m1_134400_288000 0 1.492398e-06
I1559 n1_m1_134400_292800 0 2.276353e-06
I1560 n1_m1_134400_297600 0 1.933605e-06
I1561 n1_m1_134400_302400 0 1.760107e-06
I1562 n1_m1_134400_307200 0 2.388571e-06
I1563 n1_m1_134400_312000 0 2.285452e-06
I1564 n1_m1_134400_316800 0 2.207988e-06
I1565 n1_m1_134400_321600 0 2.026429e-06
I1566 n1_m1_134400_326400 0 1.881250e-06
I1567 n1_m1_134400_331200 0 2.057970e-06
I1568 n1_m1_134400_336000 0 2.255095e-06
I1569 n1_m1_134400_340800 0 2.076286e-06
I1570 n1_m1_134400_345600 0 2.814270e-07
I1571 n1_m1_134400_350400 0 5.987679e-08
I1572 n1_m1_134400_355200 0 7.955000e-08
I1573 n1_m1_134400_360000 0 1.209368e-06
I1574 n1_m1_134400_364800 0 7.592423e-07
I1575 n1_m1_134400_369600 0 2.500328e-07
I1576 n1_m1_134400_374400 0 7.890238e-08
I1577 n1_m1_134400_379200 0 9.310238e-08
I1578 n1_m1_134400_384000 0 7.158095e-08
I1579 n1_m1_134400_388800 0 7.840000e-08
I1580 n1_m1_134400_393600 0 3.779622e-07
I1581 n1_m1_134400_398400 0 7.319350e-07
I1582 n1_m1_134400_403200 0 2.090381e-07
I1583 n1_m1_134400_408000 0 1.476079e-06
I1584 n1_m1_134400_412800 0 1.474190e-07
I1585 n1_m1_134400_417600 0 8.287496e-07
I1586 n1_m1_134400_422400 0 1.505572e-06
I1587 n1_m1_134400_427200 0 1.099714e-07
I1588 n1_m1_134400_432000 0 1.021857e-07
I1589 n1_m1_134400_436800 0 8.791429e-08
I1590 n1_m1_134400_561600 0 2.088000e-08
I1591 n1_m1_134400_585600 0 7.133333e-09
I1592 n1_m1_139200_4800 0 6.003077e-08
I1593 n1_m1_139200_9600 0 4.900026e-07
I1594 n1_m1_139200_14400 0 1.255714e-07
I1595 n1_m1_139200_19200 0 1.674286e-07
I1596 n1_m1_139200_24000 0 1.169600e-07
I1597 n1_m1_139200_43200 0 1.124308e-08
I1598 n1_m1_139200_48000 0 1.311692e-08
I1599 n1_m1_139200_139200 0 8.293651e-07
I1600 n1_m1_139200_144000 0 1.959376e-06
I1601 n1_m1_139200_148800 0 1.148057e-06
I1602 n1_m1_139200_153600 0 1.257059e-06
I1603 n1_m1_139200_158400 0 3.366151e-07
I1604 n1_m1_139200_163200 0 1.806300e-07
I1605 n1_m1_139200_168000 0 4.175512e-07
I1606 n1_m1_139200_172800 0 1.615429e-07
I1607 n1_m1_139200_177600 0 1.786357e-07
I1608 n1_m1_139200_182400 0 1.059976e-07
I1609 n1_m1_139200_187200 0 9.042857e-08
I1610 n1_m1_139200_192000 0 2.089071e-07
I1611 n1_m1_139200_196800 0 1.399429e-07
I1612 n1_m1_139200_201600 0 1.360714e-07
I1613 n1_m1_139200_206400 0 1.281857e-07
I1614 n1_m1_139200_211200 0 8.849643e-08
I1615 n1_m1_139200_216000 0 1.488571e-07
I1616 n1_m1_139200_220800 0 2.012214e-07
I1617 n1_m1_139200_225600 0 2.091690e-07
I1618 n1_m1_139200_230400 0 3.460571e-07
I1619 n1_m1_139200_235200 0 6.535924e-07
I1620 n1_m1_139200_240000 0 8.170397e-07
I1621 n1_m1_139200_244800 0 1.908286e-06
I1622 n1_m1_139200_249600 0 1.986496e-06
I1623 n1_m1_139200_254400 0 1.141048e-06
I1624 n1_m1_139200_259200 0 1.705429e-06
I1625 n1_m1_139200_264000 0 3.592857e-06
I1626 n1_m1_139200_268800 0 1.430000e-06
I1627 n1_m1_139200_273600 0 2.323143e-06
I1628 n1_m1_139200_278400 0 1.172273e-06
I1629 n1_m1_139200_283200 0 1.163715e-06
I1630 n1_m1_139200_288000 0 1.528982e-06
I1631 n1_m1_139200_292800 0 5.561466e-07
I1632 n1_m1_139200_297600 0 2.620966e-06
I1633 n1_m1_139200_302400 0 4.156071e-07
I1634 n1_m1_139200_307200 0 1.338571e-06
I1635 n1_m1_139200_312000 0 2.220000e-07
I1636 n1_m1_139200_316800 0 9.755238e-07
I1637 n1_m1_139200_321600 0 3.064143e-06
I1638 n1_m1_139200_326400 0 1.955893e-06
I1639 n1_m1_139200_331200 0 6.648393e-07
I1640 n1_m1_139200_336000 0 3.459905e-06
I1641 n1_m1_139200_340800 0 1.345238e-06
I1642 n1_m1_139200_345600 0 2.920000e-06
I1643 n1_m1_139200_350400 0 1.518089e-07
I1644 n1_m1_139200_355200 0 1.037229e-06
I1645 n1_m1_139200_360000 0 1.544423e-06
I1646 n1_m1_139200_364800 0 1.064467e-06
I1647 n1_m1_139200_369600 0 1.206940e-06
I1648 n1_m1_139200_374400 0 9.070476e-08
I1649 n1_m1_139200_379200 0 1.466762e-07
I1650 n1_m1_139200_384000 0 5.290905e-07
I1651 n1_m1_139200_388800 0 8.280000e-07
I1652 n1_m1_139200_393600 0 6.274235e-07
I1653 n1_m1_139200_398400 0 5.483317e-07
I1654 n1_m1_139200_403200 0 5.575429e-07
I1655 n1_m1_139200_408000 0 7.376674e-07
I1656 n1_m1_139200_412800 0 1.239048e-07
I1657 n1_m1_139200_417600 0 1.308408e-06
I1658 n1_m1_139200_422400 0 1.533160e-06
I1659 n1_m1_139200_427200 0 1.207361e-06
I1660 n1_m1_139200_432000 0 9.928655e-08
I1661 n1_m1_139200_585600 0 2.140000e-08
I1662 n1_m1_144000_14400 0 2.880000e-07
I1663 n1_m1_144000_24000 0 5.504000e-08
I1664 n1_m1_144000_115200 0 2.665714e-08
I1665 n1_m1_144000_120000 0 1.599429e-07
I1666 n1_m1_144000_129600 0 8.460000e-09
I1667 n1_m1_144000_139200 0 7.420635e-07
I1668 n1_m1_144000_144000 0 4.011349e-06
I1669 n1_m1_144000_148800 0 1.398405e-06
I1670 n1_m1_144000_153600 0 3.265336e-06
I1671 n1_m1_144000_158400 0 1.608471e-06
I1672 n1_m1_144000_163200 0 1.343337e-06
I1673 n1_m1_144000_168000 0 6.508944e-07
I1674 n1_m1_144000_172800 0 1.950551e-07
I1675 n1_m1_144000_177600 0 4.127548e-07
I1676 n1_m1_144000_182400 0 1.901166e-06
I1677 n1_m1_144000_187200 0 8.935429e-08
I1678 n1_m1_144000_192000 0 2.250500e-07
I1679 n1_m1_144000_196800 0 3.427143e-08
I1680 n1_m1_144000_201600 0 1.823286e-07
I1681 n1_m1_144000_206400 0 1.828286e-07
I1682 n1_m1_144000_211200 0 1.957345e-07
I1683 n1_m1_144000_216000 0 8.133394e-07
I1684 n1_m1_144000_220800 0 5.807714e-08
I1685 n1_m1_144000_225600 0 4.883957e-06
I1686 n1_m1_144000_230400 0 8.317143e-08
I1687 n1_m1_144000_235200 0 2.011075e-06
I1688 n1_m1_144000_240000 0 4.928743e-06
I1689 n1_m1_144000_244800 0 2.158457e-06
I1690 n1_m1_144000_249600 0 1.377000e-06
I1691 n1_m1_144000_254400 0 2.019000e-06
I1692 n1_m1_144000_259200 0 3.879714e-06
I1693 n1_m1_144000_264000 0 5.228518e-06
I1694 n1_m1_144000_268800 0 2.201429e-06
I1695 n1_m1_144000_273600 0 4.564143e-06
I1696 n1_m1_144000_278400 0 2.812143e-06
I1697 n1_m1_144000_283200 0 3.938292e-06
I1698 n1_m1_144000_288000 0 4.710917e-06
I1699 n1_m1_144000_292800 0 3.576071e-06
I1700 n1_m1_144000_297600 0 4.463429e-06
I1701 n1_m1_144000_302400 0 2.127114e-06
I1702 n1_m1_144000_307200 0 2.674571e-06
I1703 n1_m1_144000_312000 0 4.276114e-06
I1704 n1_m1_144000_316800 0 3.412257e-06
I1705 n1_m1_144000_321600 0 4.730114e-06
I1706 n1_m1_144000_326400 0 2.951771e-06
I1707 n1_m1_144000_331200 0 2.481449e-06
I1708 n1_m1_144000_336000 0 4.935551e-06
I1709 n1_m1_144000_340800 0 3.440095e-06
I1710 n1_m1_144000_345600 0 3.037286e-06
I1711 n1_m1_144000_350400 0 1.203557e-06
I1712 n1_m1_144000_355200 0 8.189617e-07
I1713 n1_m1_144000_360000 0 2.516659e-06
I1714 n1_m1_144000_364800 0 2.044106e-06
I1715 n1_m1_144000_369600 0 1.692303e-06
I1716 n1_m1_144000_374400 0 4.455214e-07
I1717 n1_m1_144000_379200 0 1.756929e-07
I1718 n1_m1_144000_384000 0 1.101743e-06
I1719 n1_m1_144000_388800 0 6.005429e-07
I1720 n1_m1_144000_393600 0 3.177286e-07
I1721 n1_m1_144000_398400 0 4.216095e-07
I1722 n1_m1_144000_403200 0 1.414457e-06
I1723 n1_m1_144000_408000 0 2.024781e-06
I1724 n1_m1_144000_412800 0 1.162914e-06
I1725 n1_m1_144000_417600 0 3.489753e-06
I1726 n1_m1_144000_422400 0 2.335809e-06
I1727 n1_m1_144000_427200 0 2.376067e-06
I1728 n1_m1_144000_432000 0 7.546134e-07
I1729 n1_m1_144000_580800 0 3.505154e-07
I1730 n1_m1_144000_585600 0 2.190721e-07
I1731 n1_m1_148800_4800 0 1.975385e-08
I1732 n1_m1_148800_9600 0 1.904615e-08
I1733 n1_m1_148800_115200 0 2.212286e-07
I1734 n1_m1_148800_120000 0 3.008914e-07
I1735 n1_m1_148800_124800 0 9.507143e-08
I1736 n1_m1_148800_129600 0 1.667971e-07
I1737 n1_m1_148800_134400 0 3.865571e-07
I1738 n1_m1_148800_139200 0 2.319524e-06
I1739 n1_m1_148800_144000 0 1.649000e-06
I1740 n1_m1_148800_148800 0 6.085714e-08
I1741 n1_m1_148800_153600 0 1.872449e-06
I1742 n1_m1_148800_158400 0 9.773445e-07
I1743 n1_m1_148800_163200 0 6.038185e-07
I1744 n1_m1_148800_168000 0 1.348722e-07
I1745 n1_m1_148800_172800 0 6.534490e-08
I1746 n1_m1_148800_177600 0 4.391738e-07
I1747 n1_m1_148800_182400 0 9.533429e-08
I1748 n1_m1_148800_187200 0 1.576457e-07
I1749 n1_m1_148800_192000 0 5.071000e-07
I1750 n1_m1_148800_196800 0 1.231143e-07
I1751 n1_m1_148800_201600 0 6.167306e-07
I1752 n1_m1_148800_206400 0 5.207551e-07
I1753 n1_m1_148800_211200 0 3.375048e-07
I1754 n1_m1_148800_216000 0 3.530463e-07
I1755 n1_m1_148800_220800 0 2.242286e-08
I1756 n1_m1_148800_225600 0 4.820257e-07
I1757 n1_m1_148800_230400 0 5.418571e-07
I1758 n1_m1_148800_235200 0 3.557183e-07
I1759 n1_m1_148800_240000 0 1.362384e-06
I1760 n1_m1_148800_244800 0 1.329829e-06
I1761 n1_m1_148800_249600 0 1.707214e-06
I1762 n1_m1_148800_254400 0 4.010143e-06
I1763 n1_m1_148800_259200 0 2.481429e-06
I1764 n1_m1_148800_264000 0 1.877339e-06
I1765 n1_m1_148800_268800 0 1.605429e-06
I1766 n1_m1_148800_273600 0 2.667714e-06
I1767 n1_m1_148800_278400 0 2.016948e-06
I1768 n1_m1_148800_283200 0 9.724634e-07
I1769 n1_m1_148800_288000 0 4.529881e-07
I1770 n1_m1_148800_292800 0 1.001429e-06
I1771 n1_m1_148800_297600 0 2.711714e-06
I1772 n1_m1_148800_302400 0 2.401171e-06
I1773 n1_m1_148800_307200 0 1.929714e-06
I1774 n1_m1_148800_312000 0 1.932743e-06
I1775 n1_m1_148800_316800 0 1.834886e-06
I1776 n1_m1_148800_321600 0 2.979845e-06
I1777 n1_m1_148800_326400 0 3.330841e-06
I1778 n1_m1_148800_331200 0 2.733361e-06
I1779 n1_m1_148800_336000 0 3.632990e-06
I1780 n1_m1_148800_340800 0 1.258150e-06
I1781 n1_m1_148800_345600 0 2.165492e-06
I1782 n1_m1_148800_350400 0 8.240952e-07
I1783 n1_m1_148800_355200 0 1.240710e-06
I1784 n1_m1_148800_360000 0 1.172605e-06
I1785 n1_m1_148800_364800 0 1.058168e-06
I1786 n1_m1_148800_369600 0 2.123675e-06
I1787 n1_m1_148800_374400 0 7.625294e-07
I1788 n1_m1_148800_379200 0 5.091587e-07
I1789 n1_m1_148800_384000 0 1.124451e-06
I1790 n1_m1_148800_388800 0 2.387286e-07
I1791 n1_m1_148800_393600 0 9.085143e-08
I1792 n1_m1_148800_403200 0 1.232000e-07
I1793 n1_m1_148800_408000 0 7.479714e-08
I1794 n1_m1_148800_412800 0 4.174286e-08
I1795 n1_m1_148800_417600 0 1.551508e-06
I1796 n1_m1_148800_422400 0 1.296721e-06
I1797 n1_m1_148800_427200 0 1.085714e-06
I1798 n1_m1_148800_432000 0 8.142857e-07
I1799 n1_m1_148800_580800 0 3.030385e-07
I1800 n1_m1_148800_585600 0 2.403990e-07
I1801 n1_m1_153600_4800 0 1.079631e-07
I1802 n1_m1_153600_9600 0 8.996923e-09
I1803 n1_m1_153600_100800 0 9.481429e-08
I1804 n1_m1_153600_105600 0 1.734952e-07
I1805 n1_m1_153600_110400 0 2.613810e-07
I1806 n1_m1_153600_115200 0 1.841429e-07
I1807 n1_m1_153600_120000 0 3.697657e-07
I1808 n1_m1_153600_124800 0 1.841905e-07
I1809 n1_m1_153600_129600 0 1.296905e-07
I1810 n1_m1_153600_134400 0 1.972952e-07
I1811 n1_m1_153600_139200 0 1.620357e-07
I1812 n1_m1_153600_144000 0 5.635476e-07
I1813 n1_m1_153600_148800 0 5.827714e-07
I1814 n1_m1_153600_153600 0 1.181341e-06
I1815 n1_m1_153600_158400 0 1.692286e-07
I1816 n1_m1_153600_163200 0 8.744286e-08
I1817 n1_m1_153600_168000 0 1.721429e-07
I1818 n1_m1_153600_172800 0 3.128571e-07
I1819 n1_m1_153600_177600 0 2.737132e-06
I1820 n1_m1_153600_182400 0 8.620000e-07
I1821 n1_m1_153600_192000 0 8.580000e-08
I1822 n1_m1_153600_196800 0 7.643233e-07
I1823 n1_m1_153600_201600 0 1.725184e-06
I1824 n1_m1_153600_206400 0 4.307959e-06
I1825 n1_m1_153600_211200 0 3.900000e-07
I1826 n1_m1_153600_216000 0 1.672429e-07
I1827 n1_m1_153600_220800 0 4.682381e-08
I1828 n1_m1_153600_225600 0 5.785743e-07
I1829 n1_m1_153600_230400 0 4.114286e-07
I1830 n1_m1_153600_235200 0 8.521571e-07
I1831 n1_m1_153600_240000 0 1.916450e-06
I1832 n1_m1_153600_244800 0 7.006286e-07
I1833 n1_m1_153600_249600 0 1.027129e-06
I1834 n1_m1_153600_254400 0 4.175714e-06
I1835 n1_m1_153600_259200 0 4.472571e-06
I1836 n1_m1_153600_264000 0 2.656750e-06
I1837 n1_m1_153600_268800 0 2.245405e-06
I1838 n1_m1_153600_273600 0 5.060857e-06
I1839 n1_m1_153600_278400 0 1.414067e-05
I1840 n1_m1_153600_283200 0 6.162697e-06
I1841 n1_m1_153600_288000 0 4.014429e-06
I1842 n1_m1_153600_292800 0 3.347143e-06
I1843 n1_m1_153600_297600 0 2.787095e-06
I1844 n1_m1_153600_302400 0 4.482190e-06
I1845 n1_m1_153600_307200 0 3.124048e-06
I1846 n1_m1_153600_312000 0 3.181429e-06
I1847 n1_m1_153600_316800 0 2.272714e-06
I1848 n1_m1_153600_321600 0 2.867041e-06
I1849 n1_m1_153600_326400 0 1.867540e-06
I1850 n1_m1_153600_331200 0 1.831105e-06
I1851 n1_m1_153600_336000 0 1.769744e-06
I1852 n1_m1_153600_340800 0 1.097832e-06
I1853 n1_m1_153600_345600 0 1.998624e-06
I1854 n1_m1_153600_350400 0 1.832168e-06
I1855 n1_m1_153600_355200 0 1.042281e-06
I1856 n1_m1_153600_360000 0 1.546645e-06
I1857 n1_m1_153600_364800 0 1.574540e-06
I1858 n1_m1_153600_369600 0 2.960136e-06
I1859 n1_m1_153600_374400 0 6.212269e-07
I1860 n1_m1_153600_379200 0 2.253333e-06
I1861 n1_m1_153600_384000 0 2.416898e-06
I1862 n1_m1_153600_388800 0 7.705714e-08
I1863 n1_m1_153600_393600 0 2.207200e-07
I1864 n1_m1_153600_398400 0 1.418286e-07
I1865 n1_m1_153600_403200 0 2.439714e-07
I1866 n1_m1_153600_408000 0 4.219762e-07
I1867 n1_m1_153600_412800 0 1.693429e-07
I1868 n1_m1_153600_417600 0 5.436286e-07
I1869 n1_m1_153600_422400 0 2.169857e-07
I1870 n1_m1_153600_427200 0 4.031714e-07
I1871 n1_m1_153600_432000 0 3.871619e-07
I1872 n1_m1_153600_436800 0 7.727143e-08
I1873 n1_m1_153600_441600 0 2.307571e-07
I1874 n1_m1_153600_446400 0 7.004762e-08
I1875 n1_m1_153600_451200 0 1.565714e-08
I1876 n1_m1_153600_456000 0 2.493333e-08
I1877 n1_m1_153600_580800 0 5.596154e-07
I1878 n1_m1_153600_585600 0 3.992596e-07
I1879 n1_m1_158400_4800 0 5.080615e-08
I1880 n1_m1_158400_9600 0 5.661713e-07
I1881 n1_m1_158400_91200 0 1.528571e-08
I1882 n1_m1_158400_96000 0 9.605000e-08
I1883 n1_m1_158400_100800 0 7.507143e-08
I1884 n1_m1_158400_105600 0 9.369048e-08
I1885 n1_m1_158400_110400 0 1.691190e-07
I1886 n1_m1_158400_115200 0 1.202024e-07
I1887 n1_m1_158400_120000 0 1.382429e-07
I1888 n1_m1_158400_124800 0 1.050952e-07
I1889 n1_m1_158400_129600 0 1.040381e-07
I1890 n1_m1_158400_134400 0 1.781119e-07
I1891 n1_m1_158400_139200 0 3.583102e-07
I1892 n1_m1_158400_144000 0 1.199548e-06
I1893 n1_m1_158400_148800 0 5.650646e-07
I1894 n1_m1_158400_153600 0 1.684655e-06
I1895 n1_m1_158400_158400 0 7.412611e-07
I1896 n1_m1_158400_163200 0 3.886976e-07
I1897 n1_m1_158400_168000 0 2.457395e-06
I1898 n1_m1_158400_172800 0 2.272269e-06
I1899 n1_m1_158400_177600 0 1.406460e-06
I1900 n1_m1_158400_192000 0 7.935714e-07
I1901 n1_m1_158400_196800 0 7.871053e-07
I1902 n1_m1_158400_201600 0 5.513714e-07
I1903 n1_m1_158400_206400 0 8.032857e-08
I1904 n1_m1_158400_211200 0 1.474482e-07
I1905 n1_m1_158400_216000 0 1.365190e-07
I1906 n1_m1_158400_220800 0 8.117857e-08
I1907 n1_m1_158400_225600 0 2.642500e-07
I1908 n1_m1_158400_230400 0 5.502857e-07
I1909 n1_m1_158400_235200 0 8.487143e-07
I1910 n1_m1_158400_240000 0 6.770500e-07
I1911 n1_m1_158400_244800 0 1.698000e-07
I1912 n1_m1_158400_249600 0 1.769375e-07
I1913 n1_m1_158400_254400 0 1.486810e-06
I1914 n1_m1_158400_259200 0 3.112857e-06
I1915 n1_m1_158400_264000 0 2.255879e-06
I1916 n1_m1_158400_268800 0 2.720690e-06
I1917 n1_m1_158400_273600 0 3.437619e-06
I1918 n1_m1_158400_278400 0 2.955238e-06
I1919 n1_m1_158400_283200 0 2.903619e-06
I1920 n1_m1_158400_288000 0 2.775714e-06
I1921 n1_m1_158400_292800 0 2.119286e-06
I1922 n1_m1_158400_297600 0 3.767333e-06
I1923 n1_m1_158400_302400 0 2.112714e-06
I1924 n1_m1_158400_307200 0 1.383810e-06
I1925 n1_m1_158400_312000 0 2.880714e-06
I1926 n1_m1_158400_316800 0 1.896667e-06
I1927 n1_m1_158400_321600 0 5.309524e-07
I1928 n1_m1_158400_326400 0 1.224365e-06
I1929 n1_m1_158400_331200 0 1.598757e-06
I1930 n1_m1_158400_336000 0 6.258095e-07
I1931 n1_m1_158400_340800 0 1.389214e-06
I1932 n1_m1_158400_345600 0 1.875732e-06
I1933 n1_m1_158400_350400 0 5.678979e-07
I1934 n1_m1_158400_355200 0 4.825543e-07
I1935 n1_m1_158400_360000 0 1.850943e-06
I1936 n1_m1_158400_364800 0 2.030866e-06
I1937 n1_m1_158400_369600 0 1.051413e-06
I1938 n1_m1_158400_374400 0 9.608319e-07
I1939 n1_m1_158400_379200 0 1.040222e-06
I1940 n1_m1_158400_384000 0 1.057054e-06
I1941 n1_m1_158400_388800 0 1.492857e-07
I1942 n1_m1_158400_393600 0 2.545190e-07
I1943 n1_m1_158400_398400 0 8.771429e-08
I1944 n1_m1_158400_403200 0 1.337500e-07
I1945 n1_m1_158400_408000 0 2.282667e-07
I1946 n1_m1_158400_412800 0 1.537143e-08
I1947 n1_m1_158400_417600 0 1.189500e-07
I1948 n1_m1_158400_422400 0 9.341964e-08
I1949 n1_m1_158400_427200 0 2.881500e-07
I1950 n1_m1_158400_432000 0 2.605512e-07
I1951 n1_m1_158400_436800 0 5.009286e-08
I1952 n1_m1_158400_441600 0 1.243190e-07
I1953 n1_m1_158400_446400 0 4.689286e-08
I1954 n1_m1_158400_451200 0 1.009310e-07
I1955 n1_m1_158400_456000 0 1.358238e-07
I1956 n1_m1_158400_460800 0 6.378571e-08
I1957 n1_m1_158400_542400 0 5.890000e-06
I1958 n1_m1_163200_4800 0 6.600000e-08
I1959 n1_m1_163200_9600 0 4.425625e-07
I1960 n1_m1_163200_14400 0 7.457143e-09
I1961 n1_m1_163200_19200 0 9.942857e-09
I1962 n1_m1_163200_86400 0 1.093846e-08
I1963 n1_m1_163200_91200 0 1.882473e-07
I1964 n1_m1_163200_96000 0 2.312024e-07
I1965 n1_m1_163200_100800 0 1.252000e-07
I1966 n1_m1_163200_105600 0 7.671429e-08
I1967 n1_m1_163200_110400 0 1.103333e-07
I1968 n1_m1_163200_115200 0 3.596024e-07
I1969 n1_m1_163200_120000 0 2.908143e-07
I1970 n1_m1_163200_124800 0 1.130000e-07
I1971 n1_m1_163200_129600 0 1.796143e-07
I1972 n1_m1_163200_134400 0 1.732833e-07
I1973 n1_m1_163200_139200 0 2.334160e-07
I1974 n1_m1_163200_144000 0 4.980950e-07
I1975 n1_m1_163200_148800 0 4.388069e-07
I1976 n1_m1_163200_153600 0 1.138868e-06
I1977 n1_m1_163200_158400 0 1.784912e-07
I1978 n1_m1_163200_163200 0 3.081747e-07
I1979 n1_m1_163200_168000 0 2.539496e-06
I1980 n1_m1_163200_172800 0 9.131933e-07
I1981 n1_m1_163200_177600 0 2.367622e-06
I1982 n1_m1_163200_192000 0 1.402168e-06
I1983 n1_m1_163200_196800 0 1.554857e-07
I1984 n1_m1_163200_201600 0 2.184762e-07
I1985 n1_m1_163200_206400 0 1.724714e-07
I1986 n1_m1_163200_211200 0 7.862321e-08
I1987 n1_m1_163200_216000 0 1.421667e-07
I1988 n1_m1_163200_220800 0 7.259762e-08
I1989 n1_m1_163200_225600 0 4.026167e-07
I1990 n1_m1_163200_230400 0 1.188000e-07
I1991 n1_m1_163200_235200 0 1.647667e-07
I1992 n1_m1_163200_240000 0 1.297943e-07
I1993 n1_m1_163200_244800 0 2.769714e-07
I1994 n1_m1_163200_249600 0 6.089625e-07
I1995 n1_m1_163200_254400 0 4.005048e-06
I1996 n1_m1_163200_259200 0 1.700000e-07
I1997 n1_m1_163200_264000 0 4.717286e-07
I1998 n1_m1_163200_268800 0 1.585190e-06
I1999 n1_m1_163200_273600 0 3.532238e-06
I2000 n1_m1_163200_278400 0 9.885714e-07
I2001 n1_m1_163200_283200 0 2.371905e-06
I2002 n1_m1_163200_288000 0 1.498571e-06
I2003 n1_m1_163200_292800 0 6.346071e-07
I2004 n1_m1_163200_297600 0 2.859843e-06
I2005 n1_m1_163200_302400 0 3.374095e-06
I2006 n1_m1_163200_307200 0 2.092143e-06
I2007 n1_m1_163200_312000 0 1.794857e-06
I2008 n1_m1_163200_316800 0 2.094476e-06
I2009 n1_m1_163200_321600 0 1.651799e-06
I2010 n1_m1_163200_326400 0 8.561111e-07
I2011 n1_m1_163200_331200 0 8.535286e-07
I2012 n1_m1_163200_336000 0 8.409048e-07
I2013 n1_m1_163200_340800 0 6.967179e-07
I2014 n1_m1_163200_345600 0 1.400391e-06
I2015 n1_m1_163200_350400 0 2.078169e-06
I2016 n1_m1_163200_355200 0 3.035487e-06
I2017 n1_m1_163200_360000 0 2.178571e-06
I2018 n1_m1_163200_364800 0 1.488521e-06
I2019 n1_m1_163200_369600 0 1.417658e-06
I2020 n1_m1_163200_374400 0 1.054782e-06
I2021 n1_m1_163200_379200 0 5.136387e-07
I2022 n1_m1_163200_384000 0 1.139991e-06
I2023 n1_m1_163200_393600 0 2.514714e-07
I2024 n1_m1_163200_398400 0 1.071714e-07
I2025 n1_m1_163200_403200 0 1.047405e-07
I2026 n1_m1_163200_408000 0 1.185714e-07
I2027 n1_m1_163200_412800 0 1.247714e-07
I2028 n1_m1_163200_417600 0 1.320071e-07
I2029 n1_m1_163200_422400 0 7.375893e-08
I2030 n1_m1_163200_427200 0 3.039310e-07
I2031 n1_m1_163200_432000 0 5.804517e-07
I2032 n1_m1_163200_436800 0 2.068810e-08
I2033 n1_m1_163200_441600 0 1.998238e-07
I2034 n1_m1_163200_446400 0 1.011310e-07
I2035 n1_m1_163200_451200 0 9.382619e-08
I2036 n1_m1_163200_456000 0 9.673810e-08
I2037 n1_m1_163200_460800 0 1.201667e-07
I2038 n1_m1_163200_465600 0 1.657143e-08
I2039 n1_m1_163200_480000 0 1.448571e-07
I2040 n1_m1_163200_484800 0 5.238304e-07
I2041 n1_m1_163200_585600 0 2.140000e-08
I2042 n1_m1_168000_4800 0 1.814154e-07
I2043 n1_m1_168000_9600 0 8.595624e-07
I2044 n1_m1_168000_24000 0 1.354000e-07
I2045 n1_m1_168000_28800 0 5.437500e-07
I2046 n1_m1_168000_86400 0 1.501538e-08
I2047 n1_m1_168000_91200 0 1.337275e-07
I2048 n1_m1_168000_96000 0 1.772476e-07
I2049 n1_m1_168000_100800 0 1.143905e-07
I2050 n1_m1_168000_105600 0 3.379143e-07
I2051 n1_m1_168000_110400 0 1.785595e-07
I2052 n1_m1_168000_115200 0 4.089524e-08
I2053 n1_m1_168000_120000 0 3.486714e-07
I2054 n1_m1_168000_124800 0 2.165714e-07
I2055 n1_m1_168000_129600 0 2.543143e-07
I2056 n1_m1_168000_134400 0 2.896095e-07
I2057 n1_m1_168000_139200 0 3.768571e-07
I2058 n1_m1_168000_144000 0 6.968571e-07
I2059 n1_m1_168000_148800 0 1.939571e-07
I2060 n1_m1_168000_153600 0 1.563262e-06
I2061 n1_m1_168000_158400 0 8.230476e-07
I2062 n1_m1_168000_163200 0 8.055420e-07
I2063 n1_m1_168000_168000 0 2.249118e-06
I2064 n1_m1_168000_172800 0 1.235793e-06
I2065 n1_m1_168000_177600 0 2.689000e-06
I2066 n1_m1_168000_187200 0 5.597143e-08
I2067 n1_m1_168000_192000 0 5.221227e-07
I2068 n1_m1_168000_196800 0 6.828143e-07
I2069 n1_m1_168000_201600 0 1.396881e-06
I2070 n1_m1_168000_206400 0 2.171714e-07
I2071 n1_m1_168000_211200 0 1.303286e-07
I2072 n1_m1_168000_216000 0 1.633286e-07
I2073 n1_m1_168000_220800 0 1.806429e-07
I2074 n1_m1_168000_225600 0 2.648619e-07
I2075 n1_m1_168000_230400 0 2.140381e-07
I2076 n1_m1_168000_235200 0 8.743333e-08
I2077 n1_m1_168000_240000 0 1.956271e-07
I2078 n1_m1_168000_244800 0 1.192952e-07
I2079 n1_m1_168000_249600 0 1.309714e-07
I2080 n1_m1_168000_254400 0 1.374081e-06
I2081 n1_m1_168000_259200 0 8.706095e-07
I2082 n1_m1_168000_264000 0 3.415857e-07
I2083 n1_m1_168000_268800 0 7.480000e-08
I2084 n1_m1_168000_273600 0 1.398143e-06
I2085 n1_m1_168000_278400 0 3.063571e-06
I2086 n1_m1_168000_283200 0 1.878857e-06
I2087 n1_m1_168000_288000 0 1.390071e-06
I2088 n1_m1_168000_292800 0 9.531786e-07
I2089 n1_m1_168000_297600 0 2.208754e-06
I2090 n1_m1_168000_302400 0 1.693819e-06
I2091 n1_m1_168000_307200 0 1.311984e-06
I2092 n1_m1_168000_312000 0 2.795508e-06
I2093 n1_m1_168000_316800 0 5.732857e-07
I2094 n1_m1_168000_321600 0 2.564391e-06
I2095 n1_m1_168000_326400 0 1.042857e-06
I2096 n1_m1_168000_331200 0 3.311714e-07
I2097 n1_m1_168000_336000 0 1.565214e-06
I2098 n1_m1_168000_340800 0 3.865714e-07
I2099 n1_m1_168000_345600 0 2.667902e-06
I2100 n1_m1_168000_350400 0 3.505485e-06
I2101 n1_m1_168000_355200 0 5.343513e-06
I2102 n1_m1_168000_360000 0 3.600290e-06
I2103 n1_m1_168000_364800 0 2.028931e-06
I2104 n1_m1_168000_369600 0 2.595686e-06
I2105 n1_m1_168000_374400 0 1.393017e-06
I2106 n1_m1_168000_379200 0 8.325471e-07
I2107 n1_m1_168000_384000 0 9.653773e-07
I2108 n1_m1_168000_388800 0 6.031286e-07
I2109 n1_m1_168000_393600 0 2.872381e-07
I2110 n1_m1_168000_398400 0 1.690000e-07
I2111 n1_m1_168000_403200 0 8.799524e-08
I2112 n1_m1_168000_408000 0 4.359048e-07
I2113 n1_m1_168000_412800 0 1.383143e-07
I2114 n1_m1_168000_417600 0 3.623000e-07
I2115 n1_m1_168000_422400 0 5.938786e-07
I2116 n1_m1_168000_427200 0 2.475190e-07
I2117 n1_m1_168000_432000 0 1.253954e-06
I2118 n1_m1_168000_436800 0 1.486381e-07
I2119 n1_m1_168000_441600 0 2.550571e-07
I2120 n1_m1_168000_446400 0 1.720714e-07
I2121 n1_m1_168000_451200 0 1.202857e-07
I2122 n1_m1_168000_456000 0 1.589857e-07
I2123 n1_m1_168000_460800 0 1.918571e-07
I2124 n1_m1_168000_465600 0 4.114286e-08
I2125 n1_m1_168000_480000 0 8.331429e-08
I2126 n1_m1_168000_484800 0 7.441982e-07
I2127 n1_m1_168000_580800 0 1.070769e-08
I2128 n1_m1_168000_585600 0 2.095897e-08
I2129 n1_m1_172800_9600 0 3.111111e-07
I2130 n1_m1_172800_14400 0 1.553571e-07
I2131 n1_m1_172800_19200 0 2.071429e-07
I2132 n1_m1_172800_28800 0 2.537500e-07
I2133 n1_m1_172800_86400 0 5.846154e-09
I2134 n1_m1_172800_91200 0 5.255385e-08
I2135 n1_m1_172800_96000 0 2.891905e-08
I2136 n1_m1_172800_100800 0 3.475905e-08
I2137 n1_m1_172800_105600 0 1.473071e-07
I2138 n1_m1_172800_110400 0 1.047679e-07
I2139 n1_m1_172800_115200 0 1.490321e-07
I2140 n1_m1_172800_120000 0 2.589048e-07
I2141 n1_m1_172800_124800 0 6.100000e-08
I2142 n1_m1_172800_129600 0 6.331429e-08
I2143 n1_m1_172800_134400 0 1.531762e-07
I2144 n1_m1_172800_139200 0 4.288095e-08
I2145 n1_m1_172800_144000 0 6.752857e-08
I2146 n1_m1_172800_148800 0 1.123810e-08
I2147 n1_m1_172800_153600 0 2.971714e-07
I2148 n1_m1_172800_158400 0 1.198476e-07
I2149 n1_m1_172800_163200 0 1.314000e-07
I2150 n1_m1_172800_168000 0 6.243429e-08
I2151 n1_m1_172800_172800 0 3.167429e-08
I2152 n1_m1_172800_177600 0 5.182976e-07
I2153 n1_m1_172800_182400 0 8.166667e-07
I2154 n1_m1_172800_187200 0 5.611429e-08
I2155 n1_m1_172800_192000 0 1.970574e-07
I2156 n1_m1_172800_196800 0 3.662571e-08
I2157 n1_m1_172800_201600 0 1.526552e-07
I2158 n1_m1_172800_206400 0 6.183571e-08
I2159 n1_m1_172800_211200 0 5.021429e-08
I2160 n1_m1_172800_216000 0 1.045762e-07
I2161 n1_m1_172800_220800 0 5.894286e-08
I2162 n1_m1_172800_225600 0 1.988845e-06
I2163 n1_m1_172800_230400 0 1.601905e-08
I2164 n1_m1_172800_235200 0 4.126429e-08
I2165 n1_m1_172800_240000 0 8.689048e-08
I2166 n1_m1_172800_244800 0 5.924762e-08
I2167 n1_m1_172800_249600 0 1.272679e-07
I2168 n1_m1_172800_254400 0 1.282452e-07
I2169 n1_m1_172800_259200 0 3.656571e-08
I2170 n1_m1_172800_264000 0 4.683143e-08
I2171 n1_m1_172800_268800 0 5.030000e-08
I2172 n1_m1_172800_273600 0 5.773512e-07
I2173 n1_m1_172800_278400 0 4.904762e-07
I2174 n1_m1_172800_283200 0 4.347857e-07
I2175 n1_m1_172800_288000 0 1.771111e-07
I2176 n1_m1_172800_292800 0 4.427778e-07
I2177 n1_m1_172800_297600 0 7.607066e-07
I2178 n1_m1_172800_302400 0 8.704749e-07
I2179 n1_m1_172800_307200 0 7.117460e-07
I2180 n1_m1_172800_312000 0 6.978413e-07
I2181 n1_m1_172800_316800 0 7.036429e-07
I2182 n1_m1_172800_321600 0 8.646607e-07
I2183 n1_m1_172800_326400 0 1.765714e-07
I2184 n1_m1_172800_331200 0 6.678254e-07
I2185 n1_m1_172800_336000 0 1.037120e-06
I2186 n1_m1_172800_340800 0 3.405414e-07
I2187 n1_m1_172800_345600 0 8.392655e-07
I2188 n1_m1_172800_350400 0 3.470440e-07
I2189 n1_m1_172800_355200 0 5.096063e-07
I2190 n1_m1_172800_360000 0 6.198220e-07
I2191 n1_m1_172800_364800 0 8.896118e-07
I2192 n1_m1_172800_369600 0 7.205800e-07
I2193 n1_m1_172800_374400 0 7.363361e-07
I2194 n1_m1_172800_379200 0 4.665066e-07
I2195 n1_m1_172800_384000 0 7.063590e-07
I2196 n1_m1_172800_388800 0 8.190966e-08
I2197 n1_m1_172800_393600 0 2.338857e-07
I2198 n1_m1_172800_398400 0 5.900857e-07
I2199 n1_m1_172800_403200 0 4.855286e-07
I2200 n1_m1_172800_408000 0 9.059250e-08
I2201 n1_m1_172800_412800 0 7.126929e-08
I2202 n1_m1_172800_417600 0 1.631571e-07
I2203 n1_m1_172800_422400 0 3.625357e-08
I2204 n1_m1_172800_427200 0 3.780000e-08
I2205 n1_m1_172800_432000 0 7.264286e-08
I2206 n1_m1_172800_436800 0 1.078571e-07
I2207 n1_m1_172800_441600 0 5.105000e-08
I2208 n1_m1_172800_451200 0 2.694286e-08
I2209 n1_m1_172800_456000 0 3.157000e-07
I2210 n1_m1_172800_460800 0 5.457143e-08
I2211 n1_m1_172800_465600 0 1.048571e-08
I2212 n1_m1_177600_4800 0 3.854769e-08
I2213 n1_m1_177600_9600 0 9.177998e-07
I2214 n1_m1_177600_14400 0 5.053571e-07
I2215 n1_m1_177600_19200 0 5.151429e-07
I2216 n1_m1_177600_28800 0 2.887143e-07
I2217 n1_m1_177600_33600 0 1.902857e-07
I2218 n1_m1_177600_86400 0 1.263077e-08
I2219 n1_m1_177600_91200 0 1.093794e-07
I2220 n1_m1_177600_96000 0 1.623327e-07
I2221 n1_m1_177600_100800 0 2.264000e-07
I2222 n1_m1_177600_105600 0 2.328071e-07
I2223 n1_m1_177600_110400 0 4.330179e-07
I2224 n1_m1_177600_115200 0 3.655821e-07
I2225 n1_m1_177600_120000 0 3.814857e-07
I2226 n1_m1_177600_124800 0 1.694286e-07
I2227 n1_m1_177600_129600 0 3.919143e-07
I2228 n1_m1_177600_134400 0 4.673238e-07
I2229 n1_m1_177600_139200 0 5.616548e-07
I2230 n1_m1_177600_144000 0 7.921429e-07
I2231 n1_m1_177600_148800 0 5.226190e-07
I2232 n1_m1_177600_153600 0 9.054429e-07
I2233 n1_m1_177600_158400 0 5.158952e-07
I2234 n1_m1_177600_163200 0 5.980143e-07
I2235 n1_m1_177600_168000 0 5.364907e-07
I2236 n1_m1_177600_172800 0 1.909571e-07
I2237 n1_m1_177600_177600 0 1.183401e-06
I2238 n1_m1_177600_182400 0 1.306667e-06
I2239 n1_m1_177600_187200 0 1.008857e-07
I2240 n1_m1_177600_192000 0 3.161060e-07
I2241 n1_m1_177600_196800 0 1.724143e-07
I2242 n1_m1_177600_201600 0 2.460838e-07
I2243 n1_m1_177600_206400 0 9.692143e-08
I2244 n1_m1_177600_211200 0 1.190714e-07
I2245 n1_m1_177600_216000 0 3.993438e-07
I2246 n1_m1_177600_220800 0 2.258114e-07
I2247 n1_m1_177600_225600 0 3.147024e-07
I2248 n1_m1_177600_230400 0 1.108286e-07
I2249 n1_m1_177600_235200 0 1.757357e-07
I2250 n1_m1_177600_240000 0 2.384867e-07
I2251 n1_m1_177600_244800 0 1.934629e-07
I2252 n1_m1_177600_249600 0 4.158521e-07
I2253 n1_m1_177600_254400 0 4.704643e-07
I2254 n1_m1_177600_259200 0 1.091114e-06
I2255 n1_m1_177600_264000 0 2.480286e-07
I2256 n1_m1_177600_268800 0 1.451486e-07
I2257 n1_m1_177600_273600 0 7.757202e-07
I2258 n1_m1_177600_278400 0 1.268968e-06
I2259 n1_m1_177600_283200 0 3.529135e-06
I2260 n1_m1_177600_288000 0 2.145571e-06
I2261 n1_m1_177600_292800 0 1.514286e-08
I2262 n1_m1_177600_297600 0 5.383185e-07
I2263 n1_m1_177600_302400 0 1.128392e-06
I2264 n1_m1_177600_307200 0 9.283095e-07
I2265 n1_m1_177600_312000 0 3.884952e-07
I2266 n1_m1_177600_316800 0 1.210571e-07
I2267 n1_m1_177600_321600 0 9.403107e-07
I2268 n1_m1_177600_326400 0 3.032000e-07
I2269 n1_m1_177600_331200 0 1.029914e-06
I2270 n1_m1_177600_336000 0 1.404165e-06
I2271 n1_m1_177600_340800 0 6.177672e-07
I2272 n1_m1_177600_345600 0 1.231288e-06
I2273 n1_m1_177600_350400 0 1.385589e-06
I2274 n1_m1_177600_355200 0 2.794286e-06
I2275 n1_m1_177600_360000 0 1.936222e-06
I2276 n1_m1_177600_364800 0 1.958676e-06
I2277 n1_m1_177600_369600 0 1.474131e-06
I2278 n1_m1_177600_374400 0 8.466303e-07
I2279 n1_m1_177600_379200 0 9.493446e-07
I2280 n1_m1_177600_384000 0 5.458276e-07
I2281 n1_m1_177600_388800 0 1.344598e-06
I2282 n1_m1_177600_393600 0 4.334429e-07
I2283 n1_m1_177600_398400 0 3.869143e-07
I2284 n1_m1_177600_403200 0 4.114229e-07
I2285 n1_m1_177600_408000 0 2.714793e-07
I2286 n1_m1_177600_412800 0 3.142360e-07
I2287 n1_m1_177600_417600 0 7.671384e-07
I2288 n1_m1_177600_422400 0 2.150481e-07
I2289 n1_m1_177600_427200 0 9.674286e-08
I2290 n1_m1_177600_432000 0 3.639905e-07
I2291 n1_m1_177600_436800 0 1.355349e-07
I2292 n1_m1_177600_441600 0 1.719500e-07
I2293 n1_m1_177600_446400 0 1.033571e-07
I2294 n1_m1_177600_451200 0 1.098429e-07
I2295 n1_m1_177600_456000 0 1.963019e-07
I2296 n1_m1_177600_460800 0 1.173857e-07
I2297 n1_m1_177600_465600 0 1.309771e-07
I2298 n1_m1_177600_576000 0 1.988571e-09
I2299 n1_m1_177600_580800 0 3.052275e-07
I2300 n1_m1_177600_585600 0 1.833100e-07
I2301 n1_m1_182400_4800 0 2.819077e-08
I2302 n1_m1_182400_9600 0 9.996173e-08
I2303 n1_m1_182400_86400 0 3.876923e-09
I2304 n1_m1_182400_91200 0 7.329859e-08
I2305 n1_m1_182400_96000 0 7.938163e-08
I2306 n1_m1_182400_100800 0 9.528571e-08
I2307 n1_m1_182400_105600 0 2.875857e-07
I2308 n1_m1_182400_110400 0 7.242857e-08
I2309 n1_m1_182400_115200 0 5.052619e-08
I2310 n1_m1_182400_120000 0 1.007571e-07
I2311 n1_m1_182400_124800 0 1.128571e-07
I2312 n1_m1_182400_129600 0 2.805257e-07
I2313 n1_m1_182400_134400 0 1.431955e-07
I2314 n1_m1_182400_139200 0 1.825459e-07
I2315 n1_m1_182400_144000 0 5.160643e-07
I2316 n1_m1_182400_148800 0 2.610429e-07
I2317 n1_m1_182400_153600 0 4.932298e-07
I2318 n1_m1_182400_158400 0 9.520816e-08
I2319 n1_m1_182400_163200 0 3.214840e-07
I2320 n1_m1_182400_168000 0 6.886643e-08
I2321 n1_m1_182400_172800 0 6.933810e-08
I2322 n1_m1_182400_177600 0 3.974568e-07
I2323 n1_m1_182400_182400 0 1.440000e-08
I2324 n1_m1_182400_187200 0 4.354286e-08
I2325 n1_m1_182400_192000 0 1.188738e-07
I2326 n1_m1_182400_196800 0 5.557857e-08
I2327 n1_m1_182400_201600 0 1.657248e-07
I2328 n1_m1_182400_206400 0 8.991714e-08
I2329 n1_m1_182400_211200 0 1.504905e-07
I2330 n1_m1_182400_216000 0 4.508800e-07
I2331 n1_m1_182400_220800 0 2.819743e-07
I2332 n1_m1_182400_225600 0 7.462000e-08
I2333 n1_m1_182400_230400 0 4.956190e-08
I2334 n1_m1_182400_235200 0 2.864143e-08
I2335 n1_m1_182400_240000 0 1.457290e-07
I2336 n1_m1_182400_244800 0 7.244667e-08
I2337 n1_m1_182400_249600 0 2.026800e-07
I2338 n1_m1_182400_254400 0 5.985714e-08
I2339 n1_m1_182400_259200 0 1.795429e-07
I2340 n1_m1_182400_264000 0 1.546286e-07
I2341 n1_m1_182400_268800 0 1.290443e-07
I2342 n1_m1_182400_273600 0 1.603298e-06
I2343 n1_m1_182400_278400 0 4.213073e-06
I2344 n1_m1_182400_283200 0 7.284127e-07
I2345 n1_m1_182400_288000 0 4.548876e-07
I2346 n1_m1_182400_292800 0 2.537857e-07
I2347 n1_m1_182400_297600 0 2.526000e-07
I2348 n1_m1_182400_302400 0 4.166317e-07
I2349 n1_m1_182400_307200 0 1.264286e-07
I2350 n1_m1_182400_312000 0 2.457518e-07
I2351 n1_m1_182400_316800 0 1.707911e-07
I2352 n1_m1_182400_321600 0 1.567310e-07
I2353 n1_m1_182400_326400 0 1.904095e-07
I2354 n1_m1_182400_331200 0 8.190000e-08
I2355 n1_m1_182400_336000 0 2.196238e-07
I2356 n1_m1_182400_340800 0 8.990367e-08
I2357 n1_m1_182400_345600 0 1.556347e-07
I2358 n1_m1_182400_350400 0 4.931577e-07
I2359 n1_m1_182400_355200 0 4.495437e-07
I2360 n1_m1_182400_360000 0 2.298139e-06
I2361 n1_m1_182400_364800 0 1.041176e-06
I2362 n1_m1_182400_369600 0 1.083697e-06
I2363 n1_m1_182400_374400 0 2.329743e-07
I2364 n1_m1_182400_379200 0 1.540873e-06
I2365 n1_m1_182400_384000 0 1.554208e-06
I2366 n1_m1_182400_388800 0 9.455106e-07
I2367 n1_m1_182400_393600 0 1.960143e-07
I2368 n1_m1_182400_398400 0 9.930857e-08
I2369 n1_m1_182400_403200 0 7.613714e-08
I2370 n1_m1_182400_408000 0 2.141172e-07
I2371 n1_m1_182400_412800 0 2.147956e-07
I2372 n1_m1_182400_417600 0 1.777116e-07
I2373 n1_m1_182400_422400 0 5.675837e-08
I2374 n1_m1_182400_427200 0 7.841714e-08
I2375 n1_m1_182400_432000 0 1.983714e-07
I2376 n1_m1_182400_436800 0 1.447956e-07
I2377 n1_m1_182400_441600 0 1.813857e-07
I2378 n1_m1_182400_446400 0 3.400000e-07
I2379 n1_m1_182400_451200 0 3.437557e-07
I2380 n1_m1_182400_456000 0 2.113714e-08
I2381 n1_m1_182400_460800 0 6.361429e-08
I2382 n1_m1_182400_465600 0 6.002286e-08
I2383 n1_m1_182400_576000 0 4.971429e-10
I2384 n1_m1_182400_580800 0 3.146099e-07
I2385 n1_m1_182400_585600 0 2.574169e-07
I2386 n1_m1_187200_4800 0 1.975385e-08
I2387 n1_m1_187200_9600 0 1.124615e-08
I2388 n1_m1_187200_86400 0 7.357275e-08
I2389 n1_m1_187200_91200 0 1.346930e-07
I2390 n1_m1_187200_96000 0 1.789000e-07
I2391 n1_m1_187200_100800 0 1.001886e-07
I2392 n1_m1_187200_105600 0 9.362571e-08
I2393 n1_m1_187200_110400 0 1.123143e-07
I2394 n1_m1_187200_115200 0 2.240595e-07
I2395 n1_m1_187200_120000 0 2.043000e-07
I2396 n1_m1_187200_124800 0 2.137857e-07
I2397 n1_m1_187200_129600 0 1.309314e-07
I2398 n1_m1_187200_134400 0 9.400041e-08
I2399 n1_m1_187200_139200 0 8.576531e-08
I2400 n1_m1_187200_144000 0 7.970786e-07
I2401 n1_m1_187200_148800 0 1.124571e-07
I2402 n1_m1_187200_153600 0 4.917702e-07
I2403 n1_m1_187200_158400 0 1.178204e-07
I2404 n1_m1_187200_163200 0 2.911588e-07
I2405 n1_m1_187200_168000 0 5.573229e-07
I2406 n1_m1_187200_172800 0 9.850721e-08
I2407 n1_m1_187200_177600 0 1.458033e-07
I2408 n1_m1_187200_182400 0 6.042857e-08
I2409 n1_m1_187200_187200 0 1.452857e-07
I2410 n1_m1_187200_192000 0 2.521190e-07
I2411 n1_m1_187200_196800 0 1.702786e-07
I2412 n1_m1_187200_201600 0 1.358581e-07
I2413 n1_m1_187200_206400 0 7.624000e-08
I2414 n1_m1_187200_211200 0 9.989524e-08
I2415 n1_m1_187200_216000 0 6.104857e-07
I2416 n1_m1_187200_220800 0 3.626143e-07
I2417 n1_m1_187200_225600 0 3.107314e-07
I2418 n1_m1_187200_230400 0 2.802381e-07
I2419 n1_m1_187200_235200 0 1.036271e-07
I2420 n1_m1_187200_240000 0 1.968510e-07
I2421 n1_m1_187200_244800 0 2.118429e-07
I2422 n1_m1_187200_249600 0 9.481429e-08
I2423 n1_m1_187200_254400 0 1.012429e-07
I2424 n1_m1_187200_259200 0 5.568571e-08
I2425 n1_m1_187200_264000 0 1.699286e-07
I2426 n1_m1_187200_268800 0 7.128143e-08
I2427 n1_m1_187200_273600 0 1.472558e-07
I2428 n1_m1_187200_278400 0 9.976893e-07
I2429 n1_m1_187200_283200 0 3.550349e-07
I2430 n1_m1_187200_288000 0 6.828381e-08
I2431 n1_m1_187200_292800 0 9.664286e-08
I2432 n1_m1_187200_297600 0 1.357314e-07
I2433 n1_m1_187200_302400 0 6.515293e-07
I2434 n1_m1_187200_307200 0 7.587399e-07
I2435 n1_m1_187200_312000 0 1.247529e-07
I2436 n1_m1_187200_316800 0 2.310883e-07
I2437 n1_m1_187200_321600 0 1.257118e-07
I2438 n1_m1_187200_326400 0 1.068762e-07
I2439 n1_m1_187200_331200 0 8.784286e-08
I2440 n1_m1_187200_336000 0 1.851476e-07
I2441 n1_m1_187200_340800 0 9.184490e-08
I2442 n1_m1_187200_345600 0 4.196938e-07
I2443 n1_m1_187200_350400 0 6.084643e-07
I2444 n1_m1_187200_355200 0 1.451571e-06
I2445 n1_m1_187200_360000 0 2.710648e-06
I2446 n1_m1_187200_364800 0 2.180952e-07
I2447 n1_m1_187200_369600 0 1.145039e-06
I2448 n1_m1_187200_374400 0 3.826829e-07
I2449 n1_m1_187200_379200 0 9.679637e-07
I2450 n1_m1_187200_384000 0 1.726023e-06
I2451 n1_m1_187200_388800 0 1.626679e-07
I2452 n1_m1_187200_393600 0 3.227514e-07
I2453 n1_m1_187200_398400 0 6.725200e-07
I2454 n1_m1_187200_403200 0 1.867686e-07
I2455 n1_m1_187200_408000 0 1.147176e-06
I2456 n1_m1_187200_412800 0 2.133619e-07
I2457 n1_m1_187200_417600 0 2.983586e-07
I2458 n1_m1_187200_422400 0 1.019114e-07
I2459 n1_m1_187200_427200 0 1.412971e-07
I2460 n1_m1_187200_432000 0 1.412286e-07
I2461 n1_m1_187200_436800 0 6.986286e-08
I2462 n1_m1_187200_441600 0 1.520000e-07
I2463 n1_m1_187200_446400 0 1.150000e-07
I2464 n1_m1_187200_451200 0 7.647286e-08
I2465 n1_m1_187200_456000 0 7.769429e-08
I2466 n1_m1_187200_460800 0 9.707143e-08
I2467 n1_m1_187200_465600 0 1.743714e-07
I2468 n1_m1_187200_580800 0 3.181065e-08
I2469 n1_m1_187200_585600 0 2.813166e-08
I2470 n1_m1_192000_86400 0 2.549136e-08
I2471 n1_m1_192000_91200 0 2.125239e-07
I2472 n1_m1_192000_96000 0 1.808052e-06
I2473 n1_m1_192000_100800 0 1.446067e-07
I2474 n1_m1_192000_105600 0 2.176267e-07
I2475 n1_m1_192000_110400 0 1.595429e-07
I2476 n1_m1_192000_115200 0 7.886143e-07
I2477 n1_m1_192000_120000 0 1.484200e-06
I2478 n1_m1_192000_124800 0 4.888571e-07
I2479 n1_m1_192000_129600 0 5.504905e-07
I2480 n1_m1_192000_134400 0 1.978469e-07
I2481 n1_m1_192000_139200 0 1.029388e-07
I2482 n1_m1_192000_144000 0 1.269471e-06
I2483 n1_m1_192000_148800 0 1.215857e-07
I2484 n1_m1_192000_153600 0 4.349134e-07
I2485 n1_m1_192000_158400 0 4.205429e-07
I2486 n1_m1_192000_163200 0 2.708286e-07
I2487 n1_m1_192000_168000 0 3.766914e-07
I2488 n1_m1_192000_172800 0 1.635118e-07
I2489 n1_m1_192000_177600 0 7.494701e-07
I2490 n1_m1_192000_182400 0 1.180000e-07
I2491 n1_m1_192000_187200 0 1.511143e-07
I2492 n1_m1_192000_192000 0 1.305311e-06
I2493 n1_m1_192000_196800 0 8.572286e-07
I2494 n1_m1_192000_201600 0 8.295714e-07
I2495 n1_m1_192000_206400 0 2.488000e-07
I2496 n1_m1_192000_211200 0 1.807000e-07
I2497 n1_m1_192000_216000 0 2.889242e-07
I2498 n1_m1_192000_220800 0 2.209667e-07
I2499 n1_m1_192000_225600 0 2.808010e-07
I2500 n1_m1_192000_230400 0 2.167714e-07
I2501 n1_m1_192000_235200 0 1.409743e-07
I2502 n1_m1_192000_240000 0 3.189000e-07
I2503 n1_m1_192000_244800 0 9.560000e-08
I2504 n1_m1_192000_249600 0 2.267571e-07
I2505 n1_m1_192000_254400 0 1.403571e-07
I2506 n1_m1_192000_259200 0 5.162857e-07
I2507 n1_m1_192000_264000 0 9.416571e-07
I2508 n1_m1_192000_268800 0 1.646067e-07
I2509 n1_m1_192000_273600 0 1.157836e-06
I2510 n1_m1_192000_278400 0 2.552651e-06
I2511 n1_m1_192000_283200 0 5.896389e-07
I2512 n1_m1_192000_288000 0 2.622429e-07
I2513 n1_m1_192000_292800 0 1.972429e-07
I2514 n1_m1_192000_297600 0 1.771229e-07
I2515 n1_m1_192000_302400 0 4.678932e-07
I2516 n1_m1_192000_307200 0 8.973315e-07
I2517 n1_m1_192000_312000 0 2.930381e-07
I2518 n1_m1_192000_316800 0 3.290063e-07
I2519 n1_m1_192000_321600 0 6.831857e-07
I2520 n1_m1_192000_326400 0 7.360050e-07
I2521 n1_m1_192000_331200 0 2.295508e-07
I2522 n1_m1_192000_336000 0 1.817000e-07
I2523 n1_m1_192000_340800 0 1.927143e-07
I2524 n1_m1_192000_345600 0 2.567629e-07
I2525 n1_m1_192000_350400 0 1.647321e-08
I2526 n1_m1_192000_355200 0 1.089107e-06
I2527 n1_m1_192000_360000 0 9.160071e-07
I2528 n1_m1_192000_364800 0 1.388056e-06
I2529 n1_m1_192000_369600 0 3.067521e-06
I2530 n1_m1_192000_374400 0 5.620905e-07
I2531 n1_m1_192000_379200 0 5.941271e-07
I2532 n1_m1_192000_384000 0 2.018005e-06
I2533 n1_m1_192000_388800 0 5.710000e-07
I2534 n1_m1_192000_393600 0 4.224057e-07
I2535 n1_m1_192000_398400 0 1.580857e-07
I2536 n1_m1_192000_403200 0 3.165286e-07
I2537 n1_m1_192000_408000 0 9.366654e-07
I2538 n1_m1_192000_412800 0 2.927314e-07
I2539 n1_m1_192000_417600 0 3.072486e-07
I2540 n1_m1_192000_422400 0 1.573000e-07
I2541 n1_m1_192000_427200 0 2.724190e-07
I2542 n1_m1_192000_432000 0 2.367429e-07
I2543 n1_m1_192000_436800 0 8.821114e-07
I2544 n1_m1_192000_441600 0 8.056000e-07
I2545 n1_m1_192000_446400 0 7.630952e-08
I2546 n1_m1_192000_451200 0 1.525190e-07
I2547 n1_m1_192000_456000 0 2.545286e-07
I2548 n1_m1_192000_460800 0 1.611429e-07
I2549 n1_m1_192000_465600 0 1.282000e-07
I2550 n1_m1_192000_504000 0 1.180000e-08
I2551 n1_m1_192000_508800 0 1.573333e-08
I2552 n1_m1_192000_513600 0 4.830000e-08
I2553 n1_m1_192000_518400 0 5.676923e-09
I2554 n1_m1_192000_523200 0 6.623077e-09
I2555 n1_m1_192000_528000 0 8.610000e-08
I2556 n1_m1_192000_532800 0 1.003846e-08
I2557 n1_m1_192000_537600 0 1.608077e-08
I2558 n1_m1_192000_542400 0 2.730769e-09
I2559 n1_m1_192000_547200 0 9.261538e-09
I2560 n1_m1_192000_552000 0 1.080513e-08
I2561 n1_m1_192000_580800 0 5.249073e-07
I2562 n1_m1_192000_585600 0 3.494671e-07
I2563 n1_m1_196800_4800 0 1.975385e-08
I2564 n1_m1_196800_9600 0 1.646154e-09
I2565 n1_m1_196800_86400 0 1.494051e-07
I2566 n1_m1_196800_91200 0 7.152821e-08
I2567 n1_m1_196800_96000 0 1.212857e-07
I2568 n1_m1_196800_100800 0 8.163571e-08
I2569 n1_m1_196800_105600 0 1.452095e-07
I2570 n1_m1_196800_110400 0 1.323333e-07
I2571 n1_m1_196800_115200 0 4.241143e-07
I2572 n1_m1_196800_120000 0 3.060357e-07
I2573 n1_m1_196800_124800 0 1.632054e-07
I2574 n1_m1_196800_129600 0 2.069988e-07
I2575 n1_m1_196800_134400 0 9.495714e-08
I2576 n1_m1_196800_139200 0 4.885714e-08
I2577 n1_m1_196800_144000 0 1.530257e-07
I2578 n1_m1_196800_148800 0 1.017829e-07
I2579 n1_m1_196800_153600 0 5.345098e-07
I2580 n1_m1_196800_158400 0 5.922857e-08
I2581 n1_m1_196800_163200 0 1.078125e-07
I2582 n1_m1_196800_168000 0 1.691304e-07
I2583 n1_m1_196800_172800 0 7.617143e-08
I2584 n1_m1_196800_177600 0 1.119405e-07
I2585 n1_m1_196800_182400 0 9.250000e-08
I2586 n1_m1_196800_187200 0 3.480000e-08
I2587 n1_m1_196800_192000 0 2.462744e-07
I2588 n1_m1_196800_196800 0 1.393964e-06
I2589 n1_m1_196800_201600 0 1.313857e-07
I2590 n1_m1_196800_206400 0 1.361690e-07
I2591 n1_m1_196800_211200 0 2.935357e-07
I2592 n1_m1_196800_216000 0 7.572740e-07
I2593 n1_m1_196800_220800 0 5.192619e-07
I2594 n1_m1_196800_225600 0 2.479048e-07
I2595 n1_m1_196800_230400 0 1.458857e-07
I2596 n1_m1_196800_235200 0 1.430429e-07
I2597 n1_m1_196800_240000 0 1.993000e-07
I2598 n1_m1_196800_244800 0 6.047143e-08
I2599 n1_m1_196800_249600 0 1.733286e-07
I2600 n1_m1_196800_254400 0 1.939000e-07
I2601 n1_m1_196800_259200 0 2.139410e-06
I2602 n1_m1_196800_264000 0 1.415500e-06
I2603 n1_m1_196800_268800 0 6.900833e-08
I2604 n1_m1_196800_273600 0 4.621629e-07
I2605 n1_m1_196800_278400 0 1.091955e-06
I2606 n1_m1_196800_283200 0 1.662071e-07
I2607 n1_m1_196800_288000 0 3.212857e-07
I2608 n1_m1_196800_292800 0 2.680310e-07
I2609 n1_m1_196800_297600 0 3.289100e-07
I2610 n1_m1_196800_302400 0 1.378607e-07
I2611 n1_m1_196800_307200 0 9.784524e-08
I2612 n1_m1_196800_312000 0 9.141667e-07
I2613 n1_m1_196800_316800 0 6.048571e-08
I2614 n1_m1_196800_321600 0 2.009857e-07
I2615 n1_m1_196800_326400 0 1.128824e-06
I2616 n1_m1_196800_331200 0 4.129313e-07
I2617 n1_m1_196800_336000 0 2.179667e-07
I2618 n1_m1_196800_340800 0 2.779905e-07
I2619 n1_m1_196800_345600 0 3.276571e-07
I2620 n1_m1_196800_350400 0 7.870000e-08
I2621 n1_m1_196800_355200 0 3.557143e-07
I2622 n1_m1_196800_360000 0 7.772857e-07
I2623 n1_m1_196800_364800 0 1.158725e-06
I2624 n1_m1_196800_369600 0 1.738029e-06
I2625 n1_m1_196800_374400 0 1.638238e-07
I2626 n1_m1_196800_379200 0 3.669647e-07
I2627 n1_m1_196800_384000 0 1.849849e-06
I2628 n1_m1_196800_388800 0 9.777983e-07
I2629 n1_m1_196800_393600 0 5.135975e-07
I2630 n1_m1_196800_398400 0 6.810782e-07
I2631 n1_m1_196800_403200 0 5.379464e-07
I2632 n1_m1_196800_408000 0 7.362484e-07
I2633 n1_m1_196800_412800 0 4.345714e-07
I2634 n1_m1_196800_417600 0 5.382262e-07
I2635 n1_m1_196800_422400 0 3.265607e-07
I2636 n1_m1_196800_427200 0 1.038595e-07
I2637 n1_m1_196800_432000 0 1.351214e-07
I2638 n1_m1_196800_436800 0 4.936071e-08
I2639 n1_m1_196800_441600 0 1.545810e-07
I2640 n1_m1_196800_446400 0 1.160357e-07
I2641 n1_m1_196800_451200 0 1.177952e-07
I2642 n1_m1_196800_456000 0 1.120464e-07
I2643 n1_m1_196800_460800 0 1.785804e-07
I2644 n1_m1_196800_465600 0 1.824571e-07
I2645 n1_m1_196800_484800 0 6.362619e-08
I2646 n1_m1_196800_489600 0 5.371905e-08
I2647 n1_m1_196800_494400 0 4.991429e-08
I2648 n1_m1_196800_499200 0 3.594286e-08
I2649 n1_m1_196800_504000 0 8.450714e-08
I2650 n1_m1_196800_508800 0 1.183524e-07
I2651 n1_m1_196800_513600 0 1.073048e-07
I2652 n1_m1_196800_518400 0 7.894231e-08
I2653 n1_m1_196800_523200 0 1.036720e-07
I2654 n1_m1_196800_528000 0 1.396857e-07
I2655 n1_m1_196800_532800 0 7.713846e-08
I2656 n1_m1_196800_537600 0 1.204397e-07
I2657 n1_m1_196800_542400 0 7.013846e-08
I2658 n1_m1_196800_547200 0 1.252615e-07
I2659 n1_m1_196800_552000 0 6.895641e-08
I2660 n1_m1_196800_556800 0 2.433205e-08
I2661 n1_m1_196800_561600 0 7.380000e-08
I2662 n1_m1_196800_580800 0 5.066667e-07
I2663 n1_m1_196800_585600 0 3.166667e-07
I2664 n1_m1_201600_9600 0 3.480000e-09
I2665 n1_m1_201600_86400 0 2.102564e-07
I2666 n1_m1_201600_91200 0 9.630549e-08
I2667 n1_m1_201600_96000 0 8.557143e-08
I2668 n1_m1_201600_100800 0 5.491429e-08
I2669 n1_m1_201600_105600 0 1.549905e-07
I2670 n1_m1_201600_110400 0 1.159548e-07
I2671 n1_m1_201600_115200 0 6.943250e-08
I2672 n1_m1_201600_120000 0 4.587500e-08
I2673 n1_m1_201600_124800 0 7.501786e-08
I2674 n1_m1_201600_129600 0 8.102143e-08
I2675 n1_m1_201600_134400 0 1.596036e-07
I2676 n1_m1_201600_139200 0 2.615714e-07
I2677 n1_m1_201600_144000 0 5.042000e-07
I2678 n1_m1_201600_148800 0 1.053959e-07
I2679 n1_m1_201600_153600 0 2.670069e-07
I2680 n1_m1_201600_158400 0 8.114531e-08
I2681 n1_m1_201600_163200 0 1.273204e-07
I2682 n1_m1_201600_168000 0 1.596143e-07
I2683 n1_m1_201600_172800 0 9.608571e-08
I2684 n1_m1_201600_177600 0 3.709714e-07
I2685 n1_m1_201600_182400 0 9.048000e-08
I2686 n1_m1_201600_187200 0 2.151429e-08
I2687 n1_m1_201600_192000 0 1.955714e-07
I2688 n1_m1_201600_196800 0 1.210714e-07
I2689 n1_m1_201600_201600 0 2.804286e-07
I2690 n1_m1_201600_206400 0 5.235000e-08
I2691 n1_m1_201600_211200 0 2.924082e-08
I2692 n1_m1_201600_216000 0 1.690909e-07
I2693 n1_m1_201600_220800 0 5.770000e-08
I2694 n1_m1_201600_225600 0 2.981686e-07
I2695 n1_m1_201600_230400 0 3.346286e-07
I2696 n1_m1_201600_235200 0 5.874679e-07
I2697 n1_m1_201600_240000 0 1.682932e-07
I2698 n1_m1_201600_244800 0 1.294163e-07
I2699 n1_m1_201600_249600 0 1.785929e-07
I2700 n1_m1_201600_254400 0 3.660190e-08
I2701 n1_m1_201600_259200 0 6.989714e-08
I2702 n1_m1_201600_264000 0 5.645786e-07
I2703 n1_m1_201600_268800 0 1.614881e-07
I2704 n1_m1_201600_273600 0 8.863034e-07
I2705 n1_m1_201600_278400 0 2.058194e-06
I2706 n1_m1_201600_283200 0 4.045171e-07
I2707 n1_m1_201600_288000 0 7.841057e-07
I2708 n1_m1_201600_292800 0 3.977102e-07
I2709 n1_m1_201600_297600 0 3.303157e-07
I2710 n1_m1_201600_302400 0 9.993214e-08
I2711 n1_m1_201600_307200 0 1.580842e-07
I2712 n1_m1_201600_312000 0 2.240908e-07
I2713 n1_m1_201600_316800 0 1.304000e-07
I2714 n1_m1_201600_321600 0 6.621429e-07
I2715 n1_m1_201600_326400 0 1.345055e-06
I2716 n1_m1_201600_331200 0 3.126973e-07
I2717 n1_m1_201600_336000 0 3.031571e-07
I2718 n1_m1_201600_340800 0 3.070571e-07
I2719 n1_m1_201600_345600 0 7.444286e-08
I2720 n1_m1_201600_350400 0 5.287076e-07
I2721 n1_m1_201600_355200 0 3.584000e-07
I2722 n1_m1_201600_360000 0 5.649405e-07
I2723 n1_m1_201600_364800 0 6.520000e-08
I2724 n1_m1_201600_369600 0 1.351795e-06
I2725 n1_m1_201600_374400 0 1.311798e-07
I2726 n1_m1_201600_379200 0 5.094465e-07
I2727 n1_m1_201600_384000 0 2.085656e-06
I2728 n1_m1_201600_388800 0 8.242185e-07
I2729 n1_m1_201600_393600 0 2.479714e-07
I2730 n1_m1_201600_398400 0 6.777143e-08
I2731 n1_m1_201600_403200 0 6.425714e-08
I2732 n1_m1_201600_408000 0 7.752571e-07
I2733 n1_m1_201600_412800 0 2.285714e-08
I2734 n1_m1_201600_417600 0 1.919143e-07
I2735 n1_m1_201600_422400 0 1.774229e-07
I2736 n1_m1_201600_427200 0 8.838857e-08
I2737 n1_m1_201600_432000 0 5.709629e-07
I2738 n1_m1_201600_436800 0 3.995571e-07
I2739 n1_m1_201600_441600 0 1.863143e-07
I2740 n1_m1_201600_446400 0 1.736857e-07
I2741 n1_m1_201600_451200 0 8.261171e-07
I2742 n1_m1_201600_456000 0 2.632743e-07
I2743 n1_m1_201600_460800 0 8.532857e-08
I2744 n1_m1_201600_465600 0 7.042857e-08
I2745 n1_m1_201600_480000 0 3.720000e-08
I2746 n1_m1_201600_484800 0 1.301429e-07
I2747 n1_m1_201600_489600 0 1.038571e-07
I2748 n1_m1_201600_494400 0 8.029143e-08
I2749 n1_m1_201600_499200 0 8.757238e-08
I2750 n1_m1_201600_504000 0 2.229810e-07
I2751 n1_m1_201600_508800 0 9.601429e-08
I2752 n1_m1_201600_513600 0 1.455554e-07
I2753 n1_m1_201600_518400 0 3.290989e-08
I2754 n1_m1_201600_523200 0 2.980797e-08
I2755 n1_m1_201600_528000 0 1.645911e-07
I2756 n1_m1_201600_532800 0 4.171846e-08
I2757 n1_m1_201600_537600 0 9.617744e-08
I2758 n1_m1_201600_542400 0 2.603077e-08
I2759 n1_m1_201600_547200 0 8.166286e-08
I2760 n1_m1_201600_552000 0 6.221872e-08
I2761 n1_m1_201600_556800 0 1.358462e-08
I2762 n1_m1_201600_561600 0 1.381943e-07
I2763 n1_m1_201600_566400 0 4.988571e-08
I2764 n1_m1_206400_4800 0 3.950769e-08
I2765 n1_m1_206400_9600 0 3.461231e-08
I2766 n1_m1_206400_14400 0 8.610000e-08
I2767 n1_m1_206400_33600 0 3.217846e-07
I2768 n1_m1_206400_38400 0 1.533654e-07
I2769 n1_m1_206400_86400 0 9.910000e-08
I2770 n1_m1_206400_91200 0 7.581429e-08
I2771 n1_m1_206400_96000 0 1.347952e-07
I2772 n1_m1_206400_100800 0 2.179571e-07
I2773 n1_m1_206400_105600 0 5.358095e-08
I2774 n1_m1_206400_110400 0 4.848810e-08
I2775 n1_m1_206400_115200 0 1.138018e-07
I2776 n1_m1_206400_120000 0 1.266536e-07
I2777 n1_m1_206400_124800 0 1.474345e-07
I2778 n1_m1_206400_129600 0 2.700738e-07
I2779 n1_m1_206400_134400 0 9.827143e-08
I2780 n1_m1_206400_139200 0 1.410000e-07
I2781 n1_m1_206400_144000 0 1.209286e-07
I2782 n1_m1_206400_148800 0 1.682857e-07
I2783 n1_m1_206400_153600 0 4.306114e-07
I2784 n1_m1_206400_158400 0 9.351184e-08
I2785 n1_m1_206400_163200 0 1.532510e-07
I2786 n1_m1_206400_168000 0 1.329143e-07
I2787 n1_m1_206400_172800 0 2.835143e-07
I2788 n1_m1_206400_177600 0 5.839381e-07
I2789 n1_m1_206400_182400 0 6.324667e-07
I2790 n1_m1_206400_192000 0 2.372143e-07
I2791 n1_m1_206400_196800 0 2.341214e-07
I2792 n1_m1_206400_201600 0 3.278143e-07
I2793 n1_m1_206400_206400 0 8.966429e-08
I2794 n1_m1_206400_211200 0 1.748306e-07
I2795 n1_m1_206400_216000 0 2.352662e-07
I2796 n1_m1_206400_220800 0 2.833857e-07
I2797 n1_m1_206400_225600 0 1.380171e-07
I2798 n1_m1_206400_230400 0 1.942286e-07
I2799 n1_m1_206400_235200 0 3.924893e-07
I2800 n1_m1_206400_240000 0 8.400680e-08
I2801 n1_m1_206400_244800 0 7.266939e-08
I2802 n1_m1_206400_249600 0 3.749833e-07
I2803 n1_m1_206400_254400 0 2.096029e-07
I2804 n1_m1_206400_259200 0 1.703600e-07
I2805 n1_m1_206400_264000 0 1.740286e-07
I2806 n1_m1_206400_268800 0 7.011190e-08
I2807 n1_m1_206400_273600 0 2.882714e-07
I2808 n1_m1_206400_278400 0 7.314286e-09
I2809 n1_m1_206400_283200 0 6.106857e-08
I2810 n1_m1_206400_288000 0 1.452698e-07
I2811 n1_m1_206400_292800 0 1.059837e-07
I2812 n1_m1_206400_297600 0 1.057906e-07
I2813 n1_m1_206400_302400 0 1.711876e-07
I2814 n1_m1_206400_307200 0 2.710586e-07
I2815 n1_m1_206400_312000 0 4.297187e-07
I2816 n1_m1_206400_316800 0 1.042286e-07
I2817 n1_m1_206400_321600 0 3.322571e-07
I2818 n1_m1_206400_326400 0 1.040697e-06
I2819 n1_m1_206400_331200 0 3.005789e-07
I2820 n1_m1_206400_336000 0 1.481429e-07
I2821 n1_m1_206400_340800 0 1.077429e-07
I2822 n1_m1_206400_345600 0 1.421571e-07
I2823 n1_m1_206400_350400 0 3.395904e-07
I2824 n1_m1_206400_355200 0 4.805306e-07
I2825 n1_m1_206400_360000 0 8.245595e-07
I2826 n1_m1_206400_364800 0 1.630000e-08
I2827 n1_m1_206400_369600 0 6.430714e-07
I2828 n1_m1_206400_374400 0 1.056202e-07
I2829 n1_m1_206400_379200 0 1.250440e-07
I2830 n1_m1_206400_384000 0 9.361748e-07
I2831 n1_m1_206400_388800 0 5.744076e-07
I2832 n1_m1_206400_393600 0 6.788810e-08
I2833 n1_m1_206400_398400 0 1.176286e-07
I2834 n1_m1_206400_403200 0 3.810000e-08
I2835 n1_m1_206400_408000 0 1.492000e-07
I2836 n1_m1_206400_412800 0 2.468000e-07
I2837 n1_m1_206400_417600 0 3.281000e-07
I2838 n1_m1_206400_422400 0 1.199404e-07
I2839 n1_m1_206400_427200 0 2.707053e-07
I2840 n1_m1_206400_432000 0 1.621656e-06
I2841 n1_m1_206400_436800 0 6.726548e-07
I2842 n1_m1_206400_441600 0 2.507952e-07
I2843 n1_m1_206400_446400 0 5.392857e-07
I2844 n1_m1_206400_451200 0 2.098143e-07
I2845 n1_m1_206400_456000 0 5.017143e-08
I2846 n1_m1_206400_460800 0 6.307143e-08
I2847 n1_m1_206400_465600 0 5.651429e-08
I2848 n1_m1_206400_480000 0 5.965714e-08
I2849 n1_m1_206400_484800 0 1.007714e-07
I2850 n1_m1_206400_489600 0 7.211429e-08
I2851 n1_m1_206400_494400 0 6.081333e-08
I2852 n1_m1_206400_499200 0 9.615143e-08
I2853 n1_m1_206400_504000 0 6.374956e-07
I2854 n1_m1_206400_508800 0 1.211571e-07
I2855 n1_m1_206400_513600 0 1.474304e-07
I2856 n1_m1_206400_518400 0 7.125934e-08
I2857 n1_m1_206400_523200 0 1.139418e-07
I2858 n1_m1_206400_528000 0 3.084565e-07
I2859 n1_m1_206400_532800 0 9.159231e-08
I2860 n1_m1_206400_537600 0 1.286185e-07
I2861 n1_m1_206400_542400 0 1.156692e-07
I2862 n1_m1_206400_547200 0 1.389879e-07
I2863 n1_m1_206400_552000 0 1.837641e-07
I2864 n1_m1_206400_556800 0 2.253846e-08
I2865 n1_m1_206400_561600 0 1.414431e-07
I2866 n1_m1_206400_566400 0 2.693878e-08
I2867 n1_m1_206400_580800 0 1.070769e-08
I2868 n1_m1_206400_585600 0 2.809231e-08
I2869 n1_m1_211200_4800 0 3.292308e-09
I2870 n1_m1_211200_9600 0 1.467436e-08
I2871 n1_m1_211200_33600 0 5.051538e-07
I2872 n1_m1_211200_38400 0 3.117462e-07
I2873 n1_m1_211200_86400 0 2.591026e-08
I2874 n1_m1_211200_91200 0 9.646355e-08
I2875 n1_m1_211200_96000 0 1.669262e-07
I2876 n1_m1_211200_100800 0 3.045714e-08
I2877 n1_m1_211200_105600 0 1.209750e-07
I2878 n1_m1_211200_110400 0 7.571429e-08
I2879 n1_m1_211200_115200 0 8.680714e-08
I2880 n1_m1_211200_120000 0 2.191554e-07
I2881 n1_m1_211200_124800 0 1.013333e-07
I2882 n1_m1_211200_129600 0 1.358905e-07
I2883 n1_m1_211200_134400 0 1.078714e-07
I2884 n1_m1_211200_139200 0 6.142857e-08
I2885 n1_m1_211200_144000 0 3.541429e-07
I2886 n1_m1_211200_148800 0 3.515952e-07
I2887 n1_m1_211200_153600 0 1.925000e-07
I2888 n1_m1_211200_158400 0 5.670000e-08
I2889 n1_m1_211200_163200 0 1.027310e-07
I2890 n1_m1_211200_168000 0 1.260667e-07
I2891 n1_m1_211200_172800 0 1.552000e-07
I2892 n1_m1_211200_177600 0 4.027857e-07
I2893 n1_m1_211200_182400 0 1.070905e-07
I2894 n1_m1_211200_187200 0 6.300000e-08
I2895 n1_m1_211200_192000 0 2.486179e-07
I2896 n1_m1_211200_196800 0 1.826357e-07
I2897 n1_m1_211200_201600 0 8.008190e-07
I2898 n1_m1_211200_206400 0 9.972857e-08
I2899 n1_m1_211200_211200 0 7.524286e-08
I2900 n1_m1_211200_216000 0 2.480952e-07
I2901 n1_m1_211200_220800 0 2.362286e-07
I2902 n1_m1_211200_225600 0 2.032625e-07
I2903 n1_m1_211200_230400 0 5.845714e-08
I2904 n1_m1_211200_235200 0 1.565571e-07
I2905 n1_m1_211200_240000 0 1.385375e-07
I2906 n1_m1_211200_244800 0 3.222000e-07
I2907 n1_m1_211200_249600 0 1.137571e-07
I2908 n1_m1_211200_254400 0 4.325714e-08
I2909 n1_m1_211200_259200 0 1.593143e-07
I2910 n1_m1_211200_264000 0 2.149000e-07
I2911 n1_m1_211200_268800 0 9.376964e-08
I2912 n1_m1_211200_273600 0 3.913929e-08
I2913 n1_m1_211200_278400 0 1.978571e-08
I2914 n1_m1_211200_283200 0 1.041280e-07
I2915 n1_m1_211200_288000 0 3.020984e-07
I2916 n1_m1_211200_292800 0 4.139909e-07
I2917 n1_m1_211200_297600 0 1.226865e-07
I2918 n1_m1_211200_302400 0 7.368024e-08
I2919 n1_m1_211200_307200 0 1.466220e-07
I2920 n1_m1_211200_312000 0 1.202214e-07
I2921 n1_m1_211200_316800 0 7.590952e-08
I2922 n1_m1_211200_321600 0 3.199738e-07
I2923 n1_m1_211200_326400 0 2.575048e-07
I2924 n1_m1_211200_331200 0 2.817190e-07
I2925 n1_m1_211200_336000 0 6.240595e-07
I2926 n1_m1_211200_340800 0 5.769429e-07
I2927 n1_m1_211200_345600 0 4.065429e-07
I2928 n1_m1_211200_350400 0 8.363378e-07
I2929 n1_m1_211200_355200 0 9.635170e-07
I2930 n1_m1_211200_360000 0 1.387222e-06
I2931 n1_m1_211200_364800 0 5.945238e-07
I2932 n1_m1_211200_369600 0 2.927095e-07
I2933 n1_m1_211200_374400 0 8.920000e-08
I2934 n1_m1_211200_379200 0 1.167524e-07
I2935 n1_m1_211200_384000 0 7.882062e-07
I2936 n1_m1_211200_388800 0 2.919748e-07
I2937 n1_m1_211200_393600 0 7.344619e-07
I2938 n1_m1_211200_398400 0 1.160000e-07
I2939 n1_m1_211200_403200 0 6.643810e-08
I2940 n1_m1_211200_408000 0 1.082696e-07
I2941 n1_m1_211200_412800 0 5.388571e-08
I2942 n1_m1_211200_417600 0 2.098714e-07
I2943 n1_m1_211200_422400 0 1.021367e-07
I2944 n1_m1_211200_427200 0 1.531918e-07
I2945 n1_m1_211200_432000 0 1.050810e-07
I2946 n1_m1_211200_436800 0 1.342149e-07
I2947 n1_m1_211200_441600 0 3.819476e-07
I2948 n1_m1_211200_446400 0 1.392857e-07
I2949 n1_m1_211200_451200 0 4.580714e-08
I2950 n1_m1_211200_456000 0 1.435286e-07
I2951 n1_m1_211200_460800 0 1.712857e-07
I2952 n1_m1_211200_465600 0 2.635714e-07
I2953 n1_m1_211200_470400 0 2.151905e-08
I2954 n1_m1_211200_475200 0 4.064286e-08
I2955 n1_m1_211200_480000 0 1.513643e-07
I2956 n1_m1_211200_484800 0 8.367619e-08
I2957 n1_m1_211200_489600 0 1.648411e-07
I2958 n1_m1_211200_494400 0 9.101667e-08
I2959 n1_m1_211200_499200 0 1.074250e-07
I2960 n1_m1_211200_504000 0 6.333330e-07
I2961 n1_m1_211200_508800 0 2.080286e-07
I2962 n1_m1_211200_513600 0 2.257089e-07
I2963 n1_m1_211200_518400 0 3.783077e-08
I2964 n1_m1_211200_523200 0 1.072216e-07
I2965 n1_m1_211200_528000 0 2.414810e-07
I2966 n1_m1_211200_532800 0 4.183231e-07
I2967 n1_m1_211200_537600 0 2.667692e-07
I2968 n1_m1_211200_542400 0 1.794077e-07
I2969 n1_m1_211200_547200 0 3.364231e-08
I2970 n1_m1_211200_552000 0 1.106949e-07
I2971 n1_m1_211200_556800 0 9.464615e-08
I2972 n1_m1_211200_561600 0 8.946259e-08
I2973 n1_m1_211200_566400 0 8.329859e-08
I2974 n1_m1_211200_571200 0 1.907692e-08
I2975 n1_m1_211200_576000 0 2.546032e-07
I2976 n1_m1_211200_580800 0 1.007158e-06
I2977 n1_m1_211200_585600 0 1.657782e-07
I2978 n1_m1_216000_4800 0 5.596923e-08
I2979 n1_m1_216000_9600 0 2.206410e-08
I2980 n1_m1_216000_14400 0 2.905714e-06
I2981 n1_m1_216000_19200 0 3.874286e-06
I2982 n1_m1_216000_24000 0 1.368000e-06
I2983 n1_m1_216000_33600 0 1.115385e-07
I2984 n1_m1_216000_38400 0 3.658115e-07
I2985 n1_m1_216000_81600 0 1.346429e-08
I2986 n1_m1_216000_86400 0 1.956370e-07
I2987 n1_m1_216000_91200 0 9.915348e-08
I2988 n1_m1_216000_96000 0 2.349500e-07
I2989 n1_m1_216000_100800 0 9.035143e-08
I2990 n1_m1_216000_105600 0 2.118679e-07
I2991 n1_m1_216000_110400 0 2.120714e-07
I2992 n1_m1_216000_115200 0 1.264071e-07
I2993 n1_m1_216000_120000 0 2.774637e-07
I2994 n1_m1_216000_124800 0 2.443214e-07
I2995 n1_m1_216000_129600 0 3.793857e-07
I2996 n1_m1_216000_134400 0 3.694571e-07
I2997 n1_m1_216000_139200 0 5.634048e-07
I2998 n1_m1_216000_144000 0 5.487619e-07
I2999 n1_m1_216000_148800 0 2.024419e-07
I3000 n1_m1_216000_153600 0 2.524143e-07
I3001 n1_m1_216000_158400 0 1.426143e-07
I3002 n1_m1_216000_163200 0 1.710881e-07
I3003 n1_m1_216000_168000 0 2.583087e-07
I3004 n1_m1_216000_172800 0 3.258941e-07
I3005 n1_m1_216000_177600 0 1.764940e-06
I3006 n1_m1_216000_182400 0 8.355556e-07
I3007 n1_m1_216000_187200 0 3.680000e-07
I3008 n1_m1_216000_192000 0 4.810250e-07
I3009 n1_m1_216000_196800 0 1.591857e-07
I3010 n1_m1_216000_201600 0 4.523810e-07
I3011 n1_m1_216000_206400 0 2.749000e-07
I3012 n1_m1_216000_211200 0 2.643429e-07
I3013 n1_m1_216000_216000 0 8.374190e-07
I3014 n1_m1_216000_220800 0 4.604143e-07
I3015 n1_m1_216000_225600 0 5.439832e-07
I3016 n1_m1_216000_230400 0 2.203143e-07
I3017 n1_m1_216000_235200 0 2.165857e-07
I3018 n1_m1_216000_240000 0 1.719196e-07
I3019 n1_m1_216000_244800 0 3.338286e-07
I3020 n1_m1_216000_249600 0 7.606429e-07
I3021 n1_m1_216000_254400 0 1.144714e-07
I3022 n1_m1_216000_259200 0 4.017143e-07
I3023 n1_m1_216000_264000 0 1.596571e-07
I3024 n1_m1_216000_268800 0 8.089607e-08
I3025 n1_m1_216000_273600 0 2.401369e-07
I3026 n1_m1_216000_278400 0 4.071837e-07
I3027 n1_m1_216000_283200 0 2.068941e-07
I3028 n1_m1_216000_288000 0 7.696730e-07
I3029 n1_m1_216000_292800 0 1.664397e-06
I3030 n1_m1_216000_297600 0 3.667143e-07
I3031 n1_m1_216000_302400 0 2.771036e-07
I3032 n1_m1_216000_307200 0 2.233304e-07
I3033 n1_m1_216000_312000 0 6.461929e-07
I3034 n1_m1_216000_316800 0 2.036333e-07
I3035 n1_m1_216000_321600 0 2.397119e-07
I3036 n1_m1_216000_326400 0 5.362857e-07
I3037 n1_m1_216000_331200 0 3.340905e-07
I3038 n1_m1_216000_336000 0 5.180833e-07
I3039 n1_m1_216000_340800 0 2.322857e-07
I3040 n1_m1_216000_345600 0 5.951000e-07
I3041 n1_m1_216000_350400 0 5.371500e-07
I3042 n1_m1_216000_355200 0 3.182381e-07
I3043 n1_m1_216000_360000 0 3.251929e-06
I3044 n1_m1_216000_364800 0 1.252619e-06
I3045 n1_m1_216000_369600 0 1.190162e-06
I3046 n1_m1_216000_374400 0 1.212857e-07
I3047 n1_m1_216000_379200 0 2.131667e-07
I3048 n1_m1_216000_384000 0 1.761174e-07
I3049 n1_m1_216000_388800 0 2.794571e-07
I3050 n1_m1_216000_393600 0 3.204810e-07
I3051 n1_m1_216000_398400 0 1.976857e-07
I3052 n1_m1_216000_403200 0 1.031333e-07
I3053 n1_m1_216000_408000 0 1.570875e-07
I3054 n1_m1_216000_412800 0 6.604286e-08
I3055 n1_m1_216000_417600 0 3.052607e-07
I3056 n1_m1_216000_422400 0 1.416000e-07
I3057 n1_m1_216000_427200 0 3.254000e-07
I3058 n1_m1_216000_432000 0 4.687286e-07
I3059 n1_m1_216000_436800 0 2.621911e-07
I3060 n1_m1_216000_441600 0 3.564500e-07
I3061 n1_m1_216000_446400 0 8.450000e-08
I3062 n1_m1_216000_451200 0 1.060214e-07
I3063 n1_m1_216000_456000 0 1.877000e-07
I3064 n1_m1_216000_460800 0 1.420000e-07
I3065 n1_m1_216000_465600 0 1.291429e-07
I3066 n1_m1_216000_470400 0 6.448095e-08
I3067 n1_m1_216000_475200 0 2.252381e-07
I3068 n1_m1_216000_480000 0 1.460881e-07
I3069 n1_m1_216000_484800 0 9.392381e-08
I3070 n1_m1_216000_489600 0 1.272732e-07
I3071 n1_m1_216000_494400 0 7.237381e-08
I3072 n1_m1_216000_499200 0 1.222607e-07
I3073 n1_m1_216000_504000 0 3.231952e-07
I3074 n1_m1_216000_508800 0 4.032000e-07
I3075 n1_m1_216000_513600 0 4.623339e-07
I3076 n1_m1_216000_518400 0 9.961538e-08
I3077 n1_m1_216000_523200 0 2.457846e-07
I3078 n1_m1_216000_528000 0 9.994000e-07
I3079 n1_m1_216000_532800 0 3.840667e-07
I3080 n1_m1_216000_537600 0 1.721231e-07
I3081 n1_m1_216000_542400 0 7.987692e-08
I3082 n1_m1_216000_547200 0 1.545731e-07
I3083 n1_m1_216000_552000 0 3.207923e-07
I3084 n1_m1_216000_556800 0 2.265846e-07
I3085 n1_m1_216000_561600 0 5.805714e-08
I3086 n1_m1_216000_566400 0 1.424659e-07
I3087 n1_m1_216000_571200 0 1.050769e-07
I3088 n1_m1_216000_576000 0 1.460672e-07
I3089 n1_m1_216000_580800 0 1.024557e-06
I3090 n1_m1_216000_585600 0 3.061795e-07
I3091 n1_m1_220800_9600 0 5.681250e-07
I3092 n1_m1_220800_24000 0 4.000000e-07
I3093 n1_m1_220800_81600 0 1.223214e-07
I3094 n1_m1_220800_86400 0 4.887016e-07
I3095 n1_m1_220800_91200 0 2.054614e-07
I3096 n1_m1_220800_96000 0 1.871952e-07
I3097 n1_m1_220800_100800 0 5.305810e-08
I3098 n1_m1_220800_105600 0 6.885714e-08
I3099 n1_m1_220800_110400 0 2.057143e-08
I3100 n1_m1_220800_115200 0 2.199429e-07
I3101 n1_m1_220800_120000 0 5.723524e-07
I3102 n1_m1_220800_124800 0 4.607857e-08
I3103 n1_m1_220800_129600 0 7.982886e-07
I3104 n1_m1_220800_134400 0 2.188571e-07
I3105 n1_m1_220800_139200 0 1.312524e-07
I3106 n1_m1_220800_144000 0 2.023819e-07
I3107 n1_m1_220800_148800 0 1.314371e-07
I3108 n1_m1_220800_153600 0 4.189373e-07
I3109 n1_m1_220800_158400 0 3.993714e-07
I3110 n1_m1_220800_163200 0 8.877675e-08
I3111 n1_m1_220800_168000 0 3.764440e-07
I3112 n1_m1_220800_172800 0 2.944538e-07
I3113 n1_m1_220800_177600 0 1.726647e-06
I3114 n1_m1_220800_182400 0 1.266504e-06
I3115 n1_m1_220800_187200 0 6.086723e-07
I3116 n1_m1_220800_192000 0 3.507333e-07
I3117 n1_m1_220800_196800 0 3.910952e-07
I3118 n1_m1_220800_201600 0 2.754762e-07
I3119 n1_m1_220800_206400 0 3.873571e-07
I3120 n1_m1_220800_211200 0 1.801916e-07
I3121 n1_m1_220800_216000 0 2.352571e-07
I3122 n1_m1_220800_220800 0 9.891429e-08
I3123 n1_m1_220800_225600 0 1.713400e-07
I3124 n1_m1_220800_230400 0 6.400000e-08
I3125 n1_m1_220800_235200 0 1.631500e-07
I3126 n1_m1_220800_240000 0 1.482906e-07
I3127 n1_m1_220800_244800 0 8.161224e-08
I3128 n1_m1_220800_249600 0 2.847971e-07
I3129 n1_m1_220800_254400 0 1.012571e-07
I3130 n1_m1_220800_259200 0 2.495886e-07
I3131 n1_m1_220800_264000 0 9.200571e-08
I3132 n1_m1_220800_268800 0 9.496857e-08
I3133 n1_m1_220800_273600 0 1.907381e-07
I3134 n1_m1_220800_278400 0 6.938776e-08
I3135 n1_m1_220800_283200 0 1.295884e-07
I3136 n1_m1_220800_288000 0 2.199381e-07
I3137 n1_m1_220800_292800 0 3.229524e-07
I3138 n1_m1_220800_297600 0 3.630857e-07
I3139 n1_m1_220800_302400 0 2.240190e-07
I3140 n1_m1_220800_307200 0 2.420476e-07
I3141 n1_m1_220800_312000 0 8.101429e-07
I3142 n1_m1_220800_316800 0 1.849889e-07
I3143 n1_m1_220800_321600 0 2.771571e-07
I3144 n1_m1_220800_326400 0 1.666000e-07
I3145 n1_m1_220800_331200 0 2.061857e-07
I3146 n1_m1_220800_336000 0 4.879524e-07
I3147 n1_m1_220800_340800 0 4.693714e-07
I3148 n1_m1_220800_345600 0 8.668310e-07
I3149 n1_m1_220800_350400 0 8.761714e-07
I3150 n1_m1_220800_355200 0 3.834286e-07
I3151 n1_m1_220800_360000 0 1.305278e-06
I3152 n1_m1_220800_364800 0 8.378571e-07
I3153 n1_m1_220800_369600 0 1.268762e-07
I3154 n1_m1_220800_374400 0 1.844000e-07
I3155 n1_m1_220800_379200 0 1.589486e-07
I3156 n1_m1_220800_384000 0 1.089041e-07
I3157 n1_m1_220800_388800 0 7.802449e-08
I3158 n1_m1_220800_393600 0 9.736190e-08
I3159 n1_m1_220800_398400 0 1.002571e-07
I3160 n1_m1_220800_403200 0 9.008929e-08
I3161 n1_m1_220800_408000 0 2.425095e-07
I3162 n1_m1_220800_412800 0 1.638429e-07
I3163 n1_m1_220800_417600 0 1.476393e-07
I3164 n1_m1_220800_422400 0 2.971024e-07
I3165 n1_m1_220800_427200 0 1.394571e-07
I3166 n1_m1_220800_432000 0 1.699595e-07
I3167 n1_m1_220800_436800 0 4.699643e-08
I3168 n1_m1_220800_441600 0 1.127014e-07
I3169 n1_m1_220800_446400 0 6.310714e-08
I3170 n1_m1_220800_451200 0 1.472714e-07
I3171 n1_m1_220800_456000 0 2.123143e-07
I3172 n1_m1_220800_460800 0 1.277143e-07
I3173 n1_m1_220800_465600 0 1.526857e-07
I3174 n1_m1_220800_470400 0 5.178571e-09
I3175 n1_m1_220800_475200 0 2.911905e-08
I3176 n1_m1_220800_480000 0 8.244494e-07
I3177 n1_m1_220800_484800 0 1.124955e-07
I3178 n1_m1_220800_489600 0 1.329902e-07
I3179 n1_m1_220800_494400 0 1.082305e-07
I3180 n1_m1_220800_499200 0 2.561190e-07
I3181 n1_m1_220800_504000 0 2.046976e-07
I3182 n1_m1_220800_508800 0 1.432857e-07
I3183 n1_m1_220800_513600 0 1.450543e-07
I3184 n1_m1_220800_518400 0 2.454615e-07
I3185 n1_m1_220800_523200 0 1.120099e-07
I3186 n1_m1_220800_528000 0 3.185286e-07
I3187 n1_m1_220800_532800 0 1.003256e-07
I3188 n1_m1_220800_537600 0 1.291615e-07
I3189 n1_m1_220800_542400 0 1.912462e-07
I3190 n1_m1_220800_547200 0 1.298288e-07
I3191 n1_m1_220800_552000 0 1.560385e-07
I3192 n1_m1_220800_556800 0 7.090769e-08
I3193 n1_m1_220800_561600 0 1.632400e-07
I3194 n1_m1_220800_566400 0 1.397231e-07
I3195 n1_m1_220800_571200 0 2.924769e-07
I3196 n1_m1_220800_576000 0 1.661538e-08
I3197 n1_m1_220800_580800 0 5.843077e-07
I3198 n1_m1_220800_585600 0 3.371246e-07
I3199 n1_m1_225600_4800 0 5.104615e-08
I3200 n1_m1_225600_9600 0 4.461288e-07
I3201 n1_m1_225600_28800 0 1.465714e-08
I3202 n1_m1_225600_33600 0 7.215824e-08
I3203 n1_m1_225600_38400 0 1.538462e-08
I3204 n1_m1_225600_43200 0 1.491462e-07
I3205 n1_m1_225600_48000 0 1.554253e-07
I3206 n1_m1_225600_52800 0 1.107286e-07
I3207 n1_m1_225600_57600 0 4.237429e-08
I3208 n1_m1_225600_62400 0 2.369429e-07
I3209 n1_m1_225600_67200 0 1.227429e-07
I3210 n1_m1_225600_72000 0 5.160000e-08
I3211 n1_m1_225600_76800 0 1.949714e-07
I3212 n1_m1_225600_81600 0 1.785286e-07
I3213 n1_m1_225600_86400 0 4.338192e-07
I3214 n1_m1_225600_91200 0 1.526767e-08
I3215 n1_m1_225600_96000 0 7.624762e-08
I3216 n1_m1_225600_100800 0 2.795986e-08
I3217 n1_m1_225600_105600 0 7.793061e-08
I3218 n1_m1_225600_110400 0 8.464286e-08
I3219 n1_m1_225600_115200 0 7.545143e-08
I3220 n1_m1_225600_120000 0 1.387029e-07
I3221 n1_m1_225600_124800 0 8.351429e-08
I3222 n1_m1_225600_129600 0 1.555069e-07
I3223 n1_m1_225600_134400 0 1.130388e-07
I3224 n1_m1_225600_139200 0 2.477143e-08
I3225 n1_m1_225600_144000 0 4.282705e-07
I3226 n1_m1_225600_148800 0 1.860686e-07
I3227 n1_m1_225600_153600 0 1.517847e-07
I3228 n1_m1_225600_158400 0 1.168408e-07
I3229 n1_m1_225600_163200 0 2.609042e-07
I3230 n1_m1_225600_168000 0 1.297395e-06
I3231 n1_m1_225600_172800 0 4.759664e-07
I3232 n1_m1_225600_177600 0 1.434241e-06
I3233 n1_m1_225600_182400 0 1.003464e-06
I3234 n1_m1_225600_187200 0 6.421214e-07
I3235 n1_m1_225600_192000 0 4.399048e-07
I3236 n1_m1_225600_196800 0 4.711905e-07
I3237 n1_m1_225600_201600 0 5.692095e-07
I3238 n1_m1_225600_206400 0 4.611538e-07
I3239 n1_m1_225600_211200 0 4.670798e-07
I3240 n1_m1_225600_216000 0 1.549571e-07
I3241 n1_m1_225600_220800 0 1.035571e-07
I3242 n1_m1_225600_225600 0 4.778343e-07
I3243 n1_m1_225600_230400 0 8.129143e-08
I3244 n1_m1_225600_235200 0 5.826429e-08
I3245 n1_m1_225600_240000 0 7.099796e-08
I3246 n1_m1_225600_244800 0 1.360449e-07
I3247 n1_m1_225600_249600 0 5.502829e-07
I3248 n1_m1_225600_254400 0 2.420114e-07
I3249 n1_m1_225600_259200 0 8.778286e-08
I3250 n1_m1_225600_264000 0 1.904229e-07
I3251 n1_m1_225600_268800 0 4.058086e-07
I3252 n1_m1_225600_273600 0 7.122857e-07
I3253 n1_m1_225600_278400 0 2.142857e-07
I3254 n1_m1_225600_283200 0 1.296895e-07
I3255 n1_m1_225600_288000 0 2.119619e-07
I3256 n1_m1_225600_292800 0 4.240476e-07
I3257 n1_m1_225600_297600 0 4.169371e-07
I3258 n1_m1_225600_302400 0 1.784467e-07
I3259 n1_m1_225600_307200 0 8.823810e-08
I3260 n1_m1_225600_312000 0 4.128286e-07
I3261 n1_m1_225600_316800 0 1.459810e-07
I3262 n1_m1_225600_321600 0 1.570019e-07
I3263 n1_m1_225600_331200 0 5.897714e-07
I3264 n1_m1_225600_336000 0 2.898905e-07
I3265 n1_m1_225600_340800 0 5.228706e-07
I3266 n1_m1_225600_345600 0 1.992951e-07
I3267 n1_m1_225600_350400 0 8.043429e-07
I3268 n1_m1_225600_355200 0 2.925714e-08
I3269 n1_m1_225600_360000 0 5.364000e-07
I3270 n1_m1_225600_364800 0 6.836104e-07
I3271 n1_m1_225600_369600 0 1.177010e-06
I3272 n1_m1_225600_374400 0 1.625286e-07
I3273 n1_m1_225600_379200 0 6.536000e-08
I3274 n1_m1_225600_384000 0 8.248163e-08
I3275 n1_m1_225600_388800 0 1.079612e-07
I3276 n1_m1_225600_393600 0 2.350143e-07
I3277 n1_m1_225600_398400 0 1.038776e-07
I3278 n1_m1_225600_403200 0 9.461888e-08
I3279 n1_m1_225600_408000 0 1.919333e-07
I3280 n1_m1_225600_412800 0 2.966857e-07
I3281 n1_m1_225600_417600 0 3.719429e-07
I3282 n1_m1_225600_422400 0 1.821405e-07
I3283 n1_m1_225600_427200 0 1.429429e-07
I3284 n1_m1_225600_432000 0 3.478119e-07
I3285 n1_m1_225600_436800 0 1.106229e-07
I3286 n1_m1_225600_441600 0 2.117057e-07
I3287 n1_m1_225600_446400 0 4.089286e-08
I3288 n1_m1_225600_451200 0 6.298571e-08
I3289 n1_m1_225600_456000 0 5.655714e-08
I3290 n1_m1_225600_460800 0 5.728571e-08
I3291 n1_m1_225600_465600 0 7.483714e-07
I3292 n1_m1_225600_470400 0 1.127714e-07
I3293 n1_m1_225600_475200 0 8.500000e-08
I3294 n1_m1_225600_480000 0 1.272954e-07
I3295 n1_m1_225600_484800 0 1.137759e-07
I3296 n1_m1_225600_489600 0 7.188122e-08
I3297 n1_m1_225600_494400 0 1.057600e-07
I3298 n1_m1_225600_499200 0 1.351381e-07
I3299 n1_m1_225600_504000 0 7.694871e-07
I3300 n1_m1_225600_508800 0 3.368686e-07
I3301 n1_m1_225600_513600 0 1.475886e-07
I3302 n1_m1_225600_518400 0 2.730846e-07
I3303 n1_m1_225600_523200 0 3.389011e-07
I3304 n1_m1_225600_528000 0 3.286857e-07
I3305 n1_m1_225600_532800 0 1.893631e-07
I3306 n1_m1_225600_537600 0 1.657862e-07
I3307 n1_m1_225600_542400 0 2.303308e-07
I3308 n1_m1_225600_547200 0 6.842500e-08
I3309 n1_m1_225600_552000 0 5.958462e-08
I3310 n1_m1_225600_556800 0 5.261538e-08
I3311 n1_m1_225600_561600 0 2.907486e-07
I3312 n1_m1_225600_566400 0 1.228022e-07
I3313 n1_m1_225600_571200 0 9.343590e-08
I3314 n1_m1_225600_576000 0 2.400000e-07
I3315 n1_m1_225600_580800 0 2.423077e-07
I3316 n1_m1_225600_585600 0 1.600023e-07
I3317 n1_m1_230400_4800 0 1.975385e-08
I3318 n1_m1_230400_9600 0 9.283962e-07
I3319 n1_m1_230400_28800 0 9.032857e-08
I3320 n1_m1_230400_33600 0 2.764548e-07
I3321 n1_m1_230400_38400 0 1.461000e-07
I3322 n1_m1_230400_43200 0 8.673077e-08
I3323 n1_m1_230400_48000 0 1.883407e-07
I3324 n1_m1_230400_52800 0 8.717857e-08
I3325 n1_m1_230400_57600 0 1.651500e-07
I3326 n1_m1_230400_62400 0 5.084762e-08
I3327 n1_m1_230400_67200 0 7.213571e-08
I3328 n1_m1_230400_72000 0 1.561830e-07
I3329 n1_m1_230400_76800 0 2.558366e-07
I3330 n1_m1_230400_81600 0 2.721179e-07
I3331 n1_m1_230400_86400 0 1.029000e-07
I3332 n1_m1_230400_91200 0 2.080000e-07
I3333 n1_m1_230400_96000 0 2.396786e-07
I3334 n1_m1_230400_100800 0 5.475238e-08
I3335 n1_m1_230400_105600 0 1.062714e-07
I3336 n1_m1_230400_110400 0 1.230714e-07
I3337 n1_m1_230400_115200 0 8.492798e-08
I3338 n1_m1_230400_120000 0 5.573214e-08
I3339 n1_m1_230400_124800 0 9.201786e-08
I3340 n1_m1_230400_129600 0 1.169000e-07
I3341 n1_m1_230400_134400 0 7.986190e-08
I3342 n1_m1_230400_139200 0 2.156429e-07
I3343 n1_m1_230400_144000 0 1.435238e-07
I3344 n1_m1_230400_148800 0 8.117143e-08
I3345 n1_m1_230400_153600 0 2.133524e-07
I3346 n1_m1_230400_158400 0 1.731119e-07
I3347 n1_m1_230400_163200 0 1.302439e-06
I3348 n1_m1_230400_168000 0 1.386723e-06
I3349 n1_m1_230400_172800 0 9.608067e-07
I3350 n1_m1_230400_177600 0 1.038622e-06
I3351 n1_m1_230400_182400 0 1.300840e-06
I3352 n1_m1_230400_187200 0 1.363361e-06
I3353 n1_m1_230400_192000 0 7.225983e-07
I3354 n1_m1_230400_196800 0 5.196000e-07
I3355 n1_m1_230400_201600 0 8.488924e-07
I3356 n1_m1_230400_206400 0 4.777213e-07
I3357 n1_m1_230400_211200 0 1.603000e-07
I3358 n1_m1_230400_216000 0 2.670786e-07
I3359 n1_m1_230400_220800 0 9.535714e-07
I3360 n1_m1_230400_225600 0 2.007857e-07
I3361 n1_m1_230400_230400 0 8.802857e-08
I3362 n1_m1_230400_235200 0 7.365238e-08
I3363 n1_m1_230400_240000 0 1.425893e-07
I3364 n1_m1_230400_244800 0 9.785595e-08
I3365 n1_m1_230400_249600 0 1.614548e-07
I3366 n1_m1_230400_254400 0 1.545786e-07
I3367 n1_m1_230400_259200 0 2.714000e-07
I3368 n1_m1_230400_264000 0 1.332024e-07
I3369 n1_m1_230400_268800 0 1.919071e-07
I3370 n1_m1_230400_273600 0 4.635286e-06
I3371 n1_m1_230400_278400 0 2.923571e-07
I3372 n1_m1_230400_283200 0 3.950857e-07
I3373 n1_m1_230400_288000 0 2.354286e-06
I3374 n1_m1_230400_292800 0 5.300000e-08
I3375 n1_m1_230400_297600 0 6.294286e-08
I3376 n1_m1_230400_302400 0 1.754810e-07
I3377 n1_m1_230400_307200 0 7.370357e-06
I3378 n1_m1_230400_312000 0 3.184032e-06
I3379 n1_m1_230400_316800 0 7.251571e-08
I3380 n1_m1_230400_321600 0 1.379286e-07
I3381 n1_m1_230400_326400 0 2.080840e-07
I3382 n1_m1_230400_331200 0 2.113289e-07
I3383 n1_m1_230400_336000 0 4.519286e-07
I3384 n1_m1_230400_340800 0 4.375429e-07
I3385 n1_m1_230400_345600 0 1.018657e-06
I3386 n1_m1_230400_350400 0 5.250321e-07
I3387 n1_m1_230400_355200 0 2.789571e-07
I3388 n1_m1_230400_360000 0 8.624524e-07
I3389 n1_m1_230400_364800 0 5.300476e-07
I3390 n1_m1_230400_369600 0 5.864802e-07
I3391 n1_m1_230400_374400 0 1.032458e-07
I3392 n1_m1_230400_379200 0 9.106429e-08
I3393 n1_m1_230400_384000 0 2.033952e-07
I3394 n1_m1_230400_388800 0 1.253446e-07
I3395 n1_m1_230400_393600 0 3.303625e-07
I3396 n1_m1_230400_398400 0 3.919643e-08
I3397 n1_m1_230400_403200 0 5.500357e-08
I3398 n1_m1_230400_408000 0 9.442500e-08
I3399 n1_m1_230400_412800 0 9.501667e-08
I3400 n1_m1_230400_417600 0 1.025000e-07
I3401 n1_m1_230400_422400 0 1.828250e-07
I3402 n1_m1_230400_427200 0 7.917143e-07
I3403 n1_m1_230400_432000 0 1.439857e-07
I3404 n1_m1_230400_436800 0 1.261429e-07
I3405 n1_m1_230400_441600 0 4.308571e-07
I3406 n1_m1_230400_446400 0 6.531250e-08
I3407 n1_m1_230400_451200 0 9.445929e-08
I3408 n1_m1_230400_456000 0 1.054429e-07
I3409 n1_m1_230400_460800 0 8.667857e-08
I3410 n1_m1_230400_465600 0 1.812952e-07
I3411 n1_m1_230400_470400 0 7.121786e-07
I3412 n1_m1_230400_475200 0 2.355595e-07
I3413 n1_m1_230400_480000 0 4.957774e-07
I3414 n1_m1_230400_484800 0 1.448214e-07
I3415 n1_m1_230400_489600 0 1.277393e-07
I3416 n1_m1_230400_494400 0 4.450933e-07
I3417 n1_m1_230400_499200 0 1.301132e-07
I3418 n1_m1_230400_504000 0 3.175143e-07
I3419 n1_m1_230400_508800 0 7.441429e-08
I3420 n1_m1_230400_513600 0 2.848833e-07
I3421 n1_m1_230400_518400 0 1.526179e-07
I3422 n1_m1_230400_523200 0 1.199582e-07
I3423 n1_m1_230400_528000 0 2.092571e-07
I3424 n1_m1_230400_532800 0 1.305795e-07
I3425 n1_m1_230400_537600 0 2.132625e-07
I3426 n1_m1_230400_542400 0 1.313372e-07
I3427 n1_m1_230400_547200 0 1.226038e-07
I3428 n1_m1_230400_552000 0 1.199231e-07
I3429 n1_m1_230400_556800 0 1.082231e-07
I3430 n1_m1_230400_561600 0 8.783810e-08
I3431 n1_m1_230400_566400 0 9.562857e-08
I3432 n1_m1_230400_571200 0 8.115000e-08
I3433 n1_m1_230400_576000 0 4.200000e-07
I3434 n1_m1_230400_580800 0 3.226731e-07
I3435 n1_m1_230400_585600 0 2.522707e-07
I3436 n1_m1_235200_9600 0 4.503125e-07
I3437 n1_m1_235200_24000 0 2.853333e-08
I3438 n1_m1_235200_28800 0 1.001000e-07
I3439 n1_m1_235200_33600 0 1.025769e-07
I3440 n1_m1_235200_38400 0 3.467308e-08
I3441 n1_m1_235200_43200 0 4.739231e-08
I3442 n1_m1_235200_48000 0 1.686205e-07
I3443 n1_m1_235200_52800 0 2.097971e-07
I3444 n1_m1_235200_57600 0 8.437048e-07
I3445 n1_m1_235200_62400 0 1.326286e-07
I3446 n1_m1_235200_67200 0 1.255333e-07
I3447 n1_m1_235200_72000 0 5.858590e-08
I3448 n1_m1_235200_76800 0 5.603077e-08
I3449 n1_m1_235200_81600 0 2.495036e-07
I3450 n1_m1_235200_86400 0 2.414447e-07
I3451 n1_m1_235200_91200 0 9.331817e-07
I3452 n1_m1_235200_96000 0 5.665179e-08
I3453 n1_m1_235200_100800 0 1.843333e-08
I3454 n1_m1_235200_105600 0 1.263429e-07
I3455 n1_m1_235200_110400 0 7.746429e-08
I3456 n1_m1_235200_115200 0 9.931667e-08
I3457 n1_m1_235200_120000 0 2.540690e-07
I3458 n1_m1_235200_124800 0 1.357083e-07
I3459 n1_m1_235200_129600 0 1.751071e-07
I3460 n1_m1_235200_134400 0 6.816667e-08
I3461 n1_m1_235200_139200 0 1.086429e-07
I3462 n1_m1_235200_144000 0 7.263429e-07
I3463 n1_m1_235200_148800 0 1.952071e-07
I3464 n1_m1_235200_153600 0 2.434905e-07
I3465 n1_m1_235200_158400 0 9.224762e-08
I3466 n1_m1_235200_163200 0 2.292655e-07
I3467 n1_m1_235200_168000 0 1.049700e-06
I3468 n1_m1_235200_172800 0 5.048269e-07
I3469 n1_m1_235200_177600 0 1.646050e-06
I3470 n1_m1_235200_182400 0 7.802381e-07
I3471 n1_m1_235200_187200 0 8.314286e-07
I3472 n1_m1_235200_192000 0 2.742333e-07
I3473 n1_m1_235200_196800 0 1.977857e-07
I3474 n1_m1_235200_201600 0 9.433529e-07
I3475 n1_m1_235200_206400 0 6.514594e-07
I3476 n1_m1_235200_211200 0 4.122857e-07
I3477 n1_m1_235200_216000 0 3.086500e-07
I3478 n1_m1_235200_220800 0 1.955018e-07
I3479 n1_m1_235200_225600 0 1.136750e-07
I3480 n1_m1_235200_230400 0 2.012429e-07
I3481 n1_m1_235200_235200 0 9.366548e-08
I3482 n1_m1_235200_240000 0 1.712780e-07
I3483 n1_m1_235200_244800 0 6.488000e-07
I3484 n1_m1_235200_249600 0 1.015768e-07
I3485 n1_m1_235200_254400 0 6.781429e-08
I3486 n1_m1_235200_259200 0 3.110008e-07
I3487 n1_m1_235200_264000 0 2.296331e-07
I3488 n1_m1_235200_268800 0 7.011345e-08
I3489 n1_m1_235200_273600 0 5.977451e-07
I3490 n1_m1_235200_278400 0 1.789821e-07
I3491 n1_m1_235200_283200 0 4.782576e-08
I3492 n1_m1_235200_288000 0 3.222569e-06
I3493 n1_m1_235200_292800 0 1.022143e-06
I3494 n1_m1_235200_297600 0 4.968143e-07
I3495 n1_m1_235200_302400 0 3.341446e-07
I3496 n1_m1_235200_307200 0 3.205714e-07
I3497 n1_m1_235200_312000 0 3.761857e-07
I3498 n1_m1_235200_316800 0 1.166914e-07
I3499 n1_m1_235200_321600 0 1.886286e-07
I3500 n1_m1_235200_326400 0 4.475445e-07
I3501 n1_m1_235200_331200 0 4.186908e-07
I3502 n1_m1_235200_336000 0 7.219571e-07
I3503 n1_m1_235200_340800 0 1.027179e-07
I3504 n1_m1_235200_345600 0 1.151196e-07
I3505 n1_m1_235200_350400 0 1.650286e-07
I3506 n1_m1_235200_355200 0 7.976429e-07
I3507 n1_m1_235200_360000 0 1.109929e-06
I3508 n1_m1_235200_364800 0 4.365238e-07
I3509 n1_m1_235200_369600 0 1.136905e-06
I3510 n1_m1_235200_374400 0 6.239048e-07
I3511 n1_m1_235200_379200 0 5.493810e-08
I3512 n1_m1_235200_384000 0 1.120714e-07
I3513 n1_m1_235200_388800 0 6.668214e-08
I3514 n1_m1_235200_393600 0 2.639714e-07
I3515 n1_m1_235200_398400 0 7.764286e-08
I3516 n1_m1_235200_403200 0 4.081071e-08
I3517 n1_m1_235200_408000 0 2.770179e-07
I3518 n1_m1_235200_412800 0 2.327548e-07
I3519 n1_m1_235200_417600 0 4.018857e-07
I3520 n1_m1_235200_422400 0 1.434833e-07
I3521 n1_m1_235200_427200 0 3.193643e-07
I3522 n1_m1_235200_432000 0 5.957000e-07
I3523 n1_m1_235200_436800 0 3.589782e-07
I3524 n1_m1_235200_441600 0 1.597905e-06
I3525 n1_m1_235200_446400 0 6.844643e-08
I3526 n1_m1_235200_451200 0 7.123333e-08
I3527 n1_m1_235200_456000 0 6.468571e-08
I3528 n1_m1_235200_460800 0 1.433571e-07
I3529 n1_m1_235200_465600 0 1.858524e-07
I3530 n1_m1_235200_470400 0 5.397143e-08
I3531 n1_m1_235200_475200 0 1.704286e-07
I3532 n1_m1_235200_480000 0 8.959887e-07
I3533 n1_m1_235200_484800 0 5.109707e-07
I3534 n1_m1_235200_489600 0 1.813821e-07
I3535 n1_m1_235200_494400 0 3.254966e-07
I3536 n1_m1_235200_499200 0 6.163277e-08
I3537 n1_m1_235200_504000 0 1.481357e-07
I3538 n1_m1_235200_508800 0 3.451071e-07
I3539 n1_m1_235200_513600 0 4.152631e-07
I3540 n1_m1_235200_518400 0 7.140000e-08
I3541 n1_m1_235200_523200 0 1.062107e-07
I3542 n1_m1_235200_528000 0 1.845018e-07
I3543 n1_m1_235200_532800 0 3.521359e-07
I3544 n1_m1_235200_537600 0 1.372962e-07
I3545 n1_m1_235200_542400 0 1.538462e-08
I3546 n1_m1_235200_547200 0 8.336538e-08
I3547 n1_m1_235200_552000 0 8.326154e-08
I3548 n1_m1_235200_556800 0 2.592308e-08
I3549 n1_m1_235200_561600 0 1.208167e-07
I3550 n1_m1_235200_566400 0 4.510769e-08
I3551 n1_m1_235200_571200 0 2.819231e-08
I3552 n1_m1_235200_580800 0 2.847115e-07
I3553 n1_m1_235200_585600 0 2.034447e-07
I3554 n1_m1_240000_4800 0 1.975385e-08
I3555 n1_m1_240000_9600 0 1.904615e-08
I3556 n1_m1_240000_24000 0 2.938292e-07
I3557 n1_m1_240000_28800 0 1.056786e-07
I3558 n1_m1_240000_33600 0 2.016868e-07
I3559 n1_m1_240000_38400 0 9.953462e-08
I3560 n1_m1_240000_43200 0 2.222231e-07
I3561 n1_m1_240000_48000 0 2.673998e-07
I3562 n1_m1_240000_52800 0 2.697005e-07
I3563 n1_m1_240000_57600 0 2.864973e-07
I3564 n1_m1_240000_62400 0 5.859361e-07
I3565 n1_m1_240000_67200 0 8.271810e-07
I3566 n1_m1_240000_72000 0 2.875987e-07
I3567 n1_m1_240000_76800 0 1.817418e-07
I3568 n1_m1_240000_81600 0 4.101536e-07
I3569 n1_m1_240000_86400 0 8.417846e-07
I3570 n1_m1_240000_91200 0 2.460994e-06
I3571 n1_m1_240000_96000 0 1.865952e-07
I3572 n1_m1_240000_100800 0 1.630984e-07
I3573 n1_m1_240000_105600 0 4.553008e-07
I3574 n1_m1_240000_110400 0 7.624685e-07
I3575 n1_m1_240000_115200 0 8.799550e-07
I3576 n1_m1_240000_120000 0 1.279946e-06
I3577 n1_m1_240000_124800 0 9.946310e-07
I3578 n1_m1_240000_129600 0 3.096071e-07
I3579 n1_m1_240000_134400 0 1.481679e-07
I3580 n1_m1_240000_139200 0 1.905536e-07
I3581 n1_m1_240000_144000 0 2.273769e-06
I3582 n1_m1_240000_148800 0 3.849095e-06
I3583 n1_m1_240000_153600 0 1.565029e-06
I3584 n1_m1_240000_158400 0 1.220219e-06
I3585 n1_m1_240000_163200 0 1.419143e-07
I3586 n1_m1_240000_168000 0 3.118983e-07
I3587 n1_m1_240000_172800 0 1.801143e-07
I3588 n1_m1_240000_177600 0 3.457585e-06
I3589 n1_m1_240000_182400 0 3.724524e-06
I3590 n1_m1_240000_187200 0 2.877143e-06
I3591 n1_m1_240000_192000 0 8.302667e-07
I3592 n1_m1_240000_196800 0 7.587479e-07
I3593 n1_m1_240000_201600 0 1.729193e-06
I3594 n1_m1_240000_206400 0 1.291412e-06
I3595 n1_m1_240000_211200 0 7.499000e-07
I3596 n1_m1_240000_216000 0 4.100429e-07
I3597 n1_m1_240000_220800 0 1.299446e-07
I3598 n1_m1_240000_225600 0 2.031479e-07
I3599 n1_m1_240000_230400 0 4.565714e-08
I3600 n1_m1_240000_235200 0 1.285000e-07
I3601 n1_m1_240000_240000 0 6.473649e-07
I3602 n1_m1_240000_244800 0 1.095371e-06
I3603 n1_m1_240000_249600 0 3.945858e-07
I3604 n1_m1_240000_254400 0 1.135426e-07
I3605 n1_m1_240000_259200 0 6.171857e-07
I3606 n1_m1_240000_264000 0 1.811340e-06
I3607 n1_m1_240000_268800 0 1.639287e-06
I3608 n1_m1_240000_273600 0 7.536286e-07
I3609 n1_m1_240000_278400 0 9.207279e-07
I3610 n1_m1_240000_283200 0 7.920818e-07
I3611 n1_m1_240000_288000 0 9.911184e-07
I3612 n1_m1_240000_292800 0 1.048246e-06
I3613 n1_m1_240000_297600 0 5.764238e-07
I3614 n1_m1_240000_302400 0 1.646054e-07
I3615 n1_m1_240000_307200 0 4.667143e-07
I3616 n1_m1_240000_312000 0 4.162071e-07
I3617 n1_m1_240000_316800 0 1.436190e-06
I3618 n1_m1_240000_321600 0 3.260810e-07
I3619 n1_m1_240000_326400 0 1.649964e-07
I3620 n1_m1_240000_331200 0 1.044566e-06
I3621 n1_m1_240000_336000 0 4.417595e-07
I3622 n1_m1_240000_340800 0 1.385964e-07
I3623 n1_m1_240000_345600 0 4.722689e-07
I3624 n1_m1_240000_350400 0 2.412286e-07
I3625 n1_m1_240000_355200 0 1.914500e-06
I3626 n1_m1_240000_360000 0 1.598683e-06
I3627 n1_m1_240000_364800 0 1.121311e-06
I3628 n1_m1_240000_369600 0 2.185460e-06
I3629 n1_m1_240000_374400 0 9.008762e-07
I3630 n1_m1_240000_379200 0 6.455226e-07
I3631 n1_m1_240000_384000 0 6.078179e-07
I3632 n1_m1_240000_388800 0 1.787429e-07
I3633 n1_m1_240000_393600 0 3.373500e-07
I3634 n1_m1_240000_398400 0 2.246857e-07
I3635 n1_m1_240000_403200 0 1.696143e-07
I3636 n1_m1_240000_408000 0 4.731143e-07
I3637 n1_m1_240000_412800 0 2.909143e-07
I3638 n1_m1_240000_417600 0 1.300314e-06
I3639 n1_m1_240000_422400 0 9.145774e-07
I3640 n1_m1_240000_427200 0 1.669321e-06
I3641 n1_m1_240000_432000 0 1.478786e-06
I3642 n1_m1_240000_436800 0 7.816409e-07
I3643 n1_m1_240000_441600 0 6.349303e-06
I3644 n1_m1_240000_446400 0 2.018286e-06
I3645 n1_m1_240000_451200 0 9.026524e-07
I3646 n1_m1_240000_456000 0 3.279114e-06
I3647 n1_m1_240000_460800 0 2.312738e-06
I3648 n1_m1_240000_465600 0 1.017143e-06
I3649 n1_m1_240000_470400 0 9.159643e-07
I3650 n1_m1_240000_475200 0 1.935179e-07
I3651 n1_m1_240000_480000 0 1.618100e-06
I3652 n1_m1_240000_484800 0 9.780764e-07
I3653 n1_m1_240000_489600 0 3.560185e-07
I3654 n1_m1_240000_494400 0 5.879529e-07
I3655 n1_m1_240000_499200 0 3.035779e-07
I3656 n1_m1_240000_504000 0 6.710548e-07
I3657 n1_m1_240000_508800 0 4.447214e-07
I3658 n1_m1_240000_513600 0 3.496036e-07
I3659 n1_m1_240000_518400 0 7.683750e-07
I3660 n1_m1_240000_523200 0 3.003411e-07
I3661 n1_m1_240000_528000 0 2.595839e-07
I3662 n1_m1_240000_532800 0 3.632385e-07
I3663 n1_m1_240000_537600 0 5.007315e-07
I3664 n1_m1_240000_542400 0 7.510000e-08
I3665 n1_m1_240000_547200 0 5.706885e-07
I3666 n1_m1_240000_552000 0 1.865000e-07
I3667 n1_m1_240000_556800 0 1.065615e-07
I3668 n1_m1_240000_561600 0 1.585298e-07
I3669 n1_m1_240000_566400 0 1.537486e-07
I3670 n1_m1_240000_571200 0 6.430000e-07
I3671 n1_m1_240000_576000 0 6.000000e-07
I3672 n1_m1_240000_580800 0 4.277115e-07
I3673 n1_m1_240000_585600 0 3.142197e-07
I3674 n1_m1_244800_9600 0 5.746061e-07
I3675 n1_m1_244800_24000 0 1.584375e-07
I3676 n1_m1_244800_28800 0 6.329286e-08
I3677 n1_m1_244800_33600 0 1.316059e-07
I3678 n1_m1_244800_38400 0 6.828462e-08
I3679 n1_m1_244800_43200 0 1.884000e-07
I3680 n1_m1_244800_48000 0 1.863857e-07
I3681 n1_m1_244800_52800 0 9.373095e-08
I3682 n1_m1_244800_57600 0 2.183599e-07
I3683 n1_m1_244800_62400 0 5.172109e-08
I3684 n1_m1_244800_67200 0 4.098714e-07
I3685 n1_m1_244800_72000 0 1.408154e-07
I3686 n1_m1_244800_76800 0 1.469275e-07
I3687 n1_m1_244800_81600 0 1.230857e-07
I3688 n1_m1_244800_86400 0 9.335092e-08
I3689 n1_m1_244800_91200 0 5.042729e-07
I3690 n1_m1_244800_96000 0 3.592934e-07
I3691 n1_m1_244800_100800 0 7.352806e-07
I3692 n1_m1_244800_105600 0 9.823714e-07
I3693 n1_m1_244800_110400 0 9.183193e-07
I3694 n1_m1_244800_115200 0 1.234538e-06
I3695 n1_m1_244800_120000 0 1.425950e-06
I3696 n1_m1_244800_124800 0 1.696190e-07
I3697 n1_m1_244800_129600 0 4.410048e-07
I3698 n1_m1_244800_134400 0 4.188464e-07
I3699 n1_m1_244800_139200 0 4.600893e-07
I3700 n1_m1_244800_144000 0 5.474643e-07
I3701 n1_m1_244800_148800 0 2.036269e-06
I3702 n1_m1_244800_153600 0 2.197429e-06
I3703 n1_m1_244800_158400 0 2.537619e-06
I3704 n1_m1_244800_163200 0 3.233810e-07
I3705 n1_m1_244800_168000 0 7.223398e-07
I3706 n1_m1_244800_172800 0 7.982625e-07
I3707 n1_m1_244800_177600 0 1.263714e-06
I3708 n1_m1_244800_182400 0 8.820952e-07
I3709 n1_m1_244800_187200 0 6.357143e-07
I3710 n1_m1_244800_192000 0 1.096857e-06
I3711 n1_m1_244800_196800 0 8.752017e-07
I3712 n1_m1_244800_201600 0 1.900151e-06
I3713 n1_m1_244800_206400 0 1.495176e-06
I3714 n1_m1_244800_211200 0 9.252857e-08
I3715 n1_m1_244800_216000 0 2.282929e-07
I3716 n1_m1_244800_220800 0 6.213929e-08
I3717 n1_m1_244800_225600 0 1.345486e-07
I3718 n1_m1_244800_230400 0 1.381905e-07
I3719 n1_m1_244800_235200 0 1.546643e-07
I3720 n1_m1_244800_240000 0 3.817683e-07
I3721 n1_m1_244800_244800 0 6.563810e-07
I3722 n1_m1_244800_249600 0 9.688207e-07
I3723 n1_m1_244800_254400 0 4.615546e-07
I3724 n1_m1_244800_259200 0 7.948235e-07
I3725 n1_m1_244800_264000 0 1.488458e-06
I3726 n1_m1_244800_268800 0 1.088622e-06
I3727 n1_m1_244800_273600 0 1.165430e-06
I3728 n1_m1_244800_278400 0 1.264472e-06
I3729 n1_m1_244800_283200 0 3.088067e-07
I3730 n1_m1_244800_288000 0 1.672710e-06
I3731 n1_m1_244800_292800 0 8.886825e-07
I3732 n1_m1_244800_297600 0 1.371333e-06
I3733 n1_m1_244800_302400 0 1.501357e-07
I3734 n1_m1_244800_307200 0 1.038571e-07
I3735 n1_m1_244800_312000 0 1.048126e-07
I3736 n1_m1_244800_316800 0 5.508238e-07
I3737 n1_m1_244800_321600 0 2.237238e-07
I3738 n1_m1_244800_326400 0 2.352321e-07
I3739 n1_m1_244800_331200 0 4.032911e-07
I3740 n1_m1_244800_336000 0 5.611405e-07
I3741 n1_m1_244800_340800 0 1.192000e-07
I3742 n1_m1_244800_345600 0 1.441971e-07
I3743 n1_m1_244800_350400 0 2.535000e-07
I3744 n1_m1_244800_360000 0 1.046889e-06
I3745 n1_m1_244800_364800 0 2.662363e-07
I3746 n1_m1_244800_369600 0 1.260349e-06
I3747 n1_m1_244800_374400 0 5.276000e-07
I3748 n1_m1_244800_379200 0 3.545536e-07
I3749 n1_m1_244800_384000 0 9.978214e-07
I3750 n1_m1_244800_388800 0 1.828125e-07
I3751 n1_m1_244800_393600 0 3.385000e-07
I3752 n1_m1_244800_408000 0 5.424857e-07
I3753 n1_m1_244800_412800 0 5.726286e-07
I3754 n1_m1_244800_417600 0 1.034124e-06
I3755 n1_m1_244800_422400 0 9.845714e-07
I3756 n1_m1_244800_427200 0 6.188571e-07
I3757 n1_m1_244800_432000 0 1.159762e-06
I3758 n1_m1_244800_436800 0 9.927143e-07
I3759 n1_m1_244800_441600 0 9.767143e-07
I3760 n1_m1_244800_446400 0 7.567143e-07
I3761 n1_m1_244800_451200 0 2.585429e-07
I3762 n1_m1_244800_456000 0 1.036571e-06
I3763 n1_m1_244800_460800 0 3.525000e-07
I3764 n1_m1_244800_465600 0 1.584381e-06
I3765 n1_m1_244800_470400 0 4.911500e-07
I3766 n1_m1_244800_475200 0 1.569107e-07
I3767 n1_m1_244800_480000 0 3.715261e-07
I3768 n1_m1_244800_484800 0 6.746134e-07
I3769 n1_m1_244800_489600 0 4.550307e-07
I3770 n1_m1_244800_494400 0 7.928571e-08
I3771 n1_m1_244800_499200 0 1.033571e-07
I3772 n1_m1_244800_504000 0 3.687143e-07
I3773 n1_m1_244800_508800 0 4.928571e-08
I3774 n1_m1_244800_513600 0 9.181429e-08
I3775 n1_m1_244800_518400 0 3.082500e-08
I3776 n1_m1_244800_523200 0 1.053054e-07
I3777 n1_m1_244800_528000 0 5.325714e-08
I3778 n1_m1_244800_532800 0 2.024077e-07
I3779 n1_m1_244800_537600 0 2.227800e-07
I3780 n1_m1_244800_542400 0 8.619231e-08
I3781 n1_m1_244800_547200 0 1.484308e-07
I3782 n1_m1_244800_552000 0 1.139538e-07
I3783 n1_m1_244800_556800 0 5.201538e-08
I3784 n1_m1_244800_561600 0 1.354679e-07
I3785 n1_m1_244800_566400 0 6.342945e-08
I3786 n1_m1_244800_571200 0 1.641077e-07
I3787 n1_m1_244800_576000 0 4.840000e-07
I3788 n1_m1_244800_580800 0 1.673654e-07
I3789 n1_m1_244800_585600 0 1.557034e-07
I3790 n1_m1_249600_4800 0 7.133538e-08
I3791 n1_m1_249600_9600 0 5.113539e-07
I3792 n1_m1_249600_14400 0 1.984375e-07
I3793 n1_m1_249600_19200 0 6.762857e-08
I3794 n1_m1_249600_24000 0 2.359548e-07
I3795 n1_m1_249600_28800 0 3.761429e-08
I3796 n1_m1_249600_33600 0 1.701755e-07
I3797 n1_m1_249600_38400 0 1.439436e-07
I3798 n1_m1_249600_43200 0 2.035769e-07
I3799 n1_m1_249600_48000 0 3.895231e-07
I3800 n1_m1_249600_52800 0 1.042625e-07
I3801 n1_m1_249600_57600 0 1.469429e-07
I3802 n1_m1_249600_62400 0 1.633714e-07
I3803 n1_m1_249600_67200 0 3.078357e-07
I3804 n1_m1_249600_72000 0 8.444787e-07
I3805 n1_m1_249600_76800 0 1.906615e-07
I3806 n1_m1_249600_81600 0 3.525143e-07
I3807 n1_m1_249600_86400 0 1.727396e-07
I3808 n1_m1_249600_91200 0 3.995985e-07
I3809 n1_m1_249600_96000 0 2.682845e-06
I3810 n1_m1_249600_100800 0 1.476958e-06
I3811 n1_m1_249600_105600 0 2.428596e-06
I3812 n1_m1_249600_110400 0 1.431597e-06
I3813 n1_m1_249600_115200 0 1.675000e-06
I3814 n1_m1_249600_120000 0 1.455933e-06
I3815 n1_m1_249600_124800 0 1.565658e-06
I3816 n1_m1_249600_129600 0 2.092157e-06
I3817 n1_m1_249600_134400 0 7.345714e-07
I3818 n1_m1_249600_139200 0 3.569524e-06
I3819 n1_m1_249600_144000 0 5.661952e-06
I3820 n1_m1_249600_148800 0 2.536156e-06
I3821 n1_m1_249600_153600 0 2.256082e-06
I3822 n1_m1_249600_158400 0 2.523333e-06
I3823 n1_m1_249600_163200 0 2.731571e-06
I3824 n1_m1_249600_168000 0 2.456072e-06
I3825 n1_m1_249600_172800 0 1.111969e-06
I3826 n1_m1_249600_177600 0 2.492923e-06
I3827 n1_m1_249600_182400 0 2.200852e-06
I3828 n1_m1_249600_187200 0 1.119314e-06
I3829 n1_m1_249600_192000 0 3.932358e-06
I3830 n1_m1_249600_196800 0 8.133123e-07
I3831 n1_m1_249600_201600 0 3.787882e-06
I3832 n1_m1_249600_206400 0 1.932857e-06
I3833 n1_m1_249600_211200 0 1.509641e-06
I3834 n1_m1_249600_216000 0 1.054578e-06
I3835 n1_m1_249600_220800 0 5.834286e-07
I3836 n1_m1_249600_225600 0 1.871429e-07
I3837 n1_m1_249600_230400 0 2.760667e-07
I3838 n1_m1_249600_235200 0 4.607571e-07
I3839 n1_m1_249600_240000 0 4.042794e-07
I3840 n1_m1_249600_244800 0 5.877619e-07
I3841 n1_m1_249600_249600 0 1.605095e-06
I3842 n1_m1_249600_254400 0 9.361933e-07
I3843 n1_m1_249600_259200 0 1.293126e-06
I3844 n1_m1_249600_264000 0 2.424916e-06
I3845 n1_m1_249600_268800 0 2.117045e-06
I3846 n1_m1_249600_273600 0 2.346639e-06
I3847 n1_m1_249600_278400 0 2.597007e-06
I3848 n1_m1_249600_283200 0 2.964328e-06
I3849 n1_m1_249600_288000 0 1.946110e-06
I3850 n1_m1_249600_292800 0 1.386679e-06
I3851 n1_m1_249600_297600 0 1.195915e-06
I3852 n1_m1_249600_302400 0 1.454906e-06
I3853 n1_m1_249600_307200 0 7.667429e-07
I3854 n1_m1_249600_312000 0 4.840202e-07
I3855 n1_m1_249600_316800 0 3.257746e-07
I3856 n1_m1_249600_321600 0 7.165460e-07
I3857 n1_m1_249600_326400 0 4.617429e-07
I3858 n1_m1_249600_331200 0 3.161363e-07
I3859 n1_m1_249600_336000 0 4.480452e-07
I3860 n1_m1_249600_340800 0 6.988857e-07
I3861 n1_m1_249600_345600 0 9.557714e-07
I3862 n1_m1_249600_350400 0 2.104941e-06
I3863 n1_m1_249600_355200 0 1.788468e-07
I3864 n1_m1_249600_360000 0 5.588078e-07
I3865 n1_m1_249600_364800 0 9.186250e-07
I3866 n1_m1_249600_369600 0 1.343934e-06
I3867 n1_m1_249600_374400 0 8.398883e-07
I3868 n1_m1_249600_379200 0 4.719643e-07
I3869 n1_m1_249600_384000 0 2.161089e-06
I3870 n1_m1_249600_388800 0 1.037759e-06
I3871 n1_m1_249600_393600 0 4.524889e-07
I3872 n1_m1_249600_398400 0 2.300762e-06
I3873 n1_m1_249600_403200 0 2.385471e-06
I3874 n1_m1_249600_408000 0 1.654157e-06
I3875 n1_m1_249600_412800 0 6.747143e-07
I3876 n1_m1_249600_417600 0 4.316048e-06
I3877 n1_m1_249600_422400 0 3.599429e-06
I3878 n1_m1_249600_427200 0 2.567714e-06
I3879 n1_m1_249600_432000 0 5.579524e-06
I3880 n1_m1_249600_436800 0 3.800381e-06
I3881 n1_m1_249600_441600 0 2.647857e-06
I3882 n1_m1_249600_446400 0 2.229812e-06
I3883 n1_m1_249600_451200 0 1.615782e-06
I3884 n1_m1_249600_456000 0 3.679000e-06
I3885 n1_m1_249600_460800 0 2.510000e-06
I3886 n1_m1_249600_465600 0 4.104159e-06
I3887 n1_m1_249600_470400 0 2.089057e-06
I3888 n1_m1_249600_475200 0 7.483776e-07
I3889 n1_m1_249600_480000 0 3.268327e-06
I3890 n1_m1_249600_484800 0 1.560545e-06
I3891 n1_m1_249600_489600 0 1.102753e-06
I3892 n1_m1_249600_494400 0 2.333429e-07
I3893 n1_m1_249600_499200 0 3.043571e-07
I3894 n1_m1_249600_504000 0 2.048390e-07
I3895 n1_m1_249600_508800 0 7.621714e-08
I3896 n1_m1_249600_513600 0 3.009571e-07
I3897 n1_m1_249600_518400 0 3.175923e-07
I3898 n1_m1_249600_523200 0 2.480791e-07
I3899 n1_m1_249600_528000 0 2.471952e-07
I3900 n1_m1_249600_532800 0 1.514827e-07
I3901 n1_m1_249600_537600 0 2.131191e-07
I3902 n1_m1_249600_542400 0 1.356286e-06
I3903 n1_m1_249600_547200 0 2.871308e-07
I3904 n1_m1_249600_552000 0 2.781949e-07
I3905 n1_m1_249600_556800 0 1.206410e-07
I3906 n1_m1_249600_561600 0 5.457962e-07
I3907 n1_m1_249600_566400 0 1.458079e-07
I3908 n1_m1_249600_571200 0 1.356192e-07
I3909 n1_m1_249600_585600 0 5.110000e-08
I3910 n1_m1_254400_4800 0 2.238769e-08
I3911 n1_m1_254400_9600 0 1.052503e-07
I3912 n1_m1_254400_14400 0 3.968750e-07
I3913 n1_m1_254400_24000 0 1.622833e-07
I3914 n1_m1_254400_28800 0 7.092857e-08
I3915 n1_m1_254400_33600 0 2.637714e-07
I3916 n1_m1_254400_38400 0 3.313333e-08
I3917 n1_m1_254400_43200 0 6.130513e-08
I3918 n1_m1_254400_48000 0 8.908297e-08
I3919 n1_m1_254400_52800 0 8.446607e-08
I3920 n1_m1_254400_57600 0 2.340690e-07
I3921 n1_m1_254400_62400 0 5.832857e-08
I3922 n1_m1_254400_67200 0 6.083571e-08
I3923 n1_m1_254400_72000 0 4.312264e-07
I3924 n1_m1_254400_81600 0 1.664286e-07
I3925 n1_m1_254400_86400 0 7.058681e-08
I3926 n1_m1_254400_91200 0 1.405608e-07
I3927 n1_m1_254400_96000 0 5.904921e-07
I3928 n1_m1_254400_100800 0 4.384601e-07
I3929 n1_m1_254400_105600 0 7.373114e-07
I3930 n1_m1_254400_110400 0 6.092437e-07
I3931 n1_m1_254400_115200 0 8.200000e-07
I3932 n1_m1_254400_120000 0 1.316639e-06
I3933 n1_m1_254400_124800 0 9.957983e-07
I3934 n1_m1_254400_129600 0 9.302829e-07
I3935 n1_m1_254400_134400 0 1.333571e-06
I3936 n1_m1_254400_139200 0 2.257619e-06
I3937 n1_m1_254400_144000 0 1.051619e-06
I3938 n1_m1_254400_148800 0 2.048435e-07
I3939 n1_m1_254400_153600 0 2.404331e-06
I3940 n1_m1_254400_158400 0 3.123810e-07
I3941 n1_m1_254400_163200 0 9.019286e-07
I3942 n1_m1_254400_168000 0 8.307191e-07
I3943 n1_m1_254400_172800 0 6.404826e-07
I3944 n1_m1_254400_177600 0 1.289941e-06
I3945 n1_m1_254400_182400 0 4.531515e-07
I3946 n1_m1_254400_187200 0 1.895195e-07
I3947 n1_m1_254400_192000 0 8.094464e-07
I3948 n1_m1_254400_196800 0 3.035238e-07
I3949 n1_m1_254400_201600 0 1.626186e-06
I3950 n1_m1_254400_206400 0 1.093413e-06
I3951 n1_m1_254400_211200 0 7.398397e-07
I3952 n1_m1_254400_216000 0 8.355270e-07
I3953 n1_m1_254400_225600 0 1.136667e-07
I3954 n1_m1_254400_235200 0 2.185000e-07
I3955 n1_m1_254400_240000 0 2.195238e-09
I3956 n1_m1_254400_244800 0 2.642825e-07
I3957 n1_m1_254400_249600 0 1.076840e-06
I3958 n1_m1_254400_254400 0 2.203361e-07
I3959 n1_m1_254400_259200 0 7.835294e-07
I3960 n1_m1_254400_264000 0 7.623529e-07
I3961 n1_m1_254400_268800 0 2.858095e-07
I3962 n1_m1_254400_273600 0 5.236429e-07
I3963 n1_m1_254400_278400 0 8.980252e-07
I3964 n1_m1_254400_283200 0 5.169580e-07
I3965 n1_m1_254400_288000 0 6.142829e-07
I3966 n1_m1_254400_292800 0 4.228501e-07
I3967 n1_m1_254400_297600 0 2.682354e-07
I3968 n1_m1_254400_302400 0 3.755994e-07
I3969 n1_m1_254400_307200 0 1.982857e-08
I3970 n1_m1_254400_312000 0 7.113619e-08
I3971 n1_m1_254400_316800 0 1.513683e-07
I3972 n1_m1_254400_321600 0 2.663492e-07
I3973 n1_m1_254400_326400 0 2.661429e-07
I3974 n1_m1_254400_331200 0 1.048280e-07
I3975 n1_m1_254400_336000 0 6.739762e-08
I3976 n1_m1_254400_340800 0 3.883714e-07
I3977 n1_m1_254400_345600 0 5.771429e-08
I3978 n1_m1_254400_350400 0 1.087059e-06
I3979 n1_m1_254400_355200 0 9.907390e-07
I3980 n1_m1_254400_360000 0 2.871232e-07
I3981 n1_m1_254400_364800 0 9.502162e-08
I3982 n1_m1_254400_369600 0 7.290370e-07
I3983 n1_m1_254400_374400 0 3.274831e-07
I3984 n1_m1_254400_379200 0 6.192071e-07
I3985 n1_m1_254400_384000 0 8.497206e-07
I3986 n1_m1_254400_388800 0 1.012121e-07
I3987 n1_m1_254400_393600 0 6.715111e-07
I3988 n1_m1_254400_398400 0 4.495238e-07
I3989 n1_m1_254400_403200 0 1.071429e-07
I3990 n1_m1_254400_408000 0 1.709557e-06
I3991 n1_m1_254400_412800 0 9.591429e-07
I3992 n1_m1_254400_417600 0 1.470000e-07
I3993 n1_m1_254400_422400 0 1.507143e-06
I3994 n1_m1_254400_427200 0 8.828571e-07
I3995 n1_m1_254400_432000 0 3.771429e-07
I3996 n1_m1_254400_436800 0 8.915714e-07
I3997 n1_m1_254400_441600 0 1.432952e-06
I3998 n1_m1_254400_446400 0 4.137594e-07
I3999 n1_m1_254400_451200 0 1.017694e-06
I4000 n1_m1_254400_456000 0 1.430143e-06
I4001 n1_m1_254400_460800 0 5.535714e-08
I4002 n1_m1_254400_465600 0 9.038095e-07
I4003 n1_m1_254400_470400 0 7.104762e-08
I4004 n1_m1_254400_475200 0 2.220272e-07
I4005 n1_m1_254400_480000 0 6.605952e-07
I4006 n1_m1_254400_484800 0 3.006583e-07
I4007 n1_m1_254400_489600 0 3.938452e-07
I4008 n1_m1_254400_494400 0 6.448908e-08
I4009 n1_m1_254400_499200 0 8.735714e-08
I4010 n1_m1_254400_504000 0 3.930381e-08
I4011 n1_m1_254400_508800 0 7.735429e-08
I4012 n1_m1_254400_513600 0 8.443810e-08
I4013 n1_m1_254400_518400 0 1.435385e-08
I4014 n1_m1_254400_523200 0 4.614615e-08
I4015 n1_m1_254400_528000 0 9.468333e-08
I4016 n1_m1_254400_532800 0 4.346346e-08
I4017 n1_m1_254400_537600 0 1.132476e-07
I4018 n1_m1_254400_542400 0 3.278681e-07
I4019 n1_m1_254400_547200 0 1.890000e-07
I4020 n1_m1_254400_552000 0 6.062821e-08
I4021 n1_m1_254400_556800 0 9.140513e-08
I4022 n1_m1_254400_561600 0 1.282324e-07
I4023 n1_m1_254400_566400 0 6.742505e-08
I4024 n1_m1_254400_571200 0 9.061923e-08
I4025 n1_m1_259200_14400 0 3.305268e-07
I4026 n1_m1_259200_19200 0 5.194286e-07
I4027 n1_m1_259200_24000 0 3.254905e-07
I4028 n1_m1_259200_28800 0 7.201000e-08
I4029 n1_m1_259200_33600 0 1.302520e-07
I4030 n1_m1_259200_38400 0 5.992418e-08
I4031 n1_m1_259200_43200 0 8.015000e-08
I4032 n1_m1_259200_48000 0 1.738857e-07
I4033 n1_m1_259200_52800 0 9.946571e-08
I4034 n1_m1_259200_57600 0 1.036371e-07
I4035 n1_m1_259200_62400 0 2.380857e-07
I4036 n1_m1_259200_67200 0 2.091571e-07
I4037 n1_m1_259200_72000 0 1.130231e-06
I4038 n1_m1_259200_76800 0 1.714835e-07
I4039 n1_m1_259200_81600 0 2.774143e-07
I4040 n1_m1_259200_86400 0 2.507416e-07
I4041 n1_m1_259200_91200 0 7.204790e-07
I4042 n1_m1_259200_96000 0 5.377175e-07
I4043 n1_m1_259200_100800 0 5.520437e-07
I4044 n1_m1_259200_105600 0 2.116286e-07
I4045 n1_m1_259200_110400 0 4.864286e-07
I4046 n1_m1_259200_115200 0 9.374005e-07
I4047 n1_m1_259200_120000 0 1.867631e-06
I4048 n1_m1_259200_124800 0 1.230000e-06
I4049 n1_m1_259200_129600 0 1.343190e-06
I4050 n1_m1_259200_134400 0 2.077063e-06
I4051 n1_m1_259200_139200 0 1.022768e-06
I4052 n1_m1_259200_144000 0 5.679643e-07
I4053 n1_m1_259200_148800 0 3.697254e-06
I4054 n1_m1_259200_153600 0 9.464954e-06
I4055 n1_m1_259200_158400 0 7.178667e-07
I4056 n1_m1_259200_163200 0 1.441476e-06
I4057 n1_m1_259200_168000 0 2.323286e-06
I4058 n1_m1_259200_172800 0 1.066619e-06
I4059 n1_m1_259200_177600 0 1.742250e-06
I4060 n1_m1_259200_182400 0 2.256667e-07
I4061 n1_m1_259200_187200 0 2.857143e-07
I4062 n1_m1_259200_192000 0 4.150736e-07
I4063 n1_m1_259200_196800 0 7.604429e-07
I4064 n1_m1_259200_201600 0 9.777532e-07
I4065 n1_m1_259200_206400 0 2.194508e-06
I4066 n1_m1_259200_211200 0 9.790079e-07
I4067 n1_m1_259200_216000 0 2.094729e-06
I4068 n1_m1_259200_220800 0 7.614812e-07
I4069 n1_m1_259200_225600 0 1.104607e-06
I4070 n1_m1_259200_230400 0 1.629921e-06
I4071 n1_m1_259200_235200 0 8.119048e-07
I4072 n1_m1_259200_240000 0 2.118282e-06
I4073 n1_m1_259200_244800 0 5.663571e-07
I4074 n1_m1_259200_249600 0 9.862030e-07
I4075 n1_m1_259200_254400 0 2.022032e-06
I4076 n1_m1_259200_259200 0 7.562857e-07
I4077 n1_m1_259200_264000 0 1.222817e-06
I4078 n1_m1_259200_268800 0 9.629514e-07
I4079 n1_m1_259200_273600 0 2.235822e-06
I4080 n1_m1_259200_278400 0 1.377500e-06
I4081 n1_m1_259200_283200 0 1.352354e-06
I4082 n1_m1_259200_288000 0 1.296101e-06
I4083 n1_m1_259200_292800 0 1.017773e-06
I4084 n1_m1_259200_297600 0 9.754723e-07
I4085 n1_m1_259200_302400 0 4.122040e-07
I4086 n1_m1_259200_307200 0 6.749758e-07
I4087 n1_m1_259200_312000 0 3.929707e-07
I4088 n1_m1_259200_316800 0 2.209457e-07
I4089 n1_m1_259200_321600 0 6.035000e-07
I4090 n1_m1_259200_326400 0 2.161571e-07
I4091 n1_m1_259200_331200 0 3.572776e-07
I4092 n1_m1_259200_336000 0 1.741769e-07
I4093 n1_m1_259200_340800 0 4.059374e-07
I4094 n1_m1_259200_345600 0 5.805411e-07
I4095 n1_m1_259200_350400 0 9.243767e-07
I4096 n1_m1_259200_355200 0 7.641905e-07
I4097 n1_m1_259200_360000 0 1.108021e-06
I4098 n1_m1_259200_364800 0 4.877895e-07
I4099 n1_m1_259200_369600 0 1.176548e-06
I4100 n1_m1_259200_374400 0 1.424100e-06
I4101 n1_m1_259200_379200 0 9.465673e-07
I4102 n1_m1_259200_384000 0 9.863946e-07
I4103 n1_m1_259200_388800 0 1.583550e-06
I4104 n1_m1_259200_393600 0 1.070114e-06
I4105 n1_m1_259200_398400 0 1.784876e-06
I4106 n1_m1_259200_403200 0 2.806393e-06
I4107 n1_m1_259200_408000 0 3.877192e-06
I4108 n1_m1_259200_412800 0 1.865184e-06
I4109 n1_m1_259200_417600 0 3.235667e-06
I4110 n1_m1_259200_422400 0 1.874313e-06
I4111 n1_m1_259200_427200 0 1.946735e-06
I4112 n1_m1_259200_432000 0 2.930444e-06
I4113 n1_m1_259200_436800 0 2.412286e-06
I4114 n1_m1_259200_441600 0 1.242429e-06
I4115 n1_m1_259200_446400 0 2.666190e-06
I4116 n1_m1_259200_451200 0 1.683990e-06
I4117 n1_m1_259200_456000 0 2.131800e-06
I4118 n1_m1_259200_460800 0 1.697500e-06
I4119 n1_m1_259200_465600 0 2.238768e-06
I4120 n1_m1_259200_470400 0 9.063429e-07
I4121 n1_m1_259200_475200 0 5.274365e-07
I4122 n1_m1_259200_480000 0 7.013791e-07
I4123 n1_m1_259200_484800 0 6.465011e-07
I4124 n1_m1_259200_489600 0 1.093419e-06
I4125 n1_m1_259200_494400 0 2.829882e-07
I4126 n1_m1_259200_499200 0 7.274857e-07
I4127 n1_m1_259200_504000 0 5.757238e-07
I4128 n1_m1_259200_508800 0 1.343486e-07
I4129 n1_m1_259200_513600 0 2.856229e-07
I4130 n1_m1_259200_518400 0 1.672154e-07
I4131 n1_m1_259200_523200 0 1.067418e-07
I4132 n1_m1_259200_528000 0 3.204829e-07
I4133 n1_m1_259200_532800 0 2.708554e-07
I4134 n1_m1_259200_537600 0 1.509755e-07
I4135 n1_m1_259200_542400 0 2.523901e-07
I4136 n1_m1_259200_547200 0 1.195212e-07
I4137 n1_m1_259200_552000 0 9.014519e-08
I4138 n1_m1_259200_556800 0 5.048365e-08
I4139 n1_m1_259200_561600 0 1.221286e-07
I4140 n1_m1_259200_566400 0 6.665495e-08
I4141 n1_m1_259200_571200 0 1.219308e-07
I4142 n1_m1_259200_576000 0 1.490000e-08
I4143 n1_m1_259200_580800 0 2.141538e-09
I4144 n1_m1_259200_585600 0 1.338462e-09
I4145 n1_m1_264000_4800 0 4.280000e-08
I4146 n1_m1_264000_9600 0 1.389667e-07
I4147 n1_m1_264000_14400 0 9.139394e-07
I4148 n1_m1_264000_19200 0 1.362857e-07
I4149 n1_m1_264000_24000 0 4.995643e-07
I4150 n1_m1_264000_28800 0 2.904757e-07
I4151 n1_m1_264000_33600 0 6.596046e-07
I4152 n1_m1_264000_38400 0 1.826835e-07
I4153 n1_m1_264000_43200 0 1.938064e-07
I4154 n1_m1_264000_48000 0 7.395299e-07
I4155 n1_m1_264000_52800 0 2.883367e-07
I4156 n1_m1_264000_57600 0 2.116161e-07
I4157 n1_m1_264000_62400 0 7.822857e-08
I4158 n1_m1_264000_67200 0 3.639429e-07
I4159 n1_m1_264000_72000 0 1.277394e-07
I4160 n1_m1_264000_76800 0 3.809891e-07
I4161 n1_m1_264000_81600 0 1.795262e-07
I4162 n1_m1_264000_86400 0 1.585192e-07
I4163 n1_m1_264000_91200 0 3.165935e-07
I4164 n1_m1_264000_96000 0 1.392814e-06
I4165 n1_m1_264000_100800 0 5.792405e-07
I4166 n1_m1_264000_105600 0 8.804286e-07
I4167 n1_m1_264000_110400 0 3.396429e-07
I4168 n1_m1_264000_115200 0 3.899425e-07
I4169 n1_m1_264000_120000 0 2.086846e-06
I4170 n1_m1_264000_124800 0 1.405405e-06
I4171 n1_m1_264000_129600 0 1.177710e-06
I4172 n1_m1_264000_134400 0 1.084690e-06
I4173 n1_m1_264000_139200 0 1.966369e-06
I4174 n1_m1_264000_144000 0 2.287103e-06
I4175 n1_m1_264000_148800 0 4.240508e-06
I4176 n1_m1_264000_153600 0 3.871594e-06
I4177 n1_m1_264000_158400 0 3.291990e-06
I4178 n1_m1_264000_163200 0 1.606167e-06
I4179 n1_m1_264000_168000 0 3.844238e-06
I4180 n1_m1_264000_172800 0 1.986857e-06
I4181 n1_m1_264000_177600 0 4.642043e-06
I4182 n1_m1_264000_182400 0 1.560000e-06
I4183 n1_m1_264000_187200 0 3.085714e-06
I4184 n1_m1_264000_192000 0 1.561786e-06
I4185 n1_m1_264000_196800 0 2.165750e-06
I4186 n1_m1_264000_201600 0 1.788966e-06
I4187 n1_m1_264000_206400 0 7.209857e-07
I4188 n1_m1_264000_211200 0 2.053683e-06
I4189 n1_m1_264000_216000 0 2.126555e-06
I4190 n1_m1_264000_220800 0 5.022286e-07
I4191 n1_m1_264000_225600 0 1.556645e-06
I4192 n1_m1_264000_230400 0 2.305524e-06
I4193 n1_m1_264000_235200 0 8.638571e-07
I4194 n1_m1_264000_240000 0 2.045179e-06
I4195 n1_m1_264000_244800 0 1.567992e-06
I4196 n1_m1_264000_249600 0 1.913902e-06
I4197 n1_m1_264000_254400 0 1.870202e-06
I4198 n1_m1_264000_259200 0 1.371429e-06
I4199 n1_m1_264000_264000 0 1.545413e-06
I4200 n1_m1_264000_268800 0 1.663576e-06
I4201 n1_m1_264000_273600 0 8.852143e-07
I4202 n1_m1_264000_278400 0 1.080133e-06
I4203 n1_m1_264000_283200 0 1.708804e-06
I4204 n1_m1_264000_288000 0 2.052336e-06
I4205 n1_m1_264000_292800 0 1.988739e-06
I4206 n1_m1_264000_297600 0 3.023967e-06
I4207 n1_m1_264000_302400 0 6.270092e-07
I4208 n1_m1_264000_307200 0 1.291756e-06
I4209 n1_m1_264000_312000 0 5.411436e-07
I4210 n1_m1_264000_316800 0 5.196051e-07
I4211 n1_m1_264000_321600 0 3.024333e-07
I4212 n1_m1_264000_326400 0 2.020016e-07
I4213 n1_m1_264000_331200 0 3.817292e-07
I4214 n1_m1_264000_336000 0 6.135429e-07
I4215 n1_m1_264000_340800 0 2.108952e-07
I4216 n1_m1_264000_345600 0 2.293678e-06
I4217 n1_m1_264000_350400 0 8.938233e-07
I4218 n1_m1_264000_355200 0 1.580511e-06
I4219 n1_m1_264000_360000 0 1.616962e-06
I4220 n1_m1_264000_364800 0 1.105470e-05
I4221 n1_m1_264000_369600 0 1.878771e-06
I4222 n1_m1_264000_374400 0 5.819699e-07
I4223 n1_m1_264000_379200 0 1.123597e-06
I4224 n1_m1_264000_384000 0 1.867031e-06
I4225 n1_m1_264000_388800 0 9.577489e-07
I4226 n1_m1_264000_393600 0 2.569936e-06
I4227 n1_m1_264000_398400 0 9.428822e-07
I4228 n1_m1_264000_403200 0 1.399126e-06
I4229 n1_m1_264000_408000 0 4.412363e-06
I4230 n1_m1_264000_412800 0 2.236429e-06
I4231 n1_m1_264000_417600 0 4.858762e-06
I4232 n1_m1_264000_422400 0 2.567497e-06
I4233 n1_m1_264000_427200 0 1.834694e-06
I4234 n1_m1_264000_432000 0 3.494985e-06
I4235 n1_m1_264000_436800 0 1.750857e-06
I4236 n1_m1_264000_441600 0 5.382000e-06
I4237 n1_m1_264000_446400 0 1.634286e-06
I4238 n1_m1_264000_451200 0 3.752600e-06
I4239 n1_m1_264000_456000 0 3.710029e-06
I4240 n1_m1_264000_460800 0 6.375000e-07
I4241 n1_m1_264000_465600 0 1.431937e-06
I4242 n1_m1_264000_470400 0 1.741634e-06
I4243 n1_m1_264000_475200 0 1.424429e-06
I4244 n1_m1_264000_480000 0 2.027846e-06
I4245 n1_m1_264000_484800 0 1.099153e-06
I4246 n1_m1_264000_489600 0 1.703898e-06
I4247 n1_m1_264000_494400 0 9.510714e-08
I4248 n1_m1_264000_499200 0 5.064555e-07
I4249 n1_m1_264000_504000 0 1.402929e-06
I4250 n1_m1_264000_508800 0 2.095429e-07
I4251 n1_m1_264000_513600 0 5.135476e-07
I4252 n1_m1_264000_518400 0 1.603846e-07
I4253 n1_m1_264000_523200 0 9.494753e-08
I4254 n1_m1_264000_528000 0 9.911730e-06
I4255 n1_m1_264000_532800 0 5.591215e-07
I4256 n1_m1_264000_537600 0 6.714451e-07
I4257 n1_m1_264000_542400 0 1.084791e-07
I4258 n1_m1_264000_547200 0 1.537481e-07
I4259 n1_m1_264000_552000 0 2.248817e-07
I4260 n1_m1_264000_556800 0 2.924702e-07
I4261 n1_m1_264000_561600 0 9.306905e-08
I4262 n1_m1_264000_566400 0 2.531462e-07
I4263 n1_m1_264000_571200 0 1.661538e-07
I4264 n1_m1_264000_580800 0 4.134508e-07
I4265 n1_m1_264000_585600 0 3.012067e-07
I4266 n1_m1_268800_4800 0 7.876923e-08
I4267 n1_m1_268800_9600 0 6.564103e-09
I4268 n1_m1_268800_14400 0 4.200606e-07
I4269 n1_m1_268800_24000 0 1.636500e-07
I4270 n1_m1_268800_28800 0 3.700000e-08
I4271 n1_m1_268800_33600 0 1.081321e-07
I4272 n1_m1_268800_38400 0 1.115096e-07
I4273 n1_m1_268800_43200 0 2.137500e-07
I4274 n1_m1_268800_48000 0 4.859328e-07
I4275 n1_m1_268800_52800 0 1.634976e-07
I4276 n1_m1_268800_57600 0 8.341681e-07
I4277 n1_m1_268800_62400 0 2.326857e-07
I4278 n1_m1_268800_67200 0 3.887143e-07
I4279 n1_m1_268800_72000 0 1.930606e-07
I4280 n1_m1_268800_76800 0 2.300109e-07
I4281 n1_m1_268800_81600 0 1.847024e-07
I4282 n1_m1_268800_86400 0 4.795568e-08
I4283 n1_m1_268800_91200 0 1.287824e-07
I4284 n1_m1_268800_96000 0 6.705714e-07
I4285 n1_m1_268800_100800 0 1.950452e-07
I4286 n1_m1_268800_105600 0 1.721214e-07
I4287 n1_m1_268800_110400 0 1.171429e-07
I4288 n1_m1_268800_115200 0 9.892810e-08
I4289 n1_m1_268800_120000 0 7.478807e-07
I4290 n1_m1_268800_124800 0 5.338803e-07
I4291 n1_m1_268800_129600 0 1.214690e-06
I4292 n1_m1_268800_134400 0 1.336056e-06
I4293 n1_m1_268800_139200 0 1.311657e-06
I4294 n1_m1_268800_144000 0 9.846468e-07
I4295 n1_m1_268800_148800 0 9.915714e-07
I4296 n1_m1_268800_153600 0 1.533929e-06
I4297 n1_m1_268800_158400 0 2.374238e-06
I4298 n1_m1_268800_163200 0 1.880340e-06
I4299 n1_m1_268800_168000 0 1.873048e-06
I4300 n1_m1_268800_172800 0 1.354571e-06
I4301 n1_m1_268800_177600 0 1.132291e-06
I4302 n1_m1_268800_182400 0 1.032000e-06
I4303 n1_m1_268800_187200 0 4.492000e-07
I4304 n1_m1_268800_192000 0 6.457667e-07
I4305 n1_m1_268800_196800 0 8.596786e-07
I4306 n1_m1_268800_201600 0 6.472186e-07
I4307 n1_m1_268800_206400 0 6.738604e-07
I4308 n1_m1_268800_211200 0 5.811097e-07
I4309 n1_m1_268800_216000 0 1.157513e-05
I4310 n1_m1_268800_220800 0 4.404286e-07
I4311 n1_m1_268800_225600 0 1.896605e-06
I4312 n1_m1_268800_230400 0 9.715714e-07
I4313 n1_m1_268800_235200 0 6.407922e-07
I4314 n1_m1_268800_240000 0 2.862167e-07
I4315 n1_m1_268800_244800 0 9.841270e-07
I4316 n1_m1_268800_249600 0 9.197522e-07
I4317 n1_m1_268800_254400 0 3.448095e-08
I4318 n1_m1_268800_259200 0 6.423810e-07
I4319 n1_m1_268800_264000 0 1.564262e-06
I4320 n1_m1_268800_268800 0 1.317708e-06
I4321 n1_m1_268800_273600 0 7.677476e-07
I4322 n1_m1_268800_278400 0 7.063193e-07
I4323 n1_m1_268800_283200 0 1.666185e-06
I4324 n1_m1_268800_288000 0 2.618824e-06
I4325 n1_m1_268800_292800 0 2.782353e-06
I4326 n1_m1_268800_297600 0 1.620089e-06
I4327 n1_m1_268800_302400 0 7.073985e-07
I4328 n1_m1_268800_307200 0 7.142857e-07
I4329 n1_m1_268800_312000 0 1.316920e-06
I4330 n1_m1_268800_316800 0 9.961484e-07
I4331 n1_m1_268800_321600 0 8.602973e-07
I4332 n1_m1_268800_326400 0 5.558635e-07
I4333 n1_m1_268800_331200 0 9.121214e-07
I4334 n1_m1_268800_336000 0 1.032190e-06
I4335 n1_m1_268800_340800 0 1.708571e-07
I4336 n1_m1_268800_345600 0 1.239841e-06
I4337 n1_m1_268800_350400 0 1.227964e-06
I4338 n1_m1_268800_355200 0 2.536104e-07
I4339 n1_m1_268800_360000 0 1.692931e-06
I4340 n1_m1_268800_364800 0 6.598333e-07
I4341 n1_m1_268800_369600 0 4.978810e-07
I4342 n1_m1_268800_374400 0 8.349651e-07
I4343 n1_m1_268800_379200 0 1.255673e-06
I4344 n1_m1_268800_384000 0 2.045722e-06
I4345 n1_m1_268800_388800 0 1.120286e-06
I4346 n1_m1_268800_393600 0 8.022177e-07
I4347 n1_m1_268800_398400 0 1.761682e-06
I4348 n1_m1_268800_403200 0 1.689404e-06
I4349 n1_m1_268800_408000 0 2.840542e-06
I4350 n1_m1_268800_412800 0 1.751000e-06
I4351 n1_m1_268800_417600 0 3.660000e-06
I4352 n1_m1_268800_422400 0 2.228762e-06
I4353 n1_m1_268800_427200 0 1.006857e-06
I4354 n1_m1_268800_432000 0 1.208420e-06
I4355 n1_m1_268800_436800 0 8.390536e-07
I4356 n1_m1_268800_441600 0 1.746429e-06
I4357 n1_m1_268800_446400 0 1.135714e-06
I4358 n1_m1_268800_451200 0 1.616952e-06
I4359 n1_m1_268800_456000 0 1.877581e-06
I4360 n1_m1_268800_460800 0 6.630952e-07
I4361 n1_m1_268800_465600 0 2.440311e-06
I4362 n1_m1_268800_470400 0 1.072024e-06
I4363 n1_m1_268800_475200 0 7.442857e-07
I4364 n1_m1_268800_480000 0 1.368218e-06
I4365 n1_m1_268800_484800 0 7.508277e-07
I4366 n1_m1_268800_489600 0 1.436527e-06
I4367 n1_m1_268800_494400 0 3.392206e-07
I4368 n1_m1_268800_499200 0 1.654487e-06
I4369 n1_m1_268800_504000 0 2.263576e-06
I4370 n1_m1_268800_508800 0 6.418571e-08
I4371 n1_m1_268800_513600 0 9.074738e-07
I4372 n1_m1_268800_518400 0 5.266923e-08
I4373 n1_m1_268800_523200 0 1.259986e-07
I4374 n1_m1_268800_528000 0 1.642696e-07
I4375 n1_m1_268800_532800 0 8.140000e-08
I4376 n1_m1_268800_537600 0 2.055897e-07
I4377 n1_m1_268800_542400 0 6.834359e-08
I4378 n1_m1_268800_547200 0 7.488462e-08
I4379 n1_m1_268800_552000 0 1.842013e-07
I4380 n1_m1_268800_556800 0 1.452641e-07
I4381 n1_m1_268800_561600 0 2.449762e-08
I4382 n1_m1_268800_566400 0 3.102678e-07
I4383 n1_m1_268800_571200 0 1.672513e-07
I4384 n1_m1_268800_580800 0 2.953671e-07
I4385 n1_m1_268800_585600 0 2.230045e-07
I4386 n1_m1_273600_4800 0 3.120000e-08
I4387 n1_m1_273600_9600 0 4.507250e-07
I4388 n1_m1_273600_19200 0 3.660000e-08
I4389 n1_m1_273600_24000 0 2.672000e-07
I4390 n1_m1_273600_28800 0 4.072857e-08
I4391 n1_m1_273600_33600 0 2.150525e-07
I4392 n1_m1_273600_38400 0 1.590673e-07
I4393 n1_m1_273600_43200 0 1.889577e-07
I4394 n1_m1_273600_48000 0 2.404852e-07
I4395 n1_m1_273600_52800 0 9.245714e-08
I4396 n1_m1_273600_57600 0 7.955016e-07
I4397 n1_m1_273600_62400 0 3.635429e-07
I4398 n1_m1_273600_67200 0 6.798000e-07
I4399 n1_m1_273600_72000 0 3.055000e-07
I4400 n1_m1_273600_76800 0 2.650000e-07
I4401 n1_m1_273600_81600 0 3.870714e-07
I4402 n1_m1_273600_86400 0 3.975055e-07
I4403 n1_m1_273600_91200 0 2.853112e-06
I4404 n1_m1_273600_96000 0 1.855247e-06
I4405 n1_m1_273600_100800 0 1.864592e-07
I4406 n1_m1_273600_105600 0 1.024879e-06
I4407 n1_m1_273600_110400 0 3.299603e-07
I4408 n1_m1_273600_115200 0 3.045441e-07
I4409 n1_m1_273600_120000 0 2.015857e-06
I4410 n1_m1_273600_124800 0 3.739286e-06
I4411 n1_m1_273600_129600 0 2.166833e-06
I4412 n1_m1_273600_134400 0 2.836683e-06
I4413 n1_m1_273600_139200 0 1.084778e-06
I4414 n1_m1_273600_144000 0 4.545735e-06
I4415 n1_m1_273600_148800 0 3.379013e-06
I4416 n1_m1_273600_153600 0 3.127857e-06
I4417 n1_m1_273600_158400 0 5.219429e-06
I4418 n1_m1_273600_163200 0 1.941065e-06
I4419 n1_m1_273600_168000 0 4.283429e-06
I4420 n1_m1_273600_172800 0 2.198571e-06
I4421 n1_m1_273600_177600 0 4.403810e-06
I4422 n1_m1_273600_182400 0 1.749476e-06
I4423 n1_m1_273600_187200 0 1.879429e-06
I4424 n1_m1_273600_192000 0 2.277286e-06
I4425 n1_m1_273600_196800 0 7.619633e-07
I4426 n1_m1_273600_201600 0 2.188324e-06
I4427 n1_m1_273600_206400 0 9.219968e-07
I4428 n1_m1_273600_211200 0 1.007065e-06
I4429 n1_m1_273600_216000 0 1.786362e-06
I4430 n1_m1_273600_220800 0 4.503429e-07
I4431 n1_m1_273600_225600 0 2.060286e-06
I4432 n1_m1_273600_230400 0 7.445714e-07
I4433 n1_m1_273600_235200 0 1.287792e-07
I4434 n1_m1_273600_240000 0 3.093764e-06
I4435 n1_m1_273600_244800 0 1.000381e-06
I4436 n1_m1_273600_249600 0 3.003460e-06
I4437 n1_m1_273600_254400 0 7.609841e-07
I4438 n1_m1_273600_259200 0 1.931905e-06
I4439 n1_m1_273600_264000 0 1.652095e-06
I4440 n1_m1_273600_268800 0 1.314527e-06
I4441 n1_m1_273600_273600 0 8.218048e-07
I4442 n1_m1_273600_278400 0 5.979762e-07
I4443 n1_m1_273600_283200 0 1.346857e-06
I4444 n1_m1_273600_288000 0 2.802213e-06
I4445 n1_m1_273600_292800 0 2.530097e-06
I4446 n1_m1_273600_297600 0 2.952744e-06
I4447 n1_m1_273600_302400 0 1.137153e-06
I4448 n1_m1_273600_307200 0 5.403534e-07
I4449 n1_m1_273600_312000 0 1.333112e-06
I4450 n1_m1_273600_316800 0 6.996112e-07
I4451 n1_m1_273600_321600 0 1.076755e-06
I4452 n1_m1_273600_326400 0 5.598124e-07
I4453 n1_m1_273600_331200 0 5.991258e-07
I4454 n1_m1_273600_336000 0 1.537476e-06
I4455 n1_m1_273600_340800 0 9.456825e-07
I4456 n1_m1_273600_345600 0 1.267683e-06
I4457 n1_m1_273600_350400 0 1.913465e-06
I4458 n1_m1_273600_355200 0 5.459740e-07
I4459 n1_m1_273600_360000 0 1.005371e-06
I4460 n1_m1_273600_364800 0 3.132429e-06
I4461 n1_m1_273600_369600 0 3.069429e-06
I4462 n1_m1_273600_374400 0 6.360392e-07
I4463 n1_m1_273600_379200 0 7.657000e-07
I4464 n1_m1_273600_384000 0 5.504444e-07
I4465 n1_m1_273600_388800 0 1.070000e-06
I4466 n1_m1_273600_393600 0 1.638647e-06
I4467 n1_m1_273600_398400 0 2.762784e-06
I4468 n1_m1_273600_403200 0 1.983981e-06
I4469 n1_m1_273600_408000 0 3.121434e-06
I4470 n1_m1_273600_412800 0 2.000000e-06
I4471 n1_m1_273600_417600 0 3.323286e-06
I4472 n1_m1_273600_422400 0 2.230048e-06
I4473 n1_m1_273600_427200 0 2.084286e-06
I4474 n1_m1_273600_432000 0 1.718638e-06
I4475 n1_m1_273600_436800 0 1.422575e-06
I4476 n1_m1_273600_441600 0 5.032857e-06
I4477 n1_m1_273600_446400 0 3.796429e-06
I4478 n1_m1_273600_451200 0 2.210524e-06
I4479 n1_m1_273600_456000 0 3.177619e-06
I4480 n1_m1_273600_460800 0 1.303571e-06
I4481 n1_m1_273600_465600 0 2.480762e-06
I4482 n1_m1_273600_470400 0 1.523950e-06
I4483 n1_m1_273600_475200 0 1.868445e-06
I4484 n1_m1_273600_480000 0 2.486303e-06
I4485 n1_m1_273600_484800 0 1.448440e-06
I4486 n1_m1_273600_489600 0 1.312055e-06
I4487 n1_m1_273600_494400 0 4.754151e-07
I4488 n1_m1_273600_499200 0 7.402000e-07
I4489 n1_m1_273600_504000 0 5.514607e-07
I4490 n1_m1_273600_508800 0 1.598571e-07
I4491 n1_m1_273600_513600 0 2.014976e-07
I4492 n1_m1_273600_518400 0 5.212692e-07
I4493 n1_m1_273600_523200 0 2.596593e-07
I4494 n1_m1_273600_528000 0 1.305381e-07
I4495 n1_m1_273600_532800 0 6.420308e-07
I4496 n1_m1_273600_537600 0 1.430841e-06
I4497 n1_m1_273600_542400 0 4.749949e-07
I4498 n1_m1_273600_547200 0 2.524231e-07
I4499 n1_m1_273600_552000 0 3.076518e-07
I4500 n1_m1_273600_556800 0 1.742051e-07
I4501 n1_m1_273600_561600 0 1.970381e-07
I4502 n1_m1_273600_566400 0 1.209311e-07
I4503 n1_m1_273600_571200 0 5.806410e-08
I4504 n1_m1_273600_580800 0 5.009790e-07
I4505 n1_m1_273600_585600 0 3.982119e-07
I4506 n1_m1_278400_4800 0 2.178462e-08
I4507 n1_m1_278400_9600 0 5.096904e-07
I4508 n1_m1_278400_24000 0 1.626000e-07
I4509 n1_m1_278400_28800 0 8.351429e-08
I4510 n1_m1_278400_33600 0 1.344816e-07
I4511 n1_m1_278400_38400 0 1.639744e-08
I4512 n1_m1_278400_43200 0 7.230385e-08
I4513 n1_m1_278400_48000 0 8.124258e-08
I4514 n1_m1_278400_52800 0 1.523933e-07
I4515 n1_m1_278400_57600 0 4.062765e-07
I4516 n1_m1_278400_62400 0 2.474899e-07
I4517 n1_m1_278400_67200 0 2.264571e-07
I4518 n1_m1_278400_72000 0 6.699026e-07
I4519 n1_m1_278400_76800 0 6.511648e-08
I4520 n1_m1_278400_81600 0 3.392071e-07
I4521 n1_m1_278400_86400 0 1.545418e-07
I4522 n1_m1_278400_91200 0 6.488396e-08
I4523 n1_m1_278400_96000 0 3.330035e-07
I4524 n1_m1_278400_100800 0 8.878367e-08
I4525 n1_m1_278400_105600 0 1.947381e-07
I4526 n1_m1_278400_110400 0 4.165278e-07
I4527 n1_m1_278400_115200 0 1.934444e-07
I4528 n1_m1_278400_120000 0 3.562306e-07
I4529 n1_m1_278400_124800 0 9.892950e-07
I4530 n1_m1_278400_129600 0 2.053986e-06
I4531 n1_m1_278400_134400 0 1.806543e-06
I4532 n1_m1_278400_139200 0 2.144357e-06
I4533 n1_m1_278400_144000 0 2.088888e-06
I4534 n1_m1_278400_148800 0 4.302338e-07
I4535 n1_m1_278400_153600 0 1.774857e-06
I4536 n1_m1_278400_158400 0 1.910571e-06
I4537 n1_m1_278400_163200 0 1.184000e-06
I4538 n1_m1_278400_168000 0 2.510488e-06
I4539 n1_m1_278400_172800 0 5.050000e-07
I4540 n1_m1_278400_177600 0 1.289636e-06
I4541 n1_m1_278400_182400 0 1.738262e-06
I4542 n1_m1_278400_187200 0 7.870794e-07
I4543 n1_m1_278400_192000 0 1.113357e-06
I4544 n1_m1_278400_196800 0 9.699796e-07
I4545 n1_m1_278400_201600 0 1.163766e-06
I4546 n1_m1_278400_206400 0 1.736786e-07
I4547 n1_m1_278400_211200 0 4.836905e-08
I4548 n1_m1_278400_216000 0 2.977857e-08
I4549 n1_m1_278400_220800 0 1.149482e-07
I4550 n1_m1_278400_225600 0 5.881764e-07
I4551 n1_m1_278400_230400 0 7.306667e-08
I4552 n1_m1_278400_235200 0 7.375000e-08
I4553 n1_m1_278400_240000 0 9.366607e-08
I4554 n1_m1_278400_244800 0 6.883452e-08
I4555 n1_m1_278400_249600 0 6.808611e-07
I4556 n1_m1_278400_254400 0 1.883063e-07
I4557 n1_m1_278400_259200 0 3.761429e-07
I4558 n1_m1_278400_264000 0 1.028026e-06
I4559 n1_m1_278400_268800 0 9.323759e-07
I4560 n1_m1_278400_273600 0 2.300095e-06
I4561 n1_m1_278400_278400 0 1.050516e-06
I4562 n1_m1_278400_283200 0 6.977540e-07
I4563 n1_m1_278400_288000 0 1.435553e-06
I4564 n1_m1_278400_292800 0 1.183605e-06
I4565 n1_m1_278400_297600 0 3.797143e-06
I4566 n1_m1_278400_302400 0 4.663714e-07
I4567 n1_m1_278400_307200 0 5.718371e-07
I4568 n1_m1_278400_312000 0 1.375844e-06
I4569 n1_m1_278400_316800 0 2.109610e-07
I4570 n1_m1_278400_321600 0 2.894643e-07
I4571 n1_m1_278400_326400 0 1.426797e-07
I4572 n1_m1_278400_331200 0 7.701169e-08
I4573 n1_m1_278400_336000 0 6.967619e-07
I4574 n1_m1_278400_340800 0 6.622540e-07
I4575 n1_m1_278400_345600 0 1.667661e-07
I4576 n1_m1_278400_350400 0 6.851500e-07
I4577 n1_m1_278400_355200 0 1.170857e-07
I4578 n1_m1_278400_360000 0 2.345310e-07
I4579 n1_m1_278400_364800 0 1.912883e-06
I4580 n1_m1_278400_369600 0 6.068952e-07
I4581 n1_m1_278400_374400 0 1.182829e-07
I4582 n1_m1_278400_379200 0 7.486735e-08
I4583 n1_m1_278400_384000 0 1.724160e-07
I4584 n1_m1_278400_388800 0 1.177232e-07
I4585 n1_m1_278400_393600 0 2.208952e-07
I4586 n1_m1_278400_398400 0 1.863442e-06
I4587 n1_m1_278400_403200 0 2.079620e-06
I4588 n1_m1_278400_408000 0 3.576500e-06
I4589 n1_m1_278400_412800 0 1.026286e-06
I4590 n1_m1_278400_417600 0 2.453714e-06
I4591 n1_m1_278400_422400 0 2.133286e-06
I4592 n1_m1_278400_427200 0 2.665714e-06
I4593 n1_m1_278400_432000 0 1.012657e-06
I4594 n1_m1_278400_436800 0 4.075143e-07
I4595 n1_m1_278400_441600 0 3.593143e-06
I4596 n1_m1_278400_446400 0 2.557857e-06
I4597 n1_m1_278400_451200 0 1.098238e-06
I4598 n1_m1_278400_456000 0 1.479536e-06
I4599 n1_m1_278400_460800 0 3.304762e-07
I4600 n1_m1_278400_465600 0 4.009103e-06
I4601 n1_m1_278400_470400 0 7.684790e-07
I4602 n1_m1_278400_475200 0 1.165840e-06
I4603 n1_m1_278400_480000 0 6.902017e-07
I4604 n1_m1_278400_484800 0 1.091899e-06
I4605 n1_m1_278400_489600 0 1.915900e-06
I4606 n1_m1_278400_494400 0 1.925143e-07
I4607 n1_m1_278400_499200 0 2.226571e-07
I4608 n1_m1_278400_504000 0 5.905607e-07
I4609 n1_m1_278400_508800 0 4.383857e-07
I4610 n1_m1_278400_513600 0 1.404895e-06
I4611 n1_m1_278400_518400 0 5.040808e-07
I4612 n1_m1_278400_523200 0 5.714066e-08
I4613 n1_m1_278400_528000 0 1.782619e-07
I4614 n1_m1_278400_532800 0 1.773431e-06
I4615 n1_m1_278400_537600 0 1.454430e-06
I4616 n1_m1_278400_542400 0 2.189753e-07
I4617 n1_m1_278400_547200 0 2.174769e-07
I4618 n1_m1_278400_552000 0 1.669256e-07
I4619 n1_m1_278400_556800 0 1.435308e-07
I4620 n1_m1_278400_561600 0 3.531524e-07
I4621 n1_m1_278400_566400 0 4.157143e-07
I4622 n1_m1_278400_576000 0 3.738095e-08
I4623 n1_m1_278400_580800 0 2.349934e-07
I4624 n1_m1_278400_585600 0 2.809231e-08
I4625 n1_m1_283200_4800 0 2.507692e-08
I4626 n1_m1_283200_9600 0 1.948974e-08
I4627 n1_m1_283200_24000 0 2.890000e-08
I4628 n1_m1_283200_28800 0 2.420952e-08
I4629 n1_m1_283200_33600 0 7.502381e-08
I4630 n1_m1_283200_38400 0 6.013333e-08
I4631 n1_m1_283200_43200 0 5.851154e-08
I4632 n1_m1_283200_48000 0 6.118013e-08
I4633 n1_m1_283200_52800 0 3.697118e-07
I4634 n1_m1_283200_57600 0 8.287542e-07
I4635 n1_m1_283200_62400 0 2.275672e-07
I4636 n1_m1_283200_67200 0 7.062857e-08
I4637 n1_m1_283200_72000 0 2.341282e-07
I4638 n1_m1_283200_76800 0 4.802418e-08
I4639 n1_m1_283200_81600 0 1.335357e-07
I4640 n1_m1_283200_86400 0 4.715055e-08
I4641 n1_m1_283200_91200 0 6.842088e-08
I4642 n1_m1_283200_96000 0 6.487143e-08
I4643 n1_m1_283200_100800 0 5.060571e-07
I4644 n1_m1_283200_105600 0 1.301524e-07
I4645 n1_m1_283200_110400 0 1.987024e-07
I4646 n1_m1_283200_115200 0 1.021929e-07
I4647 n1_m1_283200_120000 0 1.448551e-07
I4648 n1_m1_283200_124800 0 3.876693e-07
I4649 n1_m1_283200_129600 0 4.950612e-07
I4650 n1_m1_283200_134400 0 1.790643e-07
I4651 n1_m1_283200_139200 0 8.986429e-07
I4652 n1_m1_283200_144000 0 6.226623e-07
I4653 n1_m1_283200_148800 0 2.406104e-07
I4654 n1_m1_283200_153600 0 8.134286e-07
I4655 n1_m1_283200_158400 0 6.450000e-07
I4656 n1_m1_283200_163200 0 7.321429e-08
I4657 n1_m1_283200_168000 0 7.618690e-07
I4658 n1_m1_283200_172800 0 4.480476e-07
I4659 n1_m1_283200_177600 0 5.458636e-07
I4660 n1_m1_283200_182400 0 6.955952e-07
I4661 n1_m1_283200_187200 0 3.507937e-07
I4662 n1_m1_283200_192000 0 5.755000e-07
I4663 n1_m1_283200_196800 0 7.400476e-07
I4664 n1_m1_283200_201600 0 2.556667e-07
I4665 n1_m1_283200_206400 0 3.050357e-07
I4666 n1_m1_283200_211200 0 1.928571e-07
I4667 n1_m1_283200_216000 0 3.503262e-07
I4668 n1_m1_283200_220800 0 4.843750e-08
I4669 n1_m1_283200_225600 0 1.826808e-07
I4670 n1_m1_283200_230400 0 4.507619e-08
I4671 n1_m1_283200_235200 0 4.755000e-08
I4672 n1_m1_283200_240000 0 1.231863e-07
I4673 n1_m1_283200_244800 0 8.795595e-08
I4674 n1_m1_283200_249600 0 8.783571e-08
I4675 n1_m1_283200_254400 0 8.291131e-08
I4676 n1_m1_283200_259200 0 3.124000e-07
I4677 n1_m1_283200_264000 0 1.921102e-07
I4678 n1_m1_283200_268800 0 2.157864e-07
I4679 n1_m1_283200_273600 0 3.794286e-07
I4680 n1_m1_283200_278400 0 7.700794e-07
I4681 n1_m1_283200_283200 0 6.434603e-07
I4682 n1_m1_283200_288000 0 2.620794e-07
I4683 n1_m1_283200_292800 0 6.298413e-07
I4684 n1_m1_283200_297600 0 1.210889e-06
I4685 n1_m1_283200_302400 0 3.761429e-07
I4686 n1_m1_283200_307200 0 1.147738e-06
I4687 n1_m1_283200_312000 0 6.188117e-07
I4688 n1_m1_283200_316800 0 8.783766e-08
I4689 n1_m1_283200_321600 0 1.909429e-07
I4690 n1_m1_283200_326400 0 1.310619e-07
I4691 n1_m1_283200_331200 0 1.705833e-07
I4692 n1_m1_283200_336000 0 5.054762e-07
I4693 n1_m1_283200_340800 0 1.435410e-07
I4694 n1_m1_283200_345600 0 1.129992e-07
I4695 n1_m1_283200_350400 0 6.300000e-08
I4696 n1_m1_283200_355200 0 7.195714e-08
I4697 n1_m1_283200_360000 0 1.661137e-07
I4698 n1_m1_283200_364800 0 9.854545e-08
I4699 n1_m1_283200_369600 0 8.692619e-08
I4700 n1_m1_283200_374400 0 1.015571e-07
I4701 n1_m1_283200_379200 0 4.167551e-08
I4702 n1_m1_283200_384000 0 9.202509e-08
I4703 n1_m1_283200_388800 0 2.017054e-07
I4704 n1_m1_283200_393600 0 1.475053e-07
I4705 n1_m1_283200_398400 0 4.968626e-07
I4706 n1_m1_283200_403200 0 1.172619e-06
I4707 n1_m1_283200_408000 0 2.035714e-06
I4708 n1_m1_283200_412800 0 1.114286e-06
I4709 n1_m1_283200_417600 0 3.116667e-07
I4710 n1_m1_283200_422400 0 1.244286e-07
I4711 n1_m1_283200_427200 0 7.465714e-07
I4712 n1_m1_283200_432000 0 5.498750e-07
I4713 n1_m1_283200_436800 0 1.946429e-07
I4714 n1_m1_283200_441600 0 1.221429e-06
I4715 n1_m1_283200_446400 0 1.150357e-06
I4716 n1_m1_283200_451200 0 1.880000e-07
I4717 n1_m1_283200_456000 0 6.344286e-07
I4718 n1_m1_283200_460800 0 2.016964e-07
I4719 n1_m1_283200_465600 0 7.091667e-07
I4720 n1_m1_283200_470400 0 4.303125e-07
I4721 n1_m1_283200_480000 0 6.083333e-08
I4722 n1_m1_283200_484800 0 5.441933e-07
I4723 n1_m1_283200_489600 0 7.685714e-07
I4724 n1_m1_283200_504000 0 1.894643e-07
I4725 n1_m1_283200_508800 0 2.328571e-08
I4726 n1_m1_283200_513600 0 3.059375e-08
I4727 n1_m1_283200_518400 0 1.229750e-06
I4728 n1_m1_283200_523200 0 8.125714e-08
I4729 n1_m1_283200_528000 0 7.984286e-08
I4730 n1_m1_283200_532800 0 6.282423e-07
I4731 n1_m1_283200_537600 0 7.170549e-07
I4732 n1_m1_283200_542400 0 6.531703e-08
I4733 n1_m1_283200_547200 0 4.765385e-08
I4734 n1_m1_283200_552000 0 1.232277e-07
I4735 n1_m1_283200_556800 0 8.193846e-08
I4736 n1_m1_283200_561600 0 2.458036e-07
I4737 n1_m1_283200_566400 0 2.598214e-07
I4738 n1_m1_283200_576000 0 7.537851e-08
I4739 n1_m1_283200_580800 0 3.826711e-07
I4740 n1_m1_283200_585600 0 2.693846e-08
I4741 n1_m1_288000_19200 0 1.760000e-07
I4742 n1_m1_288000_24000 0 3.241333e-07
I4743 n1_m1_288000_28800 0 9.859714e-08
I4744 n1_m1_288000_33600 0 1.855382e-07
I4745 n1_m1_288000_38400 0 7.878462e-08
I4746 n1_m1_288000_43200 0 3.199000e-07
I4747 n1_m1_288000_48000 0 3.666899e-07
I4748 n1_m1_288000_52800 0 1.792448e-07
I4749 n1_m1_288000_57600 0 7.889367e-07
I4750 n1_m1_288000_62400 0 2.421061e-07
I4751 n1_m1_288000_67200 0 2.133643e-07
I4752 n1_m1_288000_72000 0 6.611615e-07
I4753 n1_m1_288000_76800 0 2.249527e-07
I4754 n1_m1_288000_81600 0 3.773878e-08
I4755 n1_m1_288000_86400 0 5.461961e-08
I4756 n1_m1_288000_91200 0 8.209495e-08
I4757 n1_m1_288000_96000 0 2.248714e-07
I4758 n1_m1_288000_100800 0 3.094286e-07
I4759 n1_m1_288000_105600 0 3.578092e-07
I4760 n1_m1_288000_110400 0 1.294286e-07
I4761 n1_m1_288000_115200 0 4.532429e-07
I4762 n1_m1_288000_120000 0 4.424429e-06
I4763 n1_m1_288000_124800 0 3.219048e-06
I4764 n1_m1_288000_129600 0 3.186248e-06
I4765 n1_m1_288000_134400 0 2.954819e-06
I4766 n1_m1_288000_139200 0 2.485714e-06
I4767 n1_m1_288000_144000 0 5.493626e-06
I4768 n1_m1_288000_148800 0 1.691176e-06
I4769 n1_m1_288000_153600 0 2.310214e-06
I4770 n1_m1_288000_158400 0 1.574000e-06
I4771 n1_m1_288000_163200 0 1.362436e-06
I4772 n1_m1_288000_168000 0 1.871334e-06
I4773 n1_m1_288000_172800 0 1.711857e-06
I4774 n1_m1_288000_177600 0 1.315857e-06
I4775 n1_m1_288000_182400 0 1.347841e-06
I4776 n1_m1_288000_187200 0 5.542143e-07
I4777 n1_m1_288000_192000 0 1.309513e-06
I4778 n1_m1_288000_196800 0 8.260000e-08
I4779 n1_m1_288000_201600 0 2.900146e-07
I4780 n1_m1_288000_206400 0 9.254429e-08
I4781 n1_m1_288000_211200 0 1.020429e-07
I4782 n1_m1_288000_216000 0 2.242714e-07
I4783 n1_m1_288000_220800 0 7.155857e-07
I4784 n1_m1_288000_225600 0 2.793667e-07
I4785 n1_m1_288000_230400 0 8.302857e-08
I4786 n1_m1_288000_235200 0 1.152286e-07
I4787 n1_m1_288000_240000 0 2.588473e-07
I4788 n1_m1_288000_244800 0 7.710476e-08
I4789 n1_m1_288000_249600 0 2.878286e-07
I4790 n1_m1_288000_254400 0 1.743190e-07
I4791 n1_m1_288000_259200 0 2.735714e-07
I4792 n1_m1_288000_264000 0 1.110849e-07
I4793 n1_m1_288000_268800 0 9.213320e-08
I4794 n1_m1_288000_273600 0 7.364563e-07
I4795 n1_m1_288000_278400 0 2.140918e-06
I4796 n1_m1_288000_283200 0 8.311358e-07
I4797 n1_m1_288000_288000 0 2.073555e-06
I4798 n1_m1_288000_292800 0 7.181111e-07
I4799 n1_m1_288000_297600 0 1.212794e-06
I4800 n1_m1_288000_302400 0 7.621422e-07
I4801 n1_m1_288000_307200 0 5.769388e-07
I4802 n1_m1_288000_312000 0 1.421777e-06
I4803 n1_m1_288000_316800 0 5.207760e-07
I4804 n1_m1_288000_321600 0 6.925500e-07
I4805 n1_m1_288000_326400 0 7.734000e-07
I4806 n1_m1_288000_331200 0 5.979714e-07
I4807 n1_m1_288000_336000 0 4.998905e-07
I4808 n1_m1_288000_340800 0 1.780857e-07
I4809 n1_m1_288000_345600 0 2.482286e-07
I4810 n1_m1_288000_350400 0 1.785125e-07
I4811 n1_m1_288000_355200 0 4.738571e-08
I4812 n1_m1_288000_360000 0 2.978976e-07
I4813 n1_m1_288000_364800 0 1.378921e-07
I4814 n1_m1_288000_369600 0 1.531143e-06
I4815 n1_m1_288000_374400 0 8.590000e-08
I4816 n1_m1_288000_379200 0 7.508266e-07
I4817 n1_m1_288000_384000 0 3.960905e-07
I4818 n1_m1_288000_388800 0 1.862143e-07
I4819 n1_m1_288000_393600 0 2.915667e-07
I4820 n1_m1_288000_398400 0 3.969524e-07
I4821 n1_m1_288000_403200 0 1.050681e-06
I4822 n1_m1_288000_408000 0 1.427695e-06
I4823 n1_m1_288000_412800 0 3.911429e-06
I4824 n1_m1_288000_417600 0 2.021470e-06
I4825 n1_m1_288000_422400 0 1.490438e-06
I4826 n1_m1_288000_427200 0 2.655510e-06
I4827 n1_m1_288000_432000 0 2.217143e-06
I4828 n1_m1_288000_436800 0 4.858831e-07
I4829 n1_m1_288000_441600 0 2.097952e-06
I4830 n1_m1_288000_446400 0 2.198571e-06
I4831 n1_m1_288000_451200 0 1.750619e-06
I4832 n1_m1_288000_456000 0 2.676551e-06
I4833 n1_m1_288000_460800 0 1.338020e-06
I4834 n1_m1_288000_465600 0 1.517467e-06
I4835 n1_m1_288000_470400 0 1.320215e-06
I4836 n1_m1_288000_475200 0 1.285000e-06
I4837 n1_m1_288000_480000 0 1.789929e-06
I4838 n1_m1_288000_484800 0 1.176190e-07
I4839 n1_m1_288000_499200 0 1.664286e-08
I4840 n1_m1_288000_504000 0 4.160714e-08
I4841 n1_m1_288000_513600 0 3.365313e-07
I4842 n1_m1_288000_518400 0 1.306495e-06
I4843 n1_m1_288000_523200 0 3.179084e-07
I4844 n1_m1_288000_528000 0 3.591126e-07
I4845 n1_m1_288000_532800 0 3.599410e-06
I4846 n1_m1_288000_537600 0 7.952564e-07
I4847 n1_m1_288000_547200 0 6.093750e-07
I4848 n1_m1_288000_580800 0 2.976538e-08
I4849 n1_m1_288000_585600 0 9.017003e-08
I4850 n1_m1_292800_24000 0 1.090000e-07
I4851 n1_m1_292800_28800 0 1.293343e-07
I4852 n1_m1_292800_33600 0 1.075980e-07
I4853 n1_m1_292800_38400 0 8.170769e-08
I4854 n1_m1_292800_43200 0 2.855077e-07
I4855 n1_m1_292800_48000 0 2.992881e-07
I4856 n1_m1_292800_52800 0 6.082067e-07
I4857 n1_m1_292800_57600 0 3.626490e-07
I4858 n1_m1_292800_62400 0 9.672245e-08
I4859 n1_m1_292800_67200 0 1.137429e-07
I4860 n1_m1_292800_72000 0 1.003277e-07
I4861 n1_m1_292800_76800 0 3.615780e-07
I4862 n1_m1_292800_81600 0 2.184612e-07
I4863 n1_m1_292800_86400 0 2.483323e-07
I4864 n1_m1_292800_91200 0 8.099919e-08
I4865 n1_m1_292800_96000 0 2.599714e-07
I4866 n1_m1_292800_100800 0 9.102143e-08
I4867 n1_m1_292800_105600 0 3.693622e-07
I4868 n1_m1_292800_110400 0 8.780126e-07
I4869 n1_m1_292800_115200 0 1.659546e-07
I4870 n1_m1_292800_120000 0 6.317087e-07
I4871 n1_m1_292800_124800 0 1.085714e-06
I4872 n1_m1_292800_129600 0 2.045276e-06
I4873 n1_m1_292800_134400 0 1.643752e-06
I4874 n1_m1_292800_139200 0 1.228571e-06
I4875 n1_m1_292800_144000 0 3.709714e-06
I4876 n1_m1_292800_148800 0 5.562571e-07
I4877 n1_m1_292800_153600 0 1.865214e-06
I4878 n1_m1_292800_158400 0 9.849925e-07
I4879 n1_m1_292800_163200 0 1.536158e-06
I4880 n1_m1_292800_168000 0 1.637041e-06
I4881 n1_m1_292800_172800 0 2.035451e-06
I4882 n1_m1_292800_177600 0 1.212932e-06
I4883 n1_m1_292800_182400 0 2.941778e-07
I4884 n1_m1_292800_187200 0 1.150000e-07
I4885 n1_m1_292800_192000 0 5.325035e-07
I4886 n1_m1_292800_196800 0 3.684643e-07
I4887 n1_m1_292800_201600 0 4.046711e-07
I4888 n1_m1_292800_206400 0 2.204143e-08
I4889 n1_m1_292800_211200 0 4.125571e-07
I4890 n1_m1_292800_216000 0 2.586571e-07
I4891 n1_m1_292800_220800 0 2.868857e-07
I4892 n1_m1_292800_225600 0 2.077571e-07
I4893 n1_m1_292800_230400 0 3.484286e-07
I4894 n1_m1_292800_235200 0 4.058571e-07
I4895 n1_m1_292800_240000 0 3.221527e-07
I4896 n1_m1_292800_244800 0 3.389524e-07
I4897 n1_m1_292800_249600 0 4.576857e-07
I4898 n1_m1_292800_254400 0 3.442068e-07
I4899 n1_m1_292800_259200 0 1.249551e-07
I4900 n1_m1_292800_264000 0 1.705722e-07
I4901 n1_m1_292800_268800 0 2.365790e-07
I4902 n1_m1_292800_273600 0 3.046779e-07
I4903 n1_m1_292800_278400 0 6.756531e-07
I4904 n1_m1_292800_283200 0 1.040386e-06
I4905 n1_m1_292800_288000 0 2.156352e-06
I4906 n1_m1_292800_292800 0 6.147222e-07
I4907 n1_m1_292800_297600 0 1.001559e-06
I4908 n1_m1_292800_302400 0 2.576422e-07
I4909 n1_m1_292800_307200 0 1.171627e-06
I4910 n1_m1_292800_312000 0 9.665794e-07
I4911 n1_m1_292800_316800 0 2.869027e-07
I4912 n1_m1_292800_321600 0 4.950019e-07
I4913 n1_m1_292800_326400 0 3.714286e-08
I4914 n1_m1_292800_331200 0 4.501540e-07
I4915 n1_m1_292800_336000 0 3.087980e-07
I4916 n1_m1_292800_340800 0 5.437143e-08
I4917 n1_m1_292800_345600 0 8.036143e-07
I4918 n1_m1_292800_350400 0 8.998750e-08
I4919 n1_m1_292800_355200 0 4.278571e-08
I4920 n1_m1_292800_360000 0 1.250310e-07
I4921 n1_m1_292800_364800 0 9.642571e-08
I4922 n1_m1_292800_369600 0 2.053714e-07
I4923 n1_m1_292800_374400 0 1.211429e-07
I4924 n1_m1_292800_379200 0 2.198254e-07
I4925 n1_m1_292800_384000 0 2.169771e-07
I4926 n1_m1_292800_388800 0 3.916857e-08
I4927 n1_m1_292800_393600 0 2.500952e-07
I4928 n1_m1_292800_398400 0 4.829333e-07
I4929 n1_m1_292800_403200 0 3.354857e-07
I4930 n1_m1_292800_408000 0 1.217452e-06
I4931 n1_m1_292800_412800 0 2.807571e-06
I4932 n1_m1_292800_417600 0 1.015869e-06
I4933 n1_m1_292800_422400 0 6.727514e-07
I4934 n1_m1_292800_427200 0 2.039016e-06
I4935 n1_m1_292800_432000 0 2.637905e-06
I4936 n1_m1_292800_436800 0 1.236403e-06
I4937 n1_m1_292800_441600 0 3.929048e-06
I4938 n1_m1_292800_446400 0 2.013571e-06
I4939 n1_m1_292800_451200 0 2.633286e-06
I4940 n1_m1_292800_456000 0 4.439306e-06
I4941 n1_m1_292800_460800 0 1.616265e-06
I4942 n1_m1_292800_465600 0 1.541568e-06
I4943 n1_m1_292800_470400 0 7.709899e-07
I4944 n1_m1_292800_475200 0 3.321429e-07
I4945 n1_m1_292800_480000 0 1.976743e-07
I4946 n1_m1_292800_484800 0 1.040457e-07
I4947 n1_m1_292800_489600 0 1.356571e-07
I4948 n1_m1_292800_494400 0 9.146667e-08
I4949 n1_m1_292800_499200 0 4.450635e-08
I4950 n1_m1_292800_504000 0 1.590986e-07
I4951 n1_m1_292800_508800 0 2.157600e-07
I4952 n1_m1_292800_513600 0 4.924571e-08
I4953 n1_m1_292800_518400 0 7.992000e-08
I4954 n1_m1_292800_523200 0 6.305714e-08
I4955 n1_m1_292800_528000 0 1.169398e-07
I4956 n1_m1_292800_532800 0 9.700769e-08
I4957 n1_m1_292800_537600 0 1.799615e-07
I4958 n1_m1_292800_542400 0 7.321077e-08
I4959 n1_m1_292800_547200 0 2.609500e-07
I4960 n1_m1_292800_576000 0 4.144848e-07
I4961 n1_m1_292800_580800 0 3.811538e-07
I4962 n1_m1_292800_585600 0 3.377212e-07
I4963 n1_m1_297600_4800 0 1.975385e-08
I4964 n1_m1_297600_9600 0 1.904615e-08
I4965 n1_m1_297600_24000 0 2.620000e-07
I4966 n1_m1_297600_28800 0 1.485400e-07
I4967 n1_m1_297600_33600 0 3.193513e-07
I4968 n1_m1_297600_38400 0 1.496154e-07
I4969 n1_m1_297600_43200 0 1.868077e-07
I4970 n1_m1_297600_48000 0 6.423352e-07
I4971 n1_m1_297600_52800 0 6.652327e-07
I4972 n1_m1_297600_57600 0 5.922476e-07
I4973 n1_m1_297600_62400 0 9.802857e-08
I4974 n1_m1_297600_67200 0 1.799857e-07
I4975 n1_m1_297600_72000 0 2.594311e-07
I4976 n1_m1_297600_76800 0 4.550169e-07
I4977 n1_m1_297600_81600 0 1.991143e-07
I4978 n1_m1_297600_86400 0 1.821752e-07
I4979 n1_m1_297600_91200 0 1.470407e-07
I4980 n1_m1_297600_96000 0 3.092857e-07
I4981 n1_m1_297600_100800 0 6.592071e-07
I4982 n1_m1_297600_105600 0 2.488866e-06
I4983 n1_m1_297600_110400 0 2.559440e-06
I4984 n1_m1_297600_115200 0 3.125798e-06
I4985 n1_m1_297600_120000 0 1.541406e-06
I4986 n1_m1_297600_124800 0 1.024643e-06
I4987 n1_m1_297600_129600 0 4.006961e-06
I4988 n1_m1_297600_134400 0 4.915667e-06
I4989 n1_m1_297600_139200 0 3.244048e-06
I4990 n1_m1_297600_144000 0 3.684095e-06
I4991 n1_m1_297600_148800 0 3.328600e-06
I4992 n1_m1_297600_153600 0 4.696000e-06
I4993 n1_m1_297600_158400 0 3.362722e-06
I4994 n1_m1_297600_163200 0 2.175835e-06
I4995 n1_m1_297600_168000 0 3.460911e-06
I4996 n1_m1_297600_172800 0 1.572782e-06
I4997 n1_m1_297600_177600 0 2.347397e-06
I4998 n1_m1_297600_182400 0 3.179619e-07
I4999 n1_m1_297600_187200 0 1.588762e-06
I5000 n1_m1_297600_192000 0 1.442132e-06
I5001 n1_m1_297600_196800 0 4.671071e-07
I5002 n1_m1_297600_201600 0 5.107571e-07
I5003 n1_m1_297600_206400 0 8.360000e-08
I5004 n1_m1_297600_211200 0 3.690571e-07
I5005 n1_m1_297600_216000 0 1.173957e-06
I5006 n1_m1_297600_220800 0 5.124607e-07
I5007 n1_m1_297600_225600 0 1.252143e-07
I5008 n1_m1_297600_230400 0 8.714807e-07
I5009 n1_m1_297600_235200 0 1.020246e-06
I5010 n1_m1_297600_240000 0 4.878321e-07
I5011 n1_m1_297600_244800 0 8.550714e-08
I5012 n1_m1_297600_249600 0 3.604286e-07
I5013 n1_m1_297600_254400 0 7.875510e-08
I5014 n1_m1_297600_259200 0 1.812163e-07
I5015 n1_m1_297600_264000 0 6.086286e-07
I5016 n1_m1_297600_268800 0 7.232286e-07
I5017 n1_m1_297600_273600 0 7.206250e-07
I5018 n1_m1_297600_278400 0 2.336274e-06
I5019 n1_m1_297600_283200 0 1.705100e-06
I5020 n1_m1_297600_288000 0 4.970308e-06
I5021 n1_m1_297600_292800 0 7.786905e-07
I5022 n1_m1_297600_297600 0 1.619289e-06
I5023 n1_m1_297600_302400 0 9.902792e-07
I5024 n1_m1_297600_307200 0 1.554802e-06
I5025 n1_m1_297600_312000 0 1.701656e-06
I5026 n1_m1_297600_316800 0 5.568547e-07
I5027 n1_m1_297600_321600 0 3.015472e-06
I5028 n1_m1_297600_326400 0 9.594286e-07
I5029 n1_m1_297600_331200 0 1.385510e-06
I5030 n1_m1_297600_336000 0 4.510687e-07
I5031 n1_m1_297600_340800 0 1.194000e-07
I5032 n1_m1_297600_345600 0 2.511571e-07
I5033 n1_m1_297600_350400 0 4.073143e-07
I5034 n1_m1_297600_355200 0 3.134571e-07
I5035 n1_m1_297600_360000 0 5.489286e-07
I5036 n1_m1_297600_364800 0 1.276000e-07
I5037 n1_m1_297600_369600 0 5.412476e-07
I5038 n1_m1_297600_374400 0 3.668857e-07
I5039 n1_m1_297600_379200 0 1.475714e-07
I5040 n1_m1_297600_384000 0 3.752514e-07
I5041 n1_m1_297600_388800 0 1.110171e-07
I5042 n1_m1_297600_393600 0 7.516714e-07
I5043 n1_m1_297600_398400 0 2.084000e-07
I5044 n1_m1_297600_403200 0 1.798714e-06
I5045 n1_m1_297600_408000 0 1.578067e-06
I5046 n1_m1_297600_412800 0 4.224943e-06
I5047 n1_m1_297600_417600 0 1.928773e-06
I5048 n1_m1_297600_422400 0 1.846963e-06
I5049 n1_m1_297600_427200 0 2.738576e-06
I5050 n1_m1_297600_432000 0 5.890646e-06
I5051 n1_m1_297600_436800 0 1.015000e-06
I5052 n1_m1_297600_441600 0 5.056143e-06
I5053 n1_m1_297600_446400 0 2.385952e-06
I5054 n1_m1_297600_451200 0 2.846000e-06
I5055 n1_m1_297600_456000 0 2.787143e-06
I5056 n1_m1_297600_460800 0 1.668929e-06
I5057 n1_m1_297600_465600 0 2.084022e-06
I5058 n1_m1_297600_470400 0 1.888165e-07
I5059 n1_m1_297600_475200 0 5.957143e-08
I5060 n1_m1_297600_480000 0 1.860829e-07
I5061 n1_m1_297600_484800 0 6.493019e-07
I5062 n1_m1_297600_489600 0 1.474648e-07
I5063 n1_m1_297600_494400 0 6.767048e-08
I5064 n1_m1_297600_499200 0 6.367460e-08
I5065 n1_m1_297600_504000 0 3.946038e-07
I5066 n1_m1_297600_508800 0 1.181257e-07
I5067 n1_m1_297600_513600 0 2.365733e-07
I5068 n1_m1_297600_518400 0 1.632308e-07
I5069 n1_m1_297600_523200 0 1.438407e-07
I5070 n1_m1_297600_528000 0 2.136952e-07
I5071 n1_m1_297600_532800 0 1.363692e-07
I5072 n1_m1_297600_537600 0 2.033564e-07
I5073 n1_m1_297600_542400 0 1.135610e-07
I5074 n1_m1_297600_547200 0 1.497538e-07
I5075 n1_m1_297600_552000 0 1.592154e-07
I5076 n1_m1_297600_556800 0 6.605769e-09
I5077 n1_m1_297600_576000 0 5.832294e-07
I5078 n1_m1_297600_580800 0 3.339203e-07
I5079 n1_m1_297600_585600 0 1.962216e-07
I5080 n1_m1_302400_9600 0 4.950000e-07
I5081 n1_m1_302400_28800 0 5.014286e-08
I5082 n1_m1_302400_33600 0 1.772366e-07
I5083 n1_m1_302400_38400 0 2.115385e-08
I5084 n1_m1_302400_43200 0 3.119744e-08
I5085 n1_m1_302400_48000 0 1.165812e-06
I5086 n1_m1_302400_52800 0 1.248678e-06
I5087 n1_m1_302400_57600 0 1.002167e-06
I5088 n1_m1_302400_62400 0 2.751429e-08
I5089 n1_m1_302400_67200 0 1.278190e-07
I5090 n1_m1_302400_72000 0 3.187412e-07
I5091 n1_m1_302400_76800 0 9.065479e-07
I5092 n1_m1_302400_81600 0 2.345643e-07
I5093 n1_m1_302400_86400 0 1.275566e-07
I5094 n1_m1_302400_91200 0 1.268982e-07
I5095 n1_m1_302400_96000 0 1.546750e-07
I5096 n1_m1_302400_100800 0 5.816905e-08
I5097 n1_m1_302400_105600 0 5.949563e-07
I5098 n1_m1_302400_110400 0 1.411569e-06
I5099 n1_m1_302400_115200 0 4.914602e-07
I5100 n1_m1_302400_120000 0 4.630857e-06
I5101 n1_m1_302400_124800 0 2.857103e-06
I5102 n1_m1_302400_129600 0 1.046261e-06
I5103 n1_m1_302400_134400 0 1.824690e-06
I5104 n1_m1_302400_139200 0 1.990238e-06
I5105 n1_m1_302400_144000 0 1.276476e-06
I5106 n1_m1_302400_148800 0 2.569964e-06
I5107 n1_m1_302400_153600 0 3.590160e-06
I5108 n1_m1_302400_158400 0 2.246753e-06
I5109 n1_m1_302400_163200 0 1.230667e-06
I5110 n1_m1_302400_168000 0 2.291941e-06
I5111 n1_m1_302400_172800 0 7.987669e-07
I5112 n1_m1_302400_177600 0 1.664142e-06
I5113 n1_m1_302400_182400 0 1.308952e-06
I5114 n1_m1_302400_187200 0 1.700381e-06
I5115 n1_m1_302400_192000 0 9.971111e-07
I5116 n1_m1_302400_196800 0 7.247500e-08
I5117 n1_m1_302400_201600 0 1.384595e-07
I5118 n1_m1_302400_206400 0 2.070714e-08
I5119 n1_m1_302400_211200 0 2.366857e-07
I5120 n1_m1_302400_216000 0 3.412179e-07
I5121 n1_m1_302400_220800 0 1.988964e-07
I5122 n1_m1_302400_225600 0 1.892875e-07
I5123 n1_m1_302400_230400 0 2.361050e-07
I5124 n1_m1_302400_235200 0 3.805788e-07
I5125 n1_m1_302400_240000 0 1.769782e-07
I5126 n1_m1_302400_244800 0 7.317857e-08
I5127 n1_m1_302400_249600 0 2.381000e-07
I5128 n1_m1_302400_254400 0 1.107214e-07
I5129 n1_m1_302400_259200 0 1.981000e-07
I5130 n1_m1_302400_264000 0 1.794286e-07
I5131 n1_m1_302400_268800 0 1.611571e-07
I5132 n1_m1_302400_273600 0 1.361429e-07
I5133 n1_m1_302400_278400 0 3.802259e-07
I5134 n1_m1_302400_283200 0 1.388943e-06
I5135 n1_m1_302400_288000 0 9.525906e-07
I5136 n1_m1_302400_292800 0 7.698889e-07
I5137 n1_m1_302400_297600 0 7.145039e-07
I5138 n1_m1_302400_302400 0 1.354929e-06
I5139 n1_m1_302400_307200 0 1.292857e-07
I5140 n1_m1_302400_312000 0 2.676159e-06
I5141 n1_m1_302400_316800 0 1.143024e-06
I5142 n1_m1_302400_321600 0 1.261347e-06
I5143 n1_m1_302400_326400 0 4.384812e-07
I5144 n1_m1_302400_331200 0 9.769542e-07
I5145 n1_m1_302400_336000 0 5.431565e-07
I5146 n1_m1_302400_340800 0 1.169714e-07
I5147 n1_m1_302400_345600 0 1.762393e-07
I5148 n1_m1_302400_350400 0 5.564286e-08
I5149 n1_m1_302400_355200 0 2.237143e-07
I5150 n1_m1_302400_360000 0 2.316804e-07
I5151 n1_m1_302400_364800 0 3.086607e-08
I5152 n1_m1_302400_369600 0 3.063167e-07
I5153 n1_m1_302400_374400 0 1.724714e-07
I5154 n1_m1_302400_379200 0 1.596000e-07
I5155 n1_m1_302400_384000 0 2.746143e-07
I5156 n1_m1_302400_388800 0 1.690786e-06
I5157 n1_m1_302400_393600 0 2.200762e-07
I5158 n1_m1_302400_398400 0 3.277829e-07
I5159 n1_m1_302400_403200 0 9.157193e-07
I5160 n1_m1_302400_408000 0 4.283673e-07
I5161 n1_m1_302400_412800 0 1.297143e-06
I5162 n1_m1_302400_417600 0 1.774214e-06
I5163 n1_m1_302400_422400 0 3.305714e-07
I5164 n1_m1_302400_427200 0 1.276408e-06
I5165 n1_m1_302400_432000 0 3.447306e-06
I5166 n1_m1_302400_436800 0 9.736667e-07
I5167 n1_m1_302400_441600 0 1.656643e-06
I5168 n1_m1_302400_446400 0 2.757440e-06
I5169 n1_m1_302400_451200 0 1.674762e-06
I5170 n1_m1_302400_456000 0 2.622857e-06
I5171 n1_m1_302400_460800 0 1.543214e-06
I5172 n1_m1_302400_465600 0 1.041550e-06
I5173 n1_m1_302400_470400 0 7.028095e-08
I5174 n1_m1_302400_475200 0 1.497143e-07
I5175 n1_m1_302400_480000 0 9.407143e-08
I5176 n1_m1_302400_484800 0 4.903175e-08
I5177 n1_m1_302400_489600 0 1.186710e-07
I5178 n1_m1_302400_494400 0 7.866286e-08
I5179 n1_m1_302400_499200 0 1.213905e-07
I5180 n1_m1_302400_504000 0 8.678976e-07
I5181 n1_m1_302400_508800 0 1.047857e-07
I5182 n1_m1_302400_513600 0 1.418595e-07
I5183 n1_m1_302400_518400 0 1.059397e-07
I5184 n1_m1_302400_523200 0 1.172936e-07
I5185 n1_m1_302400_528000 0 3.925000e-08
I5186 n1_m1_302400_532800 0 1.051240e-07
I5187 n1_m1_302400_537600 0 8.800513e-08
I5188 n1_m1_302400_542400 0 1.572667e-07
I5189 n1_m1_302400_547200 0 1.935462e-07
I5190 n1_m1_302400_552000 0 1.440231e-07
I5191 n1_m1_302400_556800 0 1.003558e-07
I5192 n1_m1_302400_576000 0 2.225714e-07
I5193 n1_m1_302400_580800 0 6.267824e-07
I5194 n1_m1_302400_585600 0 4.151282e-08
I5195 n1_m1_307200_9600 0 4.950000e-07
I5196 n1_m1_307200_28800 0 2.648571e-08
I5197 n1_m1_307200_33600 0 1.524451e-07
I5198 n1_m1_307200_38400 0 8.176923e-08
I5199 n1_m1_307200_43200 0 8.871795e-08
I5200 n1_m1_307200_48000 0 2.435297e-07
I5201 n1_m1_307200_52800 0 2.225190e-07
I5202 n1_m1_307200_57600 0 1.240900e-06
I5203 n1_m1_307200_62400 0 4.119048e-08
I5204 n1_m1_307200_67200 0 8.430952e-08
I5205 n1_m1_307200_72000 0 4.247487e-07
I5206 n1_m1_307200_76800 0 3.638462e-08
I5207 n1_m1_307200_81600 0 3.171357e-07
I5208 n1_m1_307200_86400 0 1.087592e-07
I5209 n1_m1_307200_91200 0 6.800275e-08
I5210 n1_m1_307200_96000 0 1.780393e-07
I5211 n1_m1_307200_100800 0 6.899150e-07
I5212 n1_m1_307200_105600 0 1.196426e-06
I5213 n1_m1_307200_110400 0 1.599160e-06
I5214 n1_m1_307200_115200 0 3.429076e-07
I5215 n1_m1_307200_120000 0 7.903810e-07
I5216 n1_m1_307200_124800 0 1.151468e-06
I5217 n1_m1_307200_129600 0 1.754635e-06
I5218 n1_m1_307200_134400 0 1.529167e-06
I5219 n1_m1_307200_139200 0 2.284048e-06
I5220 n1_m1_307200_144000 0 3.714000e-06
I5221 n1_m1_307200_148800 0 2.318560e-06
I5222 n1_m1_307200_153600 0 1.619439e-06
I5223 n1_m1_307200_158400 0 2.049818e-06
I5224 n1_m1_307200_163200 0 1.497476e-06
I5225 n1_m1_307200_168000 0 2.439660e-06
I5226 n1_m1_307200_172800 0 2.098857e-06
I5227 n1_m1_307200_177600 0 9.765714e-07
I5228 n1_m1_307200_182400 0 6.054762e-07
I5229 n1_m1_307200_187200 0 1.215286e-06
I5230 n1_m1_307200_192000 0 1.351627e-06
I5231 n1_m1_307200_196800 0 4.045357e-08
I5232 n1_m1_307200_201600 0 2.939548e-07
I5233 n1_m1_307200_206400 0 1.358500e-07
I5234 n1_m1_307200_211200 0 1.398286e-07
I5235 n1_m1_307200_216000 0 3.458315e-07
I5236 n1_m1_307200_220800 0 3.809013e-07
I5237 n1_m1_307200_225600 0 2.956268e-07
I5238 n1_m1_307200_230400 0 1.545571e-07
I5239 n1_m1_307200_235200 0 5.803690e-08
I5240 n1_m1_307200_240000 0 4.693753e-07
I5241 n1_m1_307200_244800 0 1.071429e-07
I5242 n1_m1_307200_249600 0 7.043235e-07
I5243 n1_m1_307200_254400 0 8.098366e-07
I5244 n1_m1_307200_259200 0 2.953286e-07
I5245 n1_m1_307200_264000 0 2.862914e-07
I5246 n1_m1_307200_268800 0 1.112175e-07
I5247 n1_m1_307200_273600 0 1.917543e-07
I5248 n1_m1_307200_278400 0 9.435714e-08
I5249 n1_m1_307200_283200 0 4.438571e-07
I5250 n1_m1_307200_288000 0 1.338877e-06
I5251 n1_m1_307200_292800 0 6.520418e-07
I5252 n1_m1_307200_297600 0 1.145630e-06
I5253 n1_m1_307200_302400 0 7.027653e-07
I5254 n1_m1_307200_312000 0 5.814111e-07
I5255 n1_m1_307200_316800 0 1.065857e-06
I5256 n1_m1_307200_321600 0 1.701643e-06
I5257 n1_m1_307200_326400 0 1.242947e-06
I5258 n1_m1_307200_331200 0 4.761680e-07
I5259 n1_m1_307200_336000 0 2.575167e-07
I5260 n1_m1_307200_340800 0 2.740706e-07
I5261 n1_m1_307200_345600 0 1.492607e-07
I5262 n1_m1_307200_350400 0 4.439286e-07
I5263 n1_m1_307200_355200 0 2.805143e-07
I5264 n1_m1_307200_360000 0 2.780196e-07
I5265 n1_m1_307200_364800 0 3.026292e-07
I5266 n1_m1_307200_369600 0 5.704143e-07
I5267 n1_m1_307200_374400 0 2.180857e-07
I5268 n1_m1_307200_379200 0 1.780143e-07
I5269 n1_m1_307200_384000 0 2.246000e-07
I5270 n1_m1_307200_388800 0 1.644857e-07
I5271 n1_m1_307200_393600 0 2.155024e-07
I5272 n1_m1_307200_398400 0 1.071029e-07
I5273 n1_m1_307200_403200 0 2.065664e-07
I5274 n1_m1_307200_408000 0 5.007804e-07
I5275 n1_m1_307200_412800 0 5.209203e-07
I5276 n1_m1_307200_417600 0 1.019162e-06
I5277 n1_m1_307200_422400 0 1.541000e-06
I5278 n1_m1_307200_427200 0 6.714286e-07
I5279 n1_m1_307200_432000 0 2.753000e-06
I5280 n1_m1_307200_436800 0 5.507619e-07
I5281 n1_m1_307200_441600 0 3.166786e-06
I5282 n1_m1_307200_446400 0 3.682321e-06
I5283 n1_m1_307200_451200 0 3.560667e-06
I5284 n1_m1_307200_456000 0 4.365429e-06
I5285 n1_m1_307200_460800 0 1.683571e-06
I5286 n1_m1_307200_465600 0 2.293839e-07
I5287 n1_m1_307200_470400 0 1.186857e-07
I5288 n1_m1_307200_475200 0 1.575714e-07
I5289 n1_m1_307200_480000 0 4.705714e-08
I5290 n1_m1_307200_484800 0 8.546349e-08
I5291 n1_m1_307200_489600 0 1.111093e-06
I5292 n1_m1_307200_494400 0 1.493343e-06
I5293 n1_m1_307200_499200 0 1.921000e-07
I5294 n1_m1_307200_504000 0 6.993119e-07
I5295 n1_m1_307200_508800 0 9.555397e-08
I5296 n1_m1_307200_513600 0 4.522619e-08
I5297 n1_m1_307200_518400 0 7.322949e-08
I5298 n1_m1_307200_523200 0 7.448004e-08
I5299 n1_m1_307200_528000 0 6.514048e-08
I5300 n1_m1_307200_532800 0 7.076827e-08
I5301 n1_m1_307200_537600 0 9.337949e-08
I5302 n1_m1_307200_542400 0 5.492308e-08
I5303 n1_m1_307200_547200 0 1.708962e-07
I5304 n1_m1_307200_552000 0 9.370615e-08
I5305 n1_m1_307200_556800 0 8.984103e-08
I5306 n1_m1_307200_576000 0 7.671429e-08
I5307 n1_m1_307200_580800 0 4.656396e-07
I5308 n1_m1_307200_585600 0 2.117949e-08
I5309 n1_m1_312000_4800 0 7.116923e-08
I5310 n1_m1_312000_9600 0 6.892683e-07
I5311 n1_m1_312000_33600 0 1.737077e-07
I5312 n1_m1_312000_38400 0 1.716923e-07
I5313 n1_m1_312000_43200 0 1.080154e-07
I5314 n1_m1_312000_48000 0 3.057275e-07
I5315 n1_m1_312000_52800 0 2.674571e-07
I5316 n1_m1_312000_57600 0 4.194286e-07
I5317 n1_m1_312000_62400 0 2.711524e-07
I5318 n1_m1_312000_67200 0 1.905000e-07
I5319 n1_m1_312000_72000 0 3.715359e-07
I5320 n1_m1_312000_76800 0 1.943546e-07
I5321 n1_m1_312000_81600 0 3.210571e-07
I5322 n1_m1_312000_86400 0 3.423319e-07
I5323 n1_m1_312000_91200 0 4.815324e-07
I5324 n1_m1_312000_96000 0 2.622690e-06
I5325 n1_m1_312000_100800 0 2.225038e-06
I5326 n1_m1_312000_105600 0 1.819763e-06
I5327 n1_m1_312000_110400 0 1.252605e-06
I5328 n1_m1_312000_115200 0 6.303529e-07
I5329 n1_m1_312000_120000 0 2.868423e-06
I5330 n1_m1_312000_124800 0 1.732447e-06
I5331 n1_m1_312000_129600 0 2.680010e-06
I5332 n1_m1_312000_134400 0 2.606293e-06
I5333 n1_m1_312000_139200 0 2.823810e-06
I5334 n1_m1_312000_144000 0 3.777245e-06
I5335 n1_m1_312000_148800 0 5.734088e-06
I5336 n1_m1_312000_153600 0 2.001830e-06
I5337 n1_m1_312000_158400 0 1.901714e-06
I5338 n1_m1_312000_163200 0 4.725714e-06
I5339 n1_m1_312000_168000 0 4.610922e-06
I5340 n1_m1_312000_172800 0 2.595429e-06
I5341 n1_m1_312000_177600 0 7.221143e-06
I5342 n1_m1_312000_182400 0 1.030214e-06
I5343 n1_m1_312000_187200 0 2.224000e-06
I5344 n1_m1_312000_192000 0 2.042513e-06
I5345 n1_m1_312000_196800 0 1.850950e-07
I5346 n1_m1_312000_201600 0 7.823012e-07
I5347 n1_m1_312000_206400 0 2.932143e-07
I5348 n1_m1_312000_211200 0 1.440057e-06
I5349 n1_m1_312000_216000 0 1.835182e-06
I5350 n1_m1_312000_220800 0 4.005939e-07
I5351 n1_m1_312000_225600 0 2.869476e-07
I5352 n1_m1_312000_230400 0 5.342667e-07
I5353 n1_m1_312000_235200 0 2.004952e-07
I5354 n1_m1_312000_240000 0 4.685381e-07
I5355 n1_m1_312000_244800 0 7.261688e-07
I5356 n1_m1_312000_249600 0 1.776453e-06
I5357 n1_m1_312000_254400 0 3.087706e-07
I5358 n1_m1_312000_259200 0 3.138286e-07
I5359 n1_m1_312000_264000 0 3.249800e-07
I5360 n1_m1_312000_268800 0 2.483111e-07
I5361 n1_m1_312000_273600 0 4.451457e-07
I5362 n1_m1_312000_278400 0 3.309286e-07
I5363 n1_m1_312000_283200 0 1.022710e-06
I5364 n1_m1_312000_288000 0 1.682496e-06
I5365 n1_m1_312000_292800 0 1.220280e-06
I5366 n1_m1_312000_297600 0 2.448478e-06
I5367 n1_m1_312000_302400 0 1.202831e-06
I5368 n1_m1_312000_307200 0 3.634898e-07
I5369 n1_m1_312000_312000 0 7.249143e-07
I5370 n1_m1_312000_316800 0 6.957857e-07
I5371 n1_m1_312000_321600 0 1.959565e-06
I5372 n1_m1_312000_326400 0 1.862274e-06
I5373 n1_m1_312000_331200 0 1.304563e-06
I5374 n1_m1_312000_336000 0 2.730958e-06
I5375 n1_m1_312000_340800 0 8.533008e-07
I5376 n1_m1_312000_345600 0 1.206339e-06
I5377 n1_m1_312000_350400 0 5.146143e-07
I5378 n1_m1_312000_355200 0 1.578000e-07
I5379 n1_m1_312000_360000 0 2.557857e-07
I5380 n1_m1_312000_364800 0 2.317333e-07
I5381 n1_m1_312000_369600 0 2.632695e-07
I5382 n1_m1_312000_374400 0 3.372361e-07
I5383 n1_m1_312000_379200 0 3.419745e-07
I5384 n1_m1_312000_384000 0 1.233918e-07
I5385 n1_m1_312000_388800 0 2.629429e-07
I5386 n1_m1_312000_393600 0 4.589500e-07
I5387 n1_m1_312000_398400 0 3.895714e-07
I5388 n1_m1_312000_403200 0 2.670286e-07
I5389 n1_m1_312000_408000 0 1.479200e-07
I5390 n1_m1_312000_412800 0 5.016297e-07
I5391 n1_m1_312000_417600 0 1.867424e-06
I5392 n1_m1_312000_422400 0 3.275449e-06
I5393 n1_m1_312000_427200 0 2.023429e-06
I5394 n1_m1_312000_432000 0 3.869449e-06
I5395 n1_m1_312000_436800 0 3.996351e-06
I5396 n1_m1_312000_441600 0 6.097800e-06
I5397 n1_m1_312000_446400 0 3.513061e-06
I5398 n1_m1_312000_451200 0 1.467796e-06
I5399 n1_m1_312000_456000 0 4.222067e-06
I5400 n1_m1_312000_460800 0 3.267321e-06
I5401 n1_m1_312000_465600 0 1.106894e-06
I5402 n1_m1_312000_470400 0 2.393347e-07
I5403 n1_m1_312000_475200 0 4.231190e-07
I5404 n1_m1_312000_480000 0 2.216762e-07
I5405 n1_m1_312000_484800 0 1.189857e-07
I5406 n1_m1_312000_489600 0 4.992714e-07
I5407 n1_m1_312000_494400 0 6.355810e-07
I5408 n1_m1_312000_499200 0 1.239571e-07
I5409 n1_m1_312000_504000 0 2.351524e-07
I5410 n1_m1_312000_508800 0 2.877746e-07
I5411 n1_m1_312000_513600 0 1.954949e-06
I5412 n1_m1_312000_518400 0 1.113308e-07
I5413 n1_m1_312000_523200 0 1.896292e-07
I5414 n1_m1_312000_528000 0 1.868267e-07
I5415 n1_m1_312000_532800 0 1.490538e-07
I5416 n1_m1_312000_537600 0 3.770769e-07
I5417 n1_m1_312000_542400 0 1.643692e-07
I5418 n1_m1_312000_547200 0 2.293562e-07
I5419 n1_m1_312000_552000 0 6.781367e-07
I5420 n1_m1_312000_556800 0 3.749667e-07
I5421 n1_m1_312000_561600 0 5.870000e-07
I5422 n1_m1_312000_580800 0 2.141538e-08
I5423 n1_m1_312000_585600 0 3.478462e-08
I5424 n1_m1_316800_4800 0 4.495385e-08
I5425 n1_m1_316800_9600 0 3.371117e-07
I5426 n1_m1_316800_52800 0 1.097000e-07
I5427 n1_m1_316800_57600 0 1.910857e-07
I5428 n1_m1_316800_62400 0 4.204571e-07
I5429 n1_m1_316800_67200 0 1.156343e-06
I5430 n1_m1_316800_72000 0 8.105385e-08
I5431 n1_m1_316800_76800 0 1.779366e-07
I5432 n1_m1_316800_81600 0 1.424429e-07
I5433 n1_m1_316800_86400 0 2.577231e-07
I5434 n1_m1_316800_91200 0 3.130769e-07
I5435 n1_m1_316800_96000 0 3.094314e-06
I5436 n1_m1_316800_100800 0 1.468802e-06
I5437 n1_m1_316800_105600 0 3.777832e-07
I5438 n1_m1_316800_110400 0 2.341429e-07
I5439 n1_m1_316800_115200 0 2.756840e-07
I5440 n1_m1_316800_120000 0 1.196181e-06
I5441 n1_m1_316800_124800 0 1.041867e-06
I5442 n1_m1_316800_129600 0 2.212483e-06
I5443 n1_m1_316800_134400 0 1.492688e-06
I5444 n1_m1_316800_139200 0 7.211429e-07
I5445 n1_m1_316800_144000 0 8.908408e-07
I5446 n1_m1_316800_148800 0 1.752126e-06
I5447 n1_m1_316800_153600 0 1.544857e-06
I5448 n1_m1_316800_158400 0 1.138914e-06
I5449 n1_m1_316800_163200 0 1.330914e-06
I5450 n1_m1_316800_168000 0 3.100976e-06
I5451 n1_m1_316800_172800 0 4.171429e-06
I5452 n1_m1_316800_177600 0 2.111429e-06
I5453 n1_m1_316800_182400 0 4.275000e-07
I5454 n1_m1_316800_187200 0 8.202857e-07
I5455 n1_m1_316800_192000 0 1.153387e-06
I5456 n1_m1_316800_196800 0 1.029683e-07
I5457 n1_m1_316800_201600 0 9.041292e-07
I5458 n1_m1_316800_206400 0 2.840952e-07
I5459 n1_m1_316800_211200 0 1.315327e-07
I5460 n1_m1_316800_216000 0 1.572427e-07
I5461 n1_m1_316800_220800 0 2.328310e-07
I5462 n1_m1_316800_225600 0 1.368619e-07
I5463 n1_m1_316800_230400 0 6.850476e-08
I5464 n1_m1_316800_235200 0 4.805714e-08
I5465 n1_m1_316800_240000 0 9.731476e-08
I5466 n1_m1_316800_244800 0 2.205740e-07
I5467 n1_m1_316800_249600 0 3.701412e-07
I5468 n1_m1_316800_254400 0 3.049714e-07
I5469 n1_m1_316800_259200 0 5.666286e-07
I5470 n1_m1_316800_264000 0 2.473714e-07
I5471 n1_m1_316800_268800 0 1.267889e-07
I5472 n1_m1_316800_273600 0 1.266714e-07
I5473 n1_m1_316800_278400 0 3.421429e-08
I5474 n1_m1_316800_283200 0 7.234762e-07
I5475 n1_m1_316800_288000 0 1.212212e-06
I5476 n1_m1_316800_292800 0 6.272761e-07
I5477 n1_m1_316800_297600 0 1.926410e-06
I5478 n1_m1_316800_302400 0 1.927016e-06
I5479 n1_m1_316800_307200 0 4.971451e-07
I5480 n1_m1_316800_312000 0 1.116736e-06
I5481 n1_m1_316800_316800 0 1.558918e-06
I5482 n1_m1_316800_321600 0 2.288281e-06
I5483 n1_m1_316800_326400 0 7.975834e-07
I5484 n1_m1_316800_331200 0 7.288754e-07
I5485 n1_m1_316800_336000 0 1.518745e-06
I5486 n1_m1_316800_340800 0 1.739899e-06
I5487 n1_m1_316800_345600 0 1.638144e-06
I5488 n1_m1_316800_350400 0 2.404429e-07
I5489 n1_m1_316800_355200 0 7.064286e-07
I5490 n1_m1_316800_360000 0 2.006000e-07
I5491 n1_m1_316800_364800 0 8.030786e-07
I5492 n1_m1_316800_369600 0 7.794234e-07
I5493 n1_m1_316800_374400 0 8.132924e-07
I5494 n1_m1_316800_379200 0 5.219183e-07
I5495 n1_m1_316800_384000 0 3.404224e-07
I5496 n1_m1_316800_388800 0 1.487167e-07
I5497 n1_m1_316800_393600 0 4.755708e-07
I5498 n1_m1_316800_398400 0 9.158571e-08
I5499 n1_m1_316800_403200 0 9.593929e-08
I5500 n1_m1_316800_408000 0 6.867800e-07
I5501 n1_m1_316800_412800 0 3.821429e-07
I5502 n1_m1_316800_417600 0 1.917707e-06
I5503 n1_m1_316800_422400 0 1.074551e-06
I5504 n1_m1_316800_427200 0 4.898797e-07
I5505 n1_m1_316800_432000 0 2.514461e-06
I5506 n1_m1_316800_436800 0 1.450220e-06
I5507 n1_m1_316800_441600 0 1.515200e-06
I5508 n1_m1_316800_446400 0 2.443844e-06
I5509 n1_m1_316800_451200 0 3.036395e-06
I5510 n1_m1_316800_456000 0 3.585685e-06
I5511 n1_m1_316800_460800 0 8.253929e-07
I5512 n1_m1_316800_465600 0 3.514252e-07
I5513 n1_m1_316800_470400 0 1.723582e-07
I5514 n1_m1_316800_475200 0 1.386667e-07
I5515 n1_m1_316800_480000 0 1.652524e-07
I5516 n1_m1_316800_484800 0 6.802143e-08
I5517 n1_m1_316800_489600 0 3.641679e-07
I5518 n1_m1_316800_494400 0 6.437083e-07
I5519 n1_m1_316800_499200 0 9.944821e-08
I5520 n1_m1_316800_504000 0 1.727714e-07
I5521 n1_m1_316800_508800 0 1.060571e-07
I5522 n1_m1_316800_513600 0 2.764317e-07
I5523 n1_m1_316800_518400 0 6.074971e-07
I5524 n1_m1_316800_523200 0 4.288863e-07
I5525 n1_m1_316800_528000 0 1.111924e-07
I5526 n1_m1_316800_532800 0 3.523000e-07
I5527 n1_m1_316800_537600 0 8.437128e-07
I5528 n1_m1_316800_542400 0 1.526938e-07
I5529 n1_m1_316800_547200 0 4.777301e-07
I5530 n1_m1_316800_552000 0 1.661264e-07
I5531 n1_m1_316800_556800 0 1.384026e-07
I5532 n1_m1_316800_561600 0 1.140000e-07
I5533 n1_m1_316800_576000 0 4.419048e-09
I5534 n1_m1_316800_580800 0 2.651429e-08
I5535 n1_m1_316800_585600 0 4.280000e-08
I5536 n1_m1_321600_4800 0 2.525769e-07
I5537 n1_m1_321600_9600 0 9.001390e-07
I5538 n1_m1_321600_33600 0 5.842500e-07
I5539 n1_m1_321600_62400 0 3.211429e-08
I5540 n1_m1_321600_67200 0 2.408571e-08
I5541 n1_m1_321600_72000 0 5.611248e-07
I5542 n1_m1_321600_76800 0 1.132022e-07
I5543 n1_m1_321600_81600 0 1.265333e-07
I5544 n1_m1_321600_86400 0 1.502619e-07
I5545 n1_m1_321600_91200 0 1.181714e-07
I5546 n1_m1_321600_96000 0 9.062577e-07
I5547 n1_m1_321600_100800 0 4.148955e-07
I5548 n1_m1_321600_105600 0 1.268771e-06
I5549 n1_m1_321600_110400 0 2.690714e-07
I5550 n1_m1_321600_115200 0 7.936000e-07
I5551 n1_m1_321600_120000 0 2.060655e-06
I5552 n1_m1_321600_124800 0 1.361869e-06
I5553 n1_m1_321600_129600 0 1.664315e-06
I5554 n1_m1_321600_134400 0 1.199829e-06
I5555 n1_m1_321600_139200 0 1.206714e-06
I5556 n1_m1_321600_144000 0 1.931029e-06
I5557 n1_m1_321600_148800 0 1.591535e-06
I5558 n1_m1_321600_153600 0 1.338753e-06
I5559 n1_m1_321600_158400 0 2.693371e-06
I5560 n1_m1_321600_163200 0 4.398943e-06
I5561 n1_m1_321600_168000 0 4.834643e-06
I5562 n1_m1_321600_172800 0 2.671429e-06
I5563 n1_m1_321600_177600 0 3.197714e-06
I5564 n1_m1_321600_182400 0 1.858571e-06
I5565 n1_m1_321600_187200 0 1.466857e-06
I5566 n1_m1_321600_192000 0 2.790738e-06
I5567 n1_m1_321600_196800 0 2.273224e-07
I5568 n1_m1_321600_201600 0 9.316268e-07
I5569 n1_m1_321600_206400 0 3.658476e-07
I5570 n1_m1_321600_211200 0 1.978531e-07
I5571 n1_m1_321600_216000 0 1.758827e-07
I5572 n1_m1_321600_220800 0 2.392881e-07
I5573 n1_m1_321600_225600 0 4.477048e-07
I5574 n1_m1_321600_230400 0 1.281238e-07
I5575 n1_m1_321600_235200 0 2.440714e-07
I5576 n1_m1_321600_240000 0 2.791512e-07
I5577 n1_m1_321600_244800 0 3.859388e-07
I5578 n1_m1_321600_249600 0 3.340124e-07
I5579 n1_m1_321600_254400 0 2.171429e-07
I5580 n1_m1_321600_259200 0 1.248171e-06
I5581 n1_m1_321600_264000 0 4.460667e-07
I5582 n1_m1_321600_268800 0 7.014635e-07
I5583 n1_m1_321600_273600 0 1.436400e-06
I5584 n1_m1_321600_278400 0 1.475000e-07
I5585 n1_m1_321600_283200 0 7.156023e-07
I5586 n1_m1_321600_288000 0 1.198358e-06
I5587 n1_m1_321600_292800 0 1.533220e-06
I5588 n1_m1_321600_297600 0 2.037081e-06
I5589 n1_m1_321600_302400 0 1.343762e-06
I5590 n1_m1_321600_307200 0 2.443645e-06
I5591 n1_m1_321600_312000 0 3.152866e-06
I5592 n1_m1_321600_316800 0 8.041336e-07
I5593 n1_m1_321600_321600 0 1.101336e-06
I5594 n1_m1_321600_326400 0 1.231286e-06
I5595 n1_m1_321600_331200 0 1.852183e-06
I5596 n1_m1_321600_336000 0 1.048436e-06
I5597 n1_m1_321600_340800 0 5.256336e-07
I5598 n1_m1_321600_345600 0 2.587564e-07
I5599 n1_m1_321600_350400 0 2.057429e-07
I5600 n1_m1_321600_355200 0 5.328571e-07
I5601 n1_m1_321600_360000 0 2.688286e-07
I5602 n1_m1_321600_364800 0 2.833329e-07
I5603 n1_m1_321600_369600 0 6.394143e-07
I5604 n1_m1_321600_374400 0 1.315679e-07
I5605 n1_m1_321600_379200 0 2.964214e-07
I5606 n1_m1_321600_384000 0 4.802286e-07
I5607 n1_m1_321600_388800 0 2.424405e-07
I5608 n1_m1_321600_393600 0 1.230634e-06
I5609 n1_m1_321600_398400 0 9.432857e-08
I5610 n1_m1_321600_403200 0 1.370750e-07
I5611 n1_m1_321600_408000 0 1.782571e-07
I5612 n1_m1_321600_412800 0 3.109357e-07
I5613 n1_m1_321600_417600 0 1.678303e-06
I5614 n1_m1_321600_422400 0 2.584286e-06
I5615 n1_m1_321600_427200 0 2.031549e-06
I5616 n1_m1_321600_432000 0 2.718519e-06
I5617 n1_m1_321600_436800 0 4.000429e-06
I5618 n1_m1_321600_441600 0 4.562000e-06
I5619 n1_m1_321600_446400 0 4.224286e-06
I5620 n1_m1_321600_451200 0 1.232619e-06
I5621 n1_m1_321600_456000 0 5.839347e-06
I5622 n1_m1_321600_460800 0 3.176390e-06
I5623 n1_m1_321600_465600 0 7.511381e-07
I5624 n1_m1_321600_470400 0 4.700262e-07
I5625 n1_m1_321600_475200 0 9.488571e-07
I5626 n1_m1_321600_480000 0 9.366286e-07
I5627 n1_m1_321600_484800 0 1.937214e-07
I5628 n1_m1_321600_489600 0 3.504321e-07
I5629 n1_m1_321600_494400 0 1.351393e-07
I5630 n1_m1_321600_499200 0 2.662946e-07
I5631 n1_m1_321600_504000 0 2.893143e-07
I5632 n1_m1_321600_508800 0 2.539714e-07
I5633 n1_m1_321600_513600 0 1.858810e-07
I5634 n1_m1_321600_518400 0 7.054413e-07
I5635 n1_m1_321600_523200 0 4.045152e-07
I5636 n1_m1_321600_528000 0 4.583476e-07
I5637 n1_m1_321600_532800 0 8.566154e-08
I5638 n1_m1_321600_537600 0 2.188088e-07
I5639 n1_m1_321600_542400 0 1.114706e-07
I5640 n1_m1_321600_547200 0 2.054663e-07
I5641 n1_m1_321600_552000 0 1.537538e-07
I5642 n1_m1_321600_556800 0 2.701179e-07
I5643 n1_m1_321600_561600 0 1.031000e-07
I5644 n1_m1_321600_576000 0 5.523810e-10
I5645 n1_m1_321600_580800 0 4.831429e-08
I5646 n1_m1_321600_585600 0 2.812500e-08
I5647 n1_m1_326400_4800 0 6.865385e-07
I5648 n1_m1_326400_9600 0 3.358176e-07
I5649 n1_m1_326400_19200 0 2.868750e-07
I5650 n1_m1_326400_24000 0 4.781250e-08
I5651 n1_m1_326400_33600 0 3.997500e-07
I5652 n1_m1_326400_62400 0 7.094286e-08
I5653 n1_m1_326400_67200 0 9.345849e-07
I5654 n1_m1_326400_72000 0 1.023846e-06
I5655 n1_m1_326400_76800 0 1.089875e-07
I5656 n1_m1_326400_81600 0 1.996381e-07
I5657 n1_m1_326400_86400 0 1.351462e-07
I5658 n1_m1_326400_91200 0 7.447473e-08
I5659 n1_m1_326400_96000 0 4.082381e-07
I5660 n1_m1_326400_100800 0 1.719762e-07
I5661 n1_m1_326400_105600 0 1.635457e-07
I5662 n1_m1_326400_110400 0 1.113186e-06
I5663 n1_m1_326400_115200 0 1.998048e-06
I5664 n1_m1_326400_120000 0 8.249559e-07
I5665 n1_m1_326400_124800 0 8.207283e-07
I5666 n1_m1_326400_129600 0 1.888796e-06
I5667 n1_m1_326400_134400 0 1.579261e-06
I5668 n1_m1_326400_139200 0 1.456471e-06
I5669 n1_m1_326400_144000 0 1.393376e-06
I5670 n1_m1_326400_148800 0 1.638918e-06
I5671 n1_m1_326400_153600 0 1.171532e-06
I5672 n1_m1_326400_158400 0 1.482095e-06
I5673 n1_m1_326400_163200 0 1.885846e-06
I5674 n1_m1_326400_168000 0 1.345771e-06
I5675 n1_m1_326400_172800 0 2.474743e-06
I5676 n1_m1_326400_177600 0 2.912311e-06
I5677 n1_m1_326400_182400 0 2.341429e-07
I5678 n1_m1_326400_187200 0 1.623497e-06
I5679 n1_m1_326400_192000 0 1.437251e-06
I5680 n1_m1_326400_196800 0 3.652857e-08
I5681 n1_m1_326400_201600 0 3.617384e-07
I5682 n1_m1_326400_206400 0 2.634286e-07
I5683 n1_m1_326400_211200 0 3.977143e-08
I5684 n1_m1_326400_216000 0 4.274143e-07
I5685 n1_m1_326400_220800 0 3.652143e-07
I5686 n1_m1_326400_225600 0 2.450117e-07
I5687 n1_m1_326400_230400 0 4.628476e-07
I5688 n1_m1_326400_235200 0 9.096286e-07
I5689 n1_m1_326400_240000 0 1.544102e-07
I5690 n1_m1_326400_244800 0 1.532517e-07
I5691 n1_m1_326400_249600 0 2.499672e-07
I5692 n1_m1_326400_254400 0 1.074286e-07
I5693 n1_m1_326400_259200 0 2.181714e-07
I5694 n1_m1_326400_264000 0 1.675905e-07
I5695 n1_m1_326400_268800 0 1.012643e-07
I5696 n1_m1_326400_273600 0 4.267429e-07
I5697 n1_m1_326400_278400 0 2.294286e-06
I5698 n1_m1_326400_283200 0 1.140526e-06
I5699 n1_m1_326400_288000 0 1.394241e-06
I5700 n1_m1_326400_292800 0 6.912698e-07
I5701 n1_m1_326400_297600 0 1.395374e-06
I5702 n1_m1_326400_302400 0 1.509120e-06
I5703 n1_m1_326400_307200 0 4.900058e-07
I5704 n1_m1_326400_312000 0 1.821084e-06
I5705 n1_m1_326400_316800 0 4.465371e-07
I5706 n1_m1_326400_321600 0 9.555779e-07
I5707 n1_m1_326400_326400 0 1.034084e-06
I5708 n1_m1_326400_331200 0 8.808375e-07
I5709 n1_m1_326400_336000 0 1.198226e-06
I5710 n1_m1_326400_340800 0 4.634672e-07
I5711 n1_m1_326400_345600 0 5.901893e-07
I5712 n1_m1_326400_350400 0 1.692755e-07
I5713 n1_m1_326400_355200 0 1.772816e-07
I5714 n1_m1_326400_360000 0 7.768571e-08
I5715 n1_m1_326400_364800 0 9.399571e-08
I5716 n1_m1_326400_369600 0 1.901500e-07
I5717 n1_m1_326400_374400 0 4.090179e-08
I5718 n1_m1_326400_379200 0 2.738543e-07
I5719 n1_m1_326400_384000 0 5.569914e-07
I5720 n1_m1_326400_388800 0 1.764964e-07
I5721 n1_m1_326400_393600 0 1.602653e-07
I5722 n1_m1_326400_398400 0 1.758776e-07
I5723 n1_m1_326400_403200 0 1.639810e-07
I5724 n1_m1_326400_408000 0 2.440349e-07
I5725 n1_m1_326400_412800 0 3.016000e-07
I5726 n1_m1_326400_417600 0 1.318994e-06
I5727 n1_m1_326400_422400 0 8.246307e-07
I5728 n1_m1_326400_427200 0 1.662941e-06
I5729 n1_m1_326400_432000 0 1.491835e-06
I5730 n1_m1_326400_436800 0 2.075939e-06
I5731 n1_m1_326400_441600 0 2.127143e-06
I5732 n1_m1_326400_446400 0 3.551131e-06
I5733 n1_m1_326400_451200 0 1.316127e-06
I5734 n1_m1_326400_456000 0 1.751282e-06
I5735 n1_m1_326400_460800 0 1.369480e-06
I5736 n1_m1_326400_465600 0 1.917479e-07
I5737 n1_m1_326400_470400 0 4.360410e-07
I5738 n1_m1_326400_475200 0 1.576857e-07
I5739 n1_m1_326400_480000 0 1.811732e-07
I5740 n1_m1_326400_484800 0 1.578000e-07
I5741 n1_m1_326400_489600 0 3.497500e-07
I5742 n1_m1_326400_494400 0 2.433959e-07
I5743 n1_m1_326400_499200 0 1.786160e-07
I5744 n1_m1_326400_504000 0 1.817429e-07
I5745 n1_m1_326400_508800 0 7.402857e-08
I5746 n1_m1_326400_513600 0 2.299762e-07
I5747 n1_m1_326400_518400 0 2.496264e-08
I5748 n1_m1_326400_523200 0 1.518316e-07
I5749 n1_m1_326400_528000 0 1.499371e-07
I5750 n1_m1_326400_532800 0 1.448949e-07
I5751 n1_m1_326400_537600 0 1.027886e-07
I5752 n1_m1_326400_542400 0 5.065220e-08
I5753 n1_m1_326400_547200 0 4.807359e-07
I5754 n1_m1_326400_552000 0 1.834513e-07
I5755 n1_m1_326400_556800 0 1.223595e-07
I5756 n1_m1_326400_576000 0 1.700000e-08
I5757 n1_m1_326400_580800 0 5.520000e-07
I5758 n1_m1_326400_585600 0 3.200500e-07
I5759 n1_m1_331200_4800 0 2.257154e-07
I5760 n1_m1_331200_9600 0 3.845733e-07
I5761 n1_m1_331200_14400 0 3.858571e-07
I5762 n1_m1_331200_19200 0 7.346429e-07
I5763 n1_m1_331200_24000 0 2.342500e-07
I5764 n1_m1_331200_57600 0 8.242857e-08
I5765 n1_m1_331200_62400 0 1.211714e-07
I5766 n1_m1_331200_67200 0 3.739722e-07
I5767 n1_m1_331200_72000 0 1.613313e-07
I5768 n1_m1_331200_76800 0 1.031459e-07
I5769 n1_m1_331200_81600 0 2.047143e-07
I5770 n1_m1_331200_86400 0 1.015545e-07
I5771 n1_m1_331200_91200 0 1.142912e-07
I5772 n1_m1_331200_96000 0 2.153190e-07
I5773 n1_m1_331200_100800 0 3.030667e-07
I5774 n1_m1_331200_105600 0 4.090257e-07
I5775 n1_m1_331200_110400 0 7.030396e-07
I5776 n1_m1_331200_115200 0 2.566514e-06
I5777 n1_m1_331200_120000 0 4.574095e-07
I5778 n1_m1_331200_124800 0 8.281373e-07
I5779 n1_m1_331200_129600 0 1.538734e-06
I5780 n1_m1_331200_134400 0 8.877143e-07
I5781 n1_m1_331200_139200 0 9.845378e-07
I5782 n1_m1_331200_144000 0 1.092481e-06
I5783 n1_m1_331200_148800 0 9.245238e-07
I5784 n1_m1_331200_153600 0 1.471229e-06
I5785 n1_m1_331200_158400 0 1.894190e-06
I5786 n1_m1_331200_163200 0 1.210868e-06
I5787 n1_m1_331200_168000 0 1.200943e-06
I5788 n1_m1_331200_172800 0 3.180114e-06
I5789 n1_m1_331200_177600 0 2.089118e-06
I5790 n1_m1_331200_182400 0 1.409857e-06
I5791 n1_m1_331200_187200 0 1.739646e-06
I5792 n1_m1_331200_192000 0 3.112217e-06
I5793 n1_m1_331200_196800 0 1.345857e-07
I5794 n1_m1_331200_201600 0 1.126576e-06
I5795 n1_m1_331200_206400 0 3.687679e-07
I5796 n1_m1_331200_211200 0 1.751857e-07
I5797 n1_m1_331200_216000 0 3.439179e-07
I5798 n1_m1_331200_220800 0 1.500714e-07
I5799 n1_m1_331200_225600 0 2.042312e-07
I5800 n1_m1_331200_230400 0 2.070571e-07
I5801 n1_m1_331200_235200 0 8.218571e-07
I5802 n1_m1_331200_240000 0 6.487973e-07
I5803 n1_m1_331200_244800 0 7.246667e-08
I5804 n1_m1_331200_249600 0 2.912210e-07
I5805 n1_m1_331200_254400 0 1.107388e-07
I5806 n1_m1_331200_259200 0 2.142857e-08
I5807 n1_m1_331200_264000 0 4.377873e-07
I5808 n1_m1_331200_268800 0 3.505254e-07
I5809 n1_m1_331200_273600 0 2.490905e-07
I5810 n1_m1_331200_278400 0 3.377619e-07
I5811 n1_m1_331200_283200 0 4.425357e-07
I5812 n1_m1_331200_288000 0 2.230897e-06
I5813 n1_m1_331200_292800 0 5.535714e-07
I5814 n1_m1_331200_297600 0 2.020118e-06
I5815 n1_m1_331200_302400 0 1.344918e-06
I5816 n1_m1_331200_307200 0 1.140714e-06
I5817 n1_m1_331200_312000 0 1.625962e-06
I5818 n1_m1_331200_316800 0 6.316935e-07
I5819 n1_m1_331200_321600 0 1.194978e-06
I5820 n1_m1_331200_326400 0 1.117916e-06
I5821 n1_m1_331200_331200 0 5.930692e-07
I5822 n1_m1_331200_336000 0 1.452717e-06
I5823 n1_m1_331200_340800 0 3.847571e-07
I5824 n1_m1_331200_345600 0 8.581048e-07
I5825 n1_m1_331200_350400 0 6.637388e-07
I5826 n1_m1_331200_355200 0 7.856041e-07
I5827 n1_m1_331200_360000 0 7.569893e-07
I5828 n1_m1_331200_364800 0 5.795561e-07
I5829 n1_m1_331200_369600 0 2.631153e-07
I5830 n1_m1_331200_374400 0 6.298750e-08
I5831 n1_m1_331200_379200 0 1.867029e-07
I5832 n1_m1_331200_384000 0 2.261737e-07
I5833 n1_m1_331200_388800 0 6.880643e-08
I5834 n1_m1_331200_393600 0 2.026061e-07
I5835 n1_m1_331200_398400 0 1.421224e-07
I5836 n1_m1_331200_403200 0 1.170476e-07
I5837 n1_m1_331200_408000 0 1.927651e-07
I5838 n1_m1_331200_412800 0 5.545714e-08
I5839 n1_m1_331200_417600 0 1.628127e-06
I5840 n1_m1_331200_422400 0 9.624327e-07
I5841 n1_m1_331200_427200 0 9.173448e-07
I5842 n1_m1_331200_432000 0 1.281451e-06
I5843 n1_m1_331200_436800 0 1.799061e-06
I5844 n1_m1_331200_441600 0 4.454127e-06
I5845 n1_m1_331200_446400 0 1.666091e-06
I5846 n1_m1_331200_451200 0 1.115405e-06
I5847 n1_m1_331200_456000 0 6.976190e-07
I5848 n1_m1_331200_460800 0 6.437255e-07
I5849 n1_m1_331200_465600 0 5.494902e-07
I5850 n1_m1_331200_470400 0 4.677976e-07
I5851 n1_m1_331200_475200 0 1.780694e-07
I5852 n1_m1_331200_480000 0 2.463030e-07
I5853 n1_m1_331200_484800 0 1.833490e-07
I5854 n1_m1_331200_489600 0 4.442963e-07
I5855 n1_m1_331200_494400 0 4.804041e-07
I5856 n1_m1_331200_499200 0 1.271426e-07
I5857 n1_m1_331200_504000 0 2.087429e-07
I5858 n1_m1_331200_508800 0 1.556000e-07
I5859 n1_m1_331200_513600 0 2.319333e-07
I5860 n1_m1_331200_518400 0 9.311429e-08
I5861 n1_m1_331200_523200 0 1.558914e-07
I5862 n1_m1_331200_528000 0 4.234629e-07
I5863 n1_m1_331200_532800 0 1.688359e-07
I5864 n1_m1_331200_537600 0 1.793971e-07
I5865 n1_m1_331200_542400 0 1.200789e-07
I5866 n1_m1_331200_547200 0 7.276615e-07
I5867 n1_m1_331200_552000 0 3.703498e-07
I5868 n1_m1_331200_556800 0 1.246991e-07
I5869 n1_m1_331200_561600 0 2.090000e-07
I5870 n1_m1_331200_576000 0 3.614286e-08
I5871 n1_m1_331200_580800 0 4.525648e-07
I5872 n1_m1_331200_585600 0 1.687173e-07
I5873 n1_m1_336000_4800 0 2.033119e-07
I5874 n1_m1_336000_9600 0 6.775790e-07
I5875 n1_m1_336000_19200 0 9.562500e-08
I5876 n1_m1_336000_24000 0 1.593750e-08
I5877 n1_m1_336000_57600 0 2.637429e-07
I5878 n1_m1_336000_62400 0 1.803905e-07
I5879 n1_m1_336000_67200 0 6.476000e-07
I5880 n1_m1_336000_72000 0 4.582751e-07
I5881 n1_m1_336000_76800 0 1.642711e-07
I5882 n1_m1_336000_81600 0 2.901714e-07
I5883 n1_m1_336000_86400 0 1.213429e-07
I5884 n1_m1_336000_91200 0 1.297571e-07
I5885 n1_m1_336000_96000 0 8.650429e-07
I5886 n1_m1_336000_100800 0 4.193571e-07
I5887 n1_m1_336000_105600 0 5.752286e-07
I5888 n1_m1_336000_110400 0 3.102509e-07
I5889 n1_m1_336000_115200 0 6.350718e-07
I5890 n1_m1_336000_120000 0 2.611800e-07
I5891 n1_m1_336000_124800 0 8.428571e-07
I5892 n1_m1_336000_129600 0 1.504140e-06
I5893 n1_m1_336000_134400 0 1.324924e-06
I5894 n1_m1_336000_139200 0 7.268487e-07
I5895 n1_m1_336000_144000 0 4.379976e-06
I5896 n1_m1_336000_148800 0 2.229798e-06
I5897 n1_m1_336000_153600 0 4.398271e-06
I5898 n1_m1_336000_158400 0 2.799714e-06
I5899 n1_m1_336000_163200 0 2.358714e-06
I5900 n1_m1_336000_168000 0 3.657071e-06
I5901 n1_m1_336000_172800 0 4.831429e-06
I5902 n1_m1_336000_177600 0 2.616143e-06
I5903 n1_m1_336000_182400 0 2.339714e-06
I5904 n1_m1_336000_187200 0 3.014000e-06
I5905 n1_m1_336000_192000 0 3.605119e-06
I5906 n1_m1_336000_196800 0 1.695429e-07
I5907 n1_m1_336000_201600 0 4.446000e-07
I5908 n1_m1_336000_206400 0 3.219321e-07
I5909 n1_m1_336000_211200 0 2.364571e-07
I5910 n1_m1_336000_216000 0 1.023839e-06
I5911 n1_m1_336000_220800 0 4.376286e-07
I5912 n1_m1_336000_225600 0 8.207286e-07
I5913 n1_m1_336000_230400 0 2.257714e-07
I5914 n1_m1_336000_235200 0 4.208667e-07
I5915 n1_m1_336000_240000 0 9.378884e-07
I5916 n1_m1_336000_244800 0 4.128857e-07
I5917 n1_m1_336000_249600 0 1.197967e-06
I5918 n1_m1_336000_254400 0 3.645184e-07
I5919 n1_m1_336000_259200 0 3.280857e-07
I5920 n1_m1_336000_264000 0 4.696984e-07
I5921 n1_m1_336000_268800 0 1.258913e-07
I5922 n1_m1_336000_273600 0 3.589952e-07
I5923 n1_m1_336000_278400 0 7.671667e-07
I5924 n1_m1_336000_283200 0 8.676071e-07
I5925 n1_m1_336000_288000 0 1.917628e-06
I5926 n1_m1_336000_292800 0 8.762286e-07
I5927 n1_m1_336000_297600 0 9.257472e-06
I5928 n1_m1_336000_302400 0 2.802054e-06
I5929 n1_m1_336000_307200 0 1.075000e-06
I5930 n1_m1_336000_312000 0 3.593467e-06
I5931 n1_m1_336000_316800 0 8.529893e-07
I5932 n1_m1_336000_321600 0 1.496994e-06
I5933 n1_m1_336000_326400 0 1.398171e-06
I5934 n1_m1_336000_331200 0 1.305811e-06
I5935 n1_m1_336000_336000 0 2.628948e-06
I5936 n1_m1_336000_340800 0 8.511824e-07
I5937 n1_m1_336000_345600 0 9.222213e-07
I5938 n1_m1_336000_350400 0 1.913143e-07
I5939 n1_m1_336000_355200 0 3.526571e-07
I5940 n1_m1_336000_360000 0 2.285536e-07
I5941 n1_m1_336000_364800 0 5.692653e-07
I5942 n1_m1_336000_369600 0 4.558490e-07
I5943 n1_m1_336000_374400 0 3.604143e-07
I5944 n1_m1_336000_379200 0 2.330571e-07
I5945 n1_m1_336000_384000 0 3.293206e-07
I5946 n1_m1_336000_388800 0 1.618400e-07
I5947 n1_m1_336000_393600 0 3.826524e-07
I5948 n1_m1_336000_398400 0 6.076286e-07
I5949 n1_m1_336000_403200 0 7.968571e-08
I5950 n1_m1_336000_408000 0 1.696000e-07
I5951 n1_m1_336000_412800 0 8.491429e-07
I5952 n1_m1_336000_417600 0 2.442274e-06
I5953 n1_m1_336000_422400 0 5.897523e-07
I5954 n1_m1_336000_427200 0 1.694036e-06
I5955 n1_m1_336000_432000 0 9.963463e-07
I5956 n1_m1_336000_436800 0 1.118857e-06
I5957 n1_m1_336000_441600 0 3.291873e-06
I5958 n1_m1_336000_446400 0 2.173413e-06
I5959 n1_m1_336000_451200 0 2.242455e-06
I5960 n1_m1_336000_456000 0 1.360165e-06
I5961 n1_m1_336000_460800 0 3.412661e-07
I5962 n1_m1_336000_465600 0 7.319350e-07
I5963 n1_m1_336000_470400 0 4.827172e-07
I5964 n1_m1_336000_475200 0 5.494119e-07
I5965 n1_m1_336000_480000 0 7.782881e-07
I5966 n1_m1_336000_484800 0 2.141653e-07
I5967 n1_m1_336000_489600 0 5.038633e-07
I5968 n1_m1_336000_494400 0 3.931905e-07
I5969 n1_m1_336000_499200 0 1.774783e-07
I5970 n1_m1_336000_504000 0 3.328048e-07
I5971 n1_m1_336000_508800 0 2.365429e-07
I5972 n1_m1_336000_513600 0 2.325667e-07
I5973 n1_m1_336000_518400 0 2.287692e-07
I5974 n1_m1_336000_523200 0 1.554165e-07
I5975 n1_m1_336000_528000 0 1.125714e-06
I5976 n1_m1_336000_532800 0 2.418000e-07
I5977 n1_m1_336000_537600 0 2.247311e-07
I5978 n1_m1_336000_542400 0 1.325736e-07
I5979 n1_m1_336000_547200 0 1.554154e-07
I5980 n1_m1_336000_552000 0 1.352220e-07
I5981 n1_m1_336000_556800 0 1.511055e-07
I5982 n1_m1_336000_561600 0 2.148500e-07
I5983 n1_m1_336000_576000 0 1.238750e-07
I5984 n1_m1_340800_4800 0 2.730070e-07
I5985 n1_m1_340800_9600 0 3.321256e-07
I5986 n1_m1_340800_57600 0 1.027000e-07
I5987 n1_m1_340800_62400 0 5.618286e-08
I5988 n1_m1_340800_67200 0 7.333714e-08
I5989 n1_m1_340800_72000 0 9.699314e-08
I5990 n1_m1_340800_76800 0 2.832000e-07
I5991 n1_m1_340800_81600 0 4.240000e-07
I5992 n1_m1_340800_86400 0 3.660256e-08
I5993 n1_m1_340800_91200 0 1.546172e-08
I5994 n1_m1_340800_96000 0 1.792043e-07
I5995 n1_m1_340800_100800 0 1.240619e-07
I5996 n1_m1_340800_105600 0 1.085514e-07
I5997 n1_m1_340800_110400 0 7.765000e-08
I5998 n1_m1_340800_115200 0 2.272029e-07
I5999 n1_m1_340800_120000 0 1.558857e-07
I6000 n1_m1_340800_124800 0 8.798469e-08
I6001 n1_m1_340800_129600 0 6.215423e-08
I6002 n1_m1_340800_134400 0 3.791597e-07
I6003 n1_m1_340800_139200 0 8.852941e-07
I6004 n1_m1_340800_144000 0 9.357353e-07
I6005 n1_m1_340800_148800 0 8.467619e-07
I6006 n1_m1_340800_153600 0 8.165648e-07
I6007 n1_m1_340800_158400 0 4.534991e-06
I6008 n1_m1_340800_163200 0 1.901969e-06
I6009 n1_m1_340800_168000 0 2.363000e-06
I6010 n1_m1_340800_172800 0 6.925714e-07
I6011 n1_m1_340800_177600 0 2.275429e-06
I6012 n1_m1_340800_182400 0 1.630000e-06
I6013 n1_m1_340800_187200 0 5.160000e-07
I6014 n1_m1_340800_192000 0 6.163571e-07
I6015 n1_m1_340800_201600 0 3.769524e-08
I6016 n1_m1_340800_206400 0 1.732143e-08
I6017 n1_m1_340800_211200 0 3.655714e-07
I6018 n1_m1_340800_216000 0 2.502571e-07
I6019 n1_m1_340800_220800 0 1.715714e-07
I6020 n1_m1_340800_225600 0 1.069393e-07
I6021 n1_m1_340800_230400 0 2.793000e-07
I6022 n1_m1_340800_235200 0 1.950418e-07
I6023 n1_m1_340800_240000 0 3.558378e-07
I6024 n1_m1_340800_244800 0 3.683429e-07
I6025 n1_m1_340800_249600 0 7.107286e-07
I6026 n1_m1_340800_254400 0 6.250220e-07
I6027 n1_m1_340800_259200 0 2.623605e-07
I6028 n1_m1_340800_264000 0 8.743500e-07
I6029 n1_m1_340800_268800 0 3.546393e-07
I6030 n1_m1_340800_273600 0 8.764359e-07
I6031 n1_m1_340800_278400 0 2.876190e-07
I6032 n1_m1_340800_283200 0 8.918211e-07
I6033 n1_m1_340800_288000 0 9.611688e-08
I6034 n1_m1_340800_292800 0 4.279762e-07
I6035 n1_m1_340800_297600 0 7.533681e-07
I6036 n1_m1_340800_302400 0 6.671097e-07
I6037 n1_m1_340800_307200 0 2.545113e-07
I6038 n1_m1_340800_312000 0 1.177136e-07
I6039 n1_m1_340800_316800 0 4.860541e-07
I6040 n1_m1_340800_321600 0 7.491607e-07
I6041 n1_m1_340800_326400 0 5.663810e-07
I6042 n1_m1_340800_331200 0 1.562828e-07
I6043 n1_m1_340800_336000 0 2.814887e-07
I6044 n1_m1_340800_340800 0 3.007143e-07
I6045 n1_m1_340800_345600 0 8.053869e-08
I6046 n1_m1_340800_350400 0 3.410476e-08
I6047 n1_m1_340800_355200 0 4.666063e-08
I6048 n1_m1_340800_360000 0 7.485071e-08
I6049 n1_m1_340800_364800 0 6.954167e-08
I6050 n1_m1_340800_369600 0 3.892159e-07
I6051 n1_m1_340800_374400 0 3.427013e-07
I6052 n1_m1_340800_379200 0 4.897959e-08
I6053 n1_m1_340800_384000 0 2.182954e-06
I6054 n1_m1_340800_388800 0 1.654633e-06
I6055 n1_m1_340800_393600 0 9.328810e-08
I6056 n1_m1_340800_398400 0 3.042857e-08
I6057 n1_m1_340800_403200 0 3.000000e-08
I6058 n1_m1_340800_408000 0 8.251250e-08
I6059 n1_m1_340800_412800 0 5.357143e-08
I6060 n1_m1_340800_417600 0 3.253393e-07
I6061 n1_m1_340800_422400 0 3.226090e-07
I6062 n1_m1_340800_427200 0 2.517857e-07
I6063 n1_m1_340800_432000 0 5.759913e-07
I6064 n1_m1_340800_436800 0 4.877143e-07
I6065 n1_m1_340800_441600 0 1.553952e-06
I6066 n1_m1_340800_446400 0 2.807540e-07
I6067 n1_m1_340800_451200 0 4.332460e-07
I6068 n1_m1_340800_456000 0 6.893473e-07
I6069 n1_m1_340800_460800 0 4.053221e-07
I6070 n1_m1_340800_465600 0 6.105462e-07
I6071 n1_m1_340800_470400 0 2.974118e-07
I6072 n1_m1_340800_475200 0 1.827731e-07
I6073 n1_m1_340800_480000 0 3.840289e-07
I6074 n1_m1_340800_484800 0 1.323529e-07
I6075 n1_m1_340800_489600 0 1.538686e-07
I6076 n1_m1_340800_494400 0 6.502286e-08
I6077 n1_m1_340800_499200 0 5.368571e-08
I6078 n1_m1_340800_504000 0 6.139429e-08
I6079 n1_m1_340800_508800 0 3.358286e-08
I6080 n1_m1_340800_513600 0 1.258100e-07
I6081 n1_m1_340800_518400 0 5.191667e-08
I6082 n1_m1_340800_528000 0 1.735744e-07
I6083 n1_m1_340800_532800 0 1.190769e-08
I6084 n1_m1_340800_537600 0 3.887692e-08
I6085 n1_m1_340800_542400 0 1.561538e-08
I6086 n1_m1_340800_547200 0 1.049202e-07
I6087 n1_m1_340800_552000 0 4.809121e-08
I6088 n1_m1_340800_556800 0 3.686538e-08
I6089 n1_m1_340800_561600 0 3.580000e-08
I6090 n1_m1_340800_576000 0 3.318080e-07
I6091 n1_m1_340800_580800 0 3.184924e-07
I6092 n1_m1_340800_585600 0 1.161058e-07
I6093 n1_m1_345600_4800 0 2.473700e-07
I6094 n1_m1_345600_9600 0 9.872892e-07
I6095 n1_m1_345600_14400 0 1.710000e-07
I6096 n1_m1_345600_48000 0 1.851429e-08
I6097 n1_m1_345600_52800 0 7.418571e-08
I6098 n1_m1_345600_57600 0 2.233143e-07
I6099 n1_m1_345600_62400 0 1.756000e-07
I6100 n1_m1_345600_67200 0 8.897857e-07
I6101 n1_m1_345600_72000 0 7.276913e-07
I6102 n1_m1_345600_76800 0 2.207652e-07
I6103 n1_m1_345600_81600 0 4.261286e-07
I6104 n1_m1_345600_86400 0 1.368084e-07
I6105 n1_m1_345600_91200 0 1.275701e-07
I6106 n1_m1_345600_96000 0 8.179095e-07
I6107 n1_m1_345600_100800 0 2.176810e-07
I6108 n1_m1_345600_105600 0 5.408171e-07
I6109 n1_m1_345600_110400 0 1.850071e-07
I6110 n1_m1_345600_115200 0 2.217829e-07
I6111 n1_m1_345600_120000 0 9.353086e-07
I6112 n1_m1_345600_124800 0 4.292500e-07
I6113 n1_m1_345600_129600 0 1.299563e-06
I6114 n1_m1_345600_134400 0 4.327966e-07
I6115 n1_m1_345600_139200 0 5.134744e-07
I6116 n1_m1_345600_144000 0 9.358032e-07
I6117 n1_m1_345600_148800 0 1.051586e-06
I6118 n1_m1_345600_153600 0 2.236728e-06
I6119 n1_m1_345600_158400 0 4.054995e-06
I6120 n1_m1_345600_163200 0 4.582895e-06
I6121 n1_m1_345600_168000 0 4.495310e-06
I6122 n1_m1_345600_172800 0 1.174286e-06
I6123 n1_m1_345600_177600 0 4.952714e-06
I6124 n1_m1_345600_182400 0 1.713455e-06
I6125 n1_m1_345600_187200 0 1.516873e-06
I6126 n1_m1_345600_192000 0 4.225225e-06
I6127 n1_m1_345600_196800 0 1.909886e-06
I6128 n1_m1_345600_201600 0 1.551616e-06
I6129 n1_m1_345600_206400 0 3.133643e-07
I6130 n1_m1_345600_211200 0 3.988786e-07
I6131 n1_m1_345600_216000 0 4.124468e-07
I6132 n1_m1_345600_220800 0 1.866065e-07
I6133 n1_m1_345600_225600 0 3.321489e-07
I6134 n1_m1_345600_230400 0 3.230733e-07
I6135 n1_m1_345600_235200 0 2.280811e-07
I6136 n1_m1_345600_240000 0 2.451543e-07
I6137 n1_m1_345600_244800 0 4.344714e-07
I6138 n1_m1_345600_249600 0 2.359321e-06
I6139 n1_m1_345600_254400 0 1.033237e-06
I6140 n1_m1_345600_259200 0 1.708779e-06
I6141 n1_m1_345600_264000 0 2.325775e-06
I6142 n1_m1_345600_268800 0 1.579534e-06
I6143 n1_m1_345600_273600 0 3.574696e-06
I6144 n1_m1_345600_278400 0 1.993571e-06
I6145 n1_m1_345600_283200 0 2.566251e-06
I6146 n1_m1_345600_288000 0 5.985564e-07
I6147 n1_m1_345600_292800 0 1.029048e-06
I6148 n1_m1_345600_297600 0 2.939564e-06
I6149 n1_m1_345600_302400 0 1.870488e-06
I6150 n1_m1_345600_307200 0 1.149917e-06
I6151 n1_m1_345600_312000 0 6.253435e-07
I6152 n1_m1_345600_316800 0 7.868694e-07
I6153 n1_m1_345600_321600 0 1.438967e-06
I6154 n1_m1_345600_326400 0 1.556467e-06
I6155 n1_m1_345600_331200 0 1.149190e-06
I6156 n1_m1_345600_336000 0 1.795548e-06
I6157 n1_m1_345600_340800 0 9.332571e-07
I6158 n1_m1_345600_345600 0 6.127256e-07
I6159 n1_m1_345600_350400 0 1.372014e-07
I6160 n1_m1_345600_355200 0 2.339590e-07
I6161 n1_m1_345600_360000 0 2.699845e-07
I6162 n1_m1_345600_364800 0 6.804026e-07
I6163 n1_m1_345600_369600 0 2.559071e-07
I6164 n1_m1_345600_374400 0 1.892444e-07
I6165 n1_m1_345600_379200 0 1.186952e-07
I6166 n1_m1_345600_384000 0 3.458236e-07
I6167 n1_m1_345600_388800 0 7.158607e-07
I6168 n1_m1_345600_393600 0 2.560414e-07
I6169 n1_m1_345600_398400 0 2.024343e-07
I6170 n1_m1_345600_403200 0 1.309143e-07
I6171 n1_m1_345600_408000 0 3.856732e-07
I6172 n1_m1_345600_412800 0 3.396571e-07
I6173 n1_m1_345600_417600 0 2.258332e-06
I6174 n1_m1_345600_422400 0 3.386820e-06
I6175 n1_m1_345600_427200 0 7.039357e-07
I6176 n1_m1_345600_432000 0 4.312880e-06
I6177 n1_m1_345600_436800 0 2.540238e-06
I6178 n1_m1_345600_441600 0 4.281695e-06
I6179 n1_m1_345600_446400 0 1.401548e-06
I6180 n1_m1_345600_451200 0 4.449571e-06
I6181 n1_m1_345600_456000 0 8.590476e-07
I6182 n1_m1_345600_460800 0 1.670065e-06
I6183 n1_m1_345600_465600 0 2.666653e-06
I6184 n1_m1_345600_470400 0 1.053059e-06
I6185 n1_m1_345600_475200 0 1.979160e-06
I6186 n1_m1_345600_480000 0 1.393608e-06
I6187 n1_m1_345600_484800 0 2.302387e-06
I6188 n1_m1_345600_489600 0 8.426670e-07
I6189 n1_m1_345600_494400 0 5.134286e-07
I6190 n1_m1_345600_499200 0 2.539748e-07
I6191 n1_m1_345600_504000 0 4.660319e-07
I6192 n1_m1_345600_508800 0 9.564286e-08
I6193 n1_m1_345600_513600 0 2.606305e-07
I6194 n1_m1_345600_518400 0 3.164387e-07
I6195 n1_m1_345600_523200 0 1.347646e-07
I6196 n1_m1_345600_528000 0 8.302533e-06
I6197 n1_m1_345600_532800 0 4.844538e-07
I6198 n1_m1_345600_537600 0 1.294205e-07
I6199 n1_m1_345600_542400 0 1.518527e-07
I6200 n1_m1_345600_547200 0 1.629183e-07
I6201 n1_m1_345600_552000 0 3.259604e-07
I6202 n1_m1_345600_556800 0 1.818731e-07
I6203 n1_m1_345600_561600 0 2.764000e-07
I6204 n1_m1_345600_576000 0 3.672009e-07
I6205 n1_m1_345600_580800 0 1.013936e-06
I6206 n1_m1_345600_585600 0 3.083492e-07
I6207 n1_m1_350400_4800 0 1.525349e-07
I6208 n1_m1_350400_9600 0 7.564612e-07
I6209 n1_m1_350400_48000 0 1.354286e-08
I6210 n1_m1_350400_52800 0 6.392381e-08
I6211 n1_m1_350400_57600 0 5.934286e-08
I6212 n1_m1_350400_62400 0 5.282857e-08
I6213 n1_m1_350400_67200 0 4.710000e-08
I6214 n1_m1_350400_72000 0 1.887408e-07
I6215 n1_m1_350400_76800 0 1.353051e-07
I6216 n1_m1_350400_81600 0 3.060429e-07
I6217 n1_m1_350400_86400 0 8.630879e-08
I6218 n1_m1_350400_91200 0 1.949484e-07
I6219 n1_m1_350400_96000 0 3.193748e-07
I6220 n1_m1_350400_100800 0 3.768857e-07
I6221 n1_m1_350400_105600 0 2.430114e-07
I6222 n1_m1_350400_110400 0 5.668143e-07
I6223 n1_m1_350400_115200 0 7.526171e-07
I6224 n1_m1_350400_120000 0 3.759553e-07
I6225 n1_m1_350400_124800 0 5.755952e-07
I6226 n1_m1_350400_129600 0 1.387959e-06
I6227 n1_m1_350400_134400 0 8.500000e-08
I6228 n1_m1_350400_139200 0 9.209286e-08
I6229 n1_m1_350400_144000 0 2.212884e-07
I6230 n1_m1_350400_148800 0 1.084310e-07
I6231 n1_m1_350400_153600 0 1.382278e-06
I6232 n1_m1_350400_158400 0 1.304343e-06
I6233 n1_m1_350400_163200 0 1.004105e-06
I6234 n1_m1_350400_168000 0 4.279738e-06
I6235 n1_m1_350400_172800 0 3.938857e-06
I6236 n1_m1_350400_177600 0 2.118000e-06
I6237 n1_m1_350400_182400 0 9.101169e-07
I6238 n1_m1_350400_187200 0 5.222701e-07
I6239 n1_m1_350400_192000 0 6.295607e-07
I6240 n1_m1_350400_196800 0 8.277143e-07
I6241 n1_m1_350400_201600 0 1.514403e-06
I6242 n1_m1_350400_211200 0 1.099050e-06
I6243 n1_m1_350400_216000 0 1.194237e-06
I6244 n1_m1_350400_220800 0 1.490721e-07
I6245 n1_m1_350400_225600 0 1.192435e-06
I6246 n1_m1_350400_230400 0 1.177524e-07
I6247 n1_m1_350400_235200 0 2.045686e-07
I6248 n1_m1_350400_240000 0 5.528743e-07
I6249 n1_m1_350400_244800 0 3.229286e-07
I6250 n1_m1_350400_249600 0 2.133793e-06
I6251 n1_m1_350400_254400 0 1.107500e-06
I6252 n1_m1_350400_259200 0 1.085950e-06
I6253 n1_m1_350400_264000 0 1.417648e-06
I6254 n1_m1_350400_268800 0 1.314899e-06
I6255 n1_m1_350400_273600 0 1.811776e-06
I6256 n1_m1_350400_278400 0 1.157238e-06
I6257 n1_m1_350400_283200 0 8.977432e-07
I6258 n1_m1_350400_288000 0 1.170172e-06
I6259 n1_m1_350400_292800 0 1.115601e-06
I6260 n1_m1_350400_297600 0 1.440442e-06
I6261 n1_m1_350400_302400 0 1.265851e-06
I6262 n1_m1_350400_307200 0 9.484286e-07
I6263 n1_m1_350400_312000 0 1.057011e-06
I6264 n1_m1_350400_316800 0 7.659364e-07
I6265 n1_m1_350400_321600 0 1.154243e-06
I6266 n1_m1_350400_326400 0 1.693762e-06
I6267 n1_m1_350400_331200 0 1.228631e-06
I6268 n1_m1_350400_336000 0 2.680238e-06
I6269 n1_m1_350400_340800 0 1.581824e-06
I6270 n1_m1_350400_345600 0 5.962508e-07
I6271 n1_m1_350400_350400 0 8.205510e-07
I6272 n1_m1_350400_355200 0 1.972490e-07
I6273 n1_m1_350400_360000 0 9.034190e-07
I6274 n1_m1_350400_364800 0 1.387653e-07
I6275 n1_m1_350400_369600 0 1.114900e-07
I6276 n1_m1_350400_374400 0 1.755556e-07
I6277 n1_m1_350400_379200 0 2.817429e-07
I6278 n1_m1_350400_384000 0 1.400562e-06
I6279 n1_m1_350400_388800 0 1.717571e-07
I6280 n1_m1_350400_393600 0 1.449578e-07
I6281 n1_m1_350400_398400 0 4.619429e-08
I6282 n1_m1_350400_403200 0 1.874857e-07
I6283 n1_m1_350400_408000 0 3.269667e-07
I6284 n1_m1_350400_417600 0 1.077190e-06
I6285 n1_m1_350400_422400 0 7.434762e-07
I6286 n1_m1_350400_427200 0 1.639314e-06
I6287 n1_m1_350400_432000 0 5.911479e-06
I6288 n1_m1_350400_436800 0 1.034733e-06
I6289 n1_m1_350400_441600 0 3.462353e-06
I6290 n1_m1_350400_446400 0 3.207143e-07
I6291 n1_m1_350400_451200 0 9.495429e-07
I6292 n1_m1_350400_456000 0 6.216381e-07
I6293 n1_m1_350400_460800 0 1.093254e-06
I6294 n1_m1_350400_465600 0 1.589612e-06
I6295 n1_m1_350400_470400 0 1.031849e-06
I6296 n1_m1_350400_475200 0 1.239202e-06
I6297 n1_m1_350400_480000 0 2.080504e-07
I6298 n1_m1_350400_484800 0 8.932605e-07
I6299 n1_m1_350400_489600 0 1.102547e-06
I6300 n1_m1_350400_494400 0 2.452286e-07
I6301 n1_m1_350400_499200 0 6.158496e-07
I6302 n1_m1_350400_504000 0 9.151395e-07
I6303 n1_m1_350400_508800 0 1.121286e-07
I6304 n1_m1_350400_513600 0 1.216738e-07
I6305 n1_m1_350400_518400 0 6.231734e-08
I6306 n1_m1_350400_523200 0 2.820681e-08
I6307 n1_m1_350400_528000 0 1.563952e-07
I6308 n1_m1_350400_532800 0 3.019910e-07
I6309 n1_m1_350400_537600 0 8.873714e-08
I6310 n1_m1_350400_542400 0 5.082418e-08
I6311 n1_m1_350400_547200 0 3.235385e-08
I6312 n1_m1_350400_552000 0 2.223319e-07
I6313 n1_m1_350400_556800 0 4.810000e-08
I6314 n1_m1_350400_561600 0 8.150000e-08
I6315 n1_m1_350400_585600 0 3.072000e-08
I6316 n1_m1_355200_4800 0 1.975385e-08
I6317 n1_m1_355200_9600 0 1.300212e-07
I6318 n1_m1_355200_14400 0 3.656250e-07
I6319 n1_m1_355200_48000 0 1.657143e-08
I6320 n1_m1_355200_52800 0 8.751190e-08
I6321 n1_m1_355200_57600 0 1.666107e-07
I6322 n1_m1_355200_62400 0 8.554286e-08
I6323 n1_m1_355200_67200 0 6.580000e-08
I6324 n1_m1_355200_72000 0 1.283590e-07
I6325 n1_m1_355200_76800 0 5.648320e-08
I6326 n1_m1_355200_81600 0 2.242459e-07
I6327 n1_m1_355200_86400 0 2.180549e-07
I6328 n1_m1_355200_91200 0 1.032308e-07
I6329 n1_m1_355200_96000 0 6.452643e-08
I6330 n1_m1_355200_100800 0 5.644048e-08
I6331 n1_m1_355200_105600 0 1.732551e-07
I6332 n1_m1_355200_110400 0 4.793878e-07
I6333 n1_m1_355200_115200 0 1.505714e-07
I6334 n1_m1_355200_120000 0 5.439576e-07
I6335 n1_m1_355200_124800 0 1.123512e-07
I6336 n1_m1_355200_129600 0 3.698270e-07
I6337 n1_m1_355200_134400 0 2.970952e-08
I6338 n1_m1_355200_139200 0 1.157738e-07
I6339 n1_m1_355200_144000 0 2.462214e-07
I6340 n1_m1_355200_148800 0 2.906940e-07
I6341 n1_m1_355200_153600 0 6.426571e-07
I6342 n1_m1_355200_158400 0 1.050400e-06
I6343 n1_m1_355200_163200 0 9.224286e-07
I6344 n1_m1_355200_168000 0 3.714524e-06
I6345 n1_m1_355200_172800 0 9.085714e-07
I6346 n1_m1_355200_177600 0 3.641429e-06
I6347 n1_m1_355200_182400 0 1.574857e-06
I6348 n1_m1_355200_187200 0 5.704286e-07
I6349 n1_m1_355200_192000 0 1.621143e-07
I6350 n1_m1_355200_196800 0 8.550245e-07
I6351 n1_m1_355200_201600 0 1.003230e-06
I6352 n1_m1_355200_206400 0 1.782857e-07
I6353 n1_m1_355200_211200 0 3.186833e-07
I6354 n1_m1_355200_216000 0 1.759922e-07
I6355 n1_m1_355200_220800 0 4.316250e-08
I6356 n1_m1_355200_225600 0 9.579040e-07
I6357 n1_m1_355200_230400 0 5.874571e-08
I6358 n1_m1_355200_235200 0 3.194914e-07
I6359 n1_m1_355200_240000 0 1.480454e-06
I6360 n1_m1_355200_244800 0 1.827214e-07
I6361 n1_m1_355200_249600 0 2.695714e-06
I6362 n1_m1_355200_254400 0 2.552905e-06
I6363 n1_m1_355200_259200 0 1.118732e-06
I6364 n1_m1_355200_264000 0 2.072565e-06
I6365 n1_m1_355200_268800 0 1.514736e-06
I6366 n1_m1_355200_273600 0 2.175117e-06
I6367 n1_m1_355200_278400 0 8.453810e-07
I6368 n1_m1_355200_283200 0 2.767877e-07
I6369 n1_m1_355200_288000 0 6.137143e-07
I6370 n1_m1_355200_292800 0 5.611851e-07
I6371 n1_m1_355200_297600 0 6.811299e-07
I6372 n1_m1_355200_302400 0 3.740000e-07
I6373 n1_m1_355200_307200 0 3.787500e-07
I6374 n1_m1_355200_312000 0 1.858286e-06
I6375 n1_m1_355200_316800 0 1.709646e-06
I6376 n1_m1_355200_321600 0 5.673262e-07
I6377 n1_m1_355200_326400 0 1.059012e-06
I6378 n1_m1_355200_331200 0 7.976250e-07
I6379 n1_m1_355200_336000 0 3.130000e-06
I6380 n1_m1_355200_340800 0 1.782353e-06
I6381 n1_m1_355200_345600 0 2.298877e-06
I6382 n1_m1_355200_350400 0 3.390970e-07
I6383 n1_m1_355200_355200 0 8.390143e-07
I6384 n1_m1_355200_360000 0 5.208953e-07
I6385 n1_m1_355200_364800 0 1.700238e-08
I6386 n1_m1_355200_369600 0 1.196743e-07
I6387 n1_m1_355200_374400 0 3.212500e-08
I6388 n1_m1_355200_379200 0 1.171214e-07
I6389 n1_m1_355200_384000 0 2.411968e-07
I6390 n1_m1_355200_388800 0 4.994286e-08
I6391 n1_m1_355200_393600 0 2.158603e-07
I6392 n1_m1_355200_398400 0 2.575714e-07
I6393 n1_m1_355200_403200 0 6.275714e-08
I6394 n1_m1_355200_408000 0 9.779762e-08
I6395 n1_m1_355200_412800 0 1.305714e-07
I6396 n1_m1_355200_417600 0 2.088536e-06
I6397 n1_m1_355200_422400 0 9.515310e-07
I6398 n1_m1_355200_427200 0 2.874714e-07
I6399 n1_m1_355200_432000 0 7.619891e-07
I6400 n1_m1_355200_436800 0 1.905286e-07
I6401 n1_m1_355200_441600 0 1.530000e-07
I6402 n1_m1_355200_446400 0 1.994196e-07
I6403 n1_m1_355200_451200 0 3.451842e-07
I6404 n1_m1_355200_456000 0 5.936920e-07
I6405 n1_m1_355200_460800 0 2.108036e-08
I6406 n1_m1_355200_465600 0 1.290899e-06
I6407 n1_m1_355200_470400 0 1.040383e-06
I6408 n1_m1_355200_475200 0 8.340000e-07
I6409 n1_m1_355200_480000 0 1.405366e-06
I6410 n1_m1_355200_484800 0 1.442370e-06
I6411 n1_m1_355200_489600 0 4.707731e-07
I6412 n1_m1_355200_494400 0 5.229580e-07
I6413 n1_m1_355200_499200 0 6.576336e-07
I6414 n1_m1_355200_504000 0 7.949779e-07
I6415 n1_m1_355200_508800 0 8.578286e-07
I6416 n1_m1_355200_513600 0 2.042729e-07
I6417 n1_m1_355200_518400 0 5.995804e-08
I6418 n1_m1_355200_523200 0 3.891209e-08
I6419 n1_m1_355200_528000 0 1.144738e-07
I6420 n1_m1_355200_532800 0 1.974706e-07
I6421 n1_m1_355200_537600 0 7.372949e-08
I6422 n1_m1_355200_542400 0 9.255385e-08
I6423 n1_m1_355200_547200 0 1.326538e-07
I6424 n1_m1_355200_552000 0 7.392308e-08
I6425 n1_m1_355200_556800 0 7.152308e-08
I6426 n1_m1_355200_561600 0 7.030000e-07
I6427 n1_m1_355200_580800 0 2.245385e-07
I6428 n1_m1_355200_585600 0 1.403365e-07
I6429 n1_m1_360000_4800 0 3.950769e-08
I6430 n1_m1_360000_9600 0 6.922621e-06
I6431 n1_m1_360000_14400 0 8.849464e-07
I6432 n1_m1_360000_19200 0 1.074286e-07
I6433 n1_m1_360000_48000 0 9.742857e-08
I6434 n1_m1_360000_52800 0 6.822143e-08
I6435 n1_m1_360000_57600 0 1.590369e-07
I6436 n1_m1_360000_62400 0 2.158000e-07
I6437 n1_m1_360000_67200 0 4.040714e-07
I6438 n1_m1_360000_72000 0 9.603513e-07
I6439 n1_m1_360000_76800 0 1.324970e-07
I6440 n1_m1_360000_81600 0 1.843350e-07
I6441 n1_m1_360000_86400 0 1.951352e-07
I6442 n1_m1_360000_91200 0 1.460934e-07
I6443 n1_m1_360000_96000 0 5.462393e-07
I6444 n1_m1_360000_100800 0 2.257929e-07
I6445 n1_m1_360000_105600 0 8.480694e-07
I6446 n1_m1_360000_110400 0 2.088163e-07
I6447 n1_m1_360000_115200 0 2.942143e-07
I6448 n1_m1_360000_120000 0 4.139786e-07
I6449 n1_m1_360000_124800 0 1.927679e-07
I6450 n1_m1_360000_129600 0 2.630000e-07
I6451 n1_m1_360000_134400 0 4.025762e-07
I6452 n1_m1_360000_139200 0 1.205833e-07
I6453 n1_m1_360000_144000 0 3.449000e-07
I6454 n1_m1_360000_148800 0 3.393107e-07
I6455 n1_m1_360000_153600 0 3.194533e-06
I6456 n1_m1_360000_158400 0 3.128838e-06
I6457 n1_m1_360000_163200 0 2.413657e-06
I6458 n1_m1_360000_168000 0 1.252857e-07
I6459 n1_m1_360000_172800 0 6.493143e-07
I6460 n1_m1_360000_177600 0 4.783500e-06
I6461 n1_m1_360000_182400 0 8.520000e-08
I6462 n1_m1_360000_187200 0 8.794286e-08
I6463 n1_m1_360000_192000 0 2.807905e-07
I6464 n1_m1_360000_196800 0 2.956898e-07
I6465 n1_m1_360000_201600 0 1.571541e-06
I6466 n1_m1_360000_206400 0 2.881286e-07
I6467 n1_m1_360000_211200 0 1.774514e-07
I6468 n1_m1_360000_216000 0 3.446320e-07
I6469 n1_m1_360000_220800 0 1.963018e-07
I6470 n1_m1_360000_225600 0 1.777786e-07
I6471 n1_m1_360000_230400 0 1.023000e-07
I6472 n1_m1_360000_235200 0 6.080381e-07
I6473 n1_m1_360000_240000 0 2.298631e-06
I6474 n1_m1_360000_244800 0 1.859536e-06
I6475 n1_m1_360000_249600 0 3.590714e-06
I6476 n1_m1_360000_254400 0 1.598286e-06
I6477 n1_m1_360000_259200 0 2.423587e-06
I6478 n1_m1_360000_264000 0 2.753024e-06
I6479 n1_m1_360000_268800 0 1.140386e-06
I6480 n1_m1_360000_273600 0 2.309832e-06
I6481 n1_m1_360000_278400 0 1.769048e-06
I6482 n1_m1_360000_283200 0 2.838539e-07
I6483 n1_m1_360000_288000 0 3.384628e-06
I6484 n1_m1_360000_292800 0 1.828968e-06
I6485 n1_m1_360000_297600 0 2.080238e-06
I6486 n1_m1_360000_302400 0 8.520571e-07
I6487 n1_m1_360000_307200 0 5.540357e-07
I6488 n1_m1_360000_312000 0 1.459161e-06
I6489 n1_m1_360000_316800 0 7.839250e-07
I6490 n1_m1_360000_321600 0 1.360964e-06
I6491 n1_m1_360000_326400 0 1.269663e-06
I6492 n1_m1_360000_331200 0 2.327179e-06
I6493 n1_m1_360000_336000 0 4.212230e-06
I6494 n1_m1_360000_340800 0 2.239881e-06
I6495 n1_m1_360000_345600 0 2.647193e-06
I6496 n1_m1_360000_350400 0 7.107030e-07
I6497 n1_m1_360000_355200 0 8.246629e-07
I6498 n1_m1_360000_360000 0 9.929342e-07
I6499 n1_m1_360000_364800 0 1.943690e-07
I6500 n1_m1_360000_369600 0 3.775190e-07
I6501 n1_m1_360000_374400 0 1.422036e-07
I6502 n1_m1_360000_379200 0 1.932833e-07
I6503 n1_m1_360000_384000 0 5.394889e-07
I6504 n1_m1_360000_388800 0 6.999714e-07
I6505 n1_m1_360000_393600 0 1.977778e-06
I6506 n1_m1_360000_398400 0 8.068571e-08
I6507 n1_m1_360000_403200 0 1.023143e-07
I6508 n1_m1_360000_408000 0 1.164421e-06
I6509 n1_m1_360000_412800 0 1.338286e-07
I6510 n1_m1_360000_417600 0 2.478304e-07
I6511 n1_m1_360000_422400 0 1.110643e-07
I6512 n1_m1_360000_427200 0 1.959000e-07
I6513 n1_m1_360000_432000 0 1.624092e-07
I6514 n1_m1_360000_436800 0 1.572580e-07
I6515 n1_m1_360000_441600 0 1.791286e-07
I6516 n1_m1_360000_446400 0 1.199375e-07
I6517 n1_m1_360000_451200 0 1.377587e-06
I6518 n1_m1_360000_456000 0 3.928080e-07
I6519 n1_m1_360000_460800 0 1.229196e-07
I6520 n1_m1_360000_465600 0 4.455505e-07
I6521 n1_m1_360000_470400 0 4.475897e-07
I6522 n1_m1_360000_475200 0 1.468447e-06
I6523 n1_m1_360000_480000 0 4.780022e-07
I6524 n1_m1_360000_484800 0 9.742874e-07
I6525 n1_m1_360000_489600 0 7.535269e-07
I6526 n1_m1_360000_494400 0 7.863849e-07
I6527 n1_m1_360000_499200 0 5.349706e-07
I6528 n1_m1_360000_504000 0 2.367165e-06
I6529 n1_m1_360000_508800 0 9.131429e-07
I6530 n1_m1_360000_513600 0 6.596557e-07
I6531 n1_m1_360000_518400 0 1.678462e-07
I6532 n1_m1_360000_523200 0 1.182110e-07
I6533 n1_m1_360000_528000 0 1.400595e-07
I6534 n1_m1_360000_532800 0 2.487487e-07
I6535 n1_m1_360000_537600 0 3.150321e-07
I6536 n1_m1_360000_542400 0 6.976923e-08
I6537 n1_m1_360000_547200 0 1.442462e-07
I6538 n1_m1_360000_552000 0 2.449769e-07
I6539 n1_m1_360000_556800 0 1.577269e-07
I6540 n1_m1_360000_561600 0 6.780000e-08
I6541 n1_m1_360000_576000 0 5.002597e-08
I6542 n1_m1_360000_580800 0 7.501558e-07
I6543 n1_m1_360000_585600 0 3.505500e-07
I6544 n1_m1_364800_4800 0 1.975385e-08
I6545 n1_m1_364800_9600 0 1.147618e-06
I6546 n1_m1_364800_48000 0 2.190408e-07
I6547 n1_m1_364800_52800 0 8.683061e-08
I6548 n1_m1_364800_57600 0 1.783114e-07
I6549 n1_m1_364800_62400 0 4.026857e-08
I6550 n1_m1_364800_67200 0 2.541667e-08
I6551 n1_m1_364800_72000 0 1.655032e-07
I6552 n1_m1_364800_76800 0 1.867303e-07
I6553 n1_m1_364800_81600 0 1.960619e-07
I6554 n1_m1_364800_86400 0 7.690462e-08
I6555 n1_m1_364800_91200 0 3.967582e-07
I6556 n1_m1_364800_96000 0 3.403857e-07
I6557 n1_m1_364800_100800 0 1.378948e-07
I6558 n1_m1_364800_105600 0 2.233302e-07
I6559 n1_m1_364800_110400 0 1.381388e-07
I6560 n1_m1_364800_115200 0 8.528571e-08
I6561 n1_m1_364800_120000 0 1.217952e-07
I6562 n1_m1_364800_124800 0 1.934881e-07
I6563 n1_m1_364800_129600 0 3.073143e-07
I6564 n1_m1_364800_134400 0 6.252857e-08
I6565 n1_m1_364800_139200 0 1.561429e-07
I6566 n1_m1_364800_144000 0 2.903607e-07
I6567 n1_m1_364800_148800 0 3.941762e-07
I6568 n1_m1_364800_153600 0 1.277810e-06
I6569 n1_m1_364800_158400 0 7.201905e-07
I6570 n1_m1_364800_163200 0 3.809714e-08
I6571 n1_m1_364800_168000 0 1.600952e-07
I6572 n1_m1_364800_172800 0 9.957714e-08
I6573 n1_m1_364800_177600 0 1.619571e-07
I6574 n1_m1_364800_182400 0 1.656107e-07
I6575 n1_m1_364800_187200 0 4.971429e-08
I6576 n1_m1_364800_192000 0 1.214500e-07
I6577 n1_m1_364800_196800 0 9.940000e-08
I6578 n1_m1_364800_201600 0 2.412286e-07
I6579 n1_m1_364800_206400 0 1.321114e-07
I6580 n1_m1_364800_211200 0 1.215367e-07
I6581 n1_m1_364800_216000 0 2.074204e-07
I6582 n1_m1_364800_220800 0 1.286286e-07
I6583 n1_m1_364800_225600 0 1.808210e-07
I6584 n1_m1_364800_230400 0 8.507059e-07
I6585 n1_m1_364800_235200 0 1.074048e-06
I6586 n1_m1_364800_240000 0 1.874832e-06
I6587 n1_m1_364800_244800 0 1.382387e-06
I6588 n1_m1_364800_249600 0 7.712857e-07
I6589 n1_m1_364800_254400 0 3.684524e-07
I6590 n1_m1_364800_259200 0 1.122460e-06
I6591 n1_m1_364800_264000 0 2.494206e-06
I6592 n1_m1_364800_268800 0 9.557643e-07
I6593 n1_m1_364800_273600 0 7.710403e-07
I6594 n1_m1_364800_278400 0 3.295238e-07
I6595 n1_m1_364800_283200 0 1.039284e-06
I6596 n1_m1_364800_288000 0 1.212116e-06
I6597 n1_m1_364800_292800 0 1.221408e-06
I6598 n1_m1_364800_297600 0 2.217393e-06
I6599 n1_m1_364800_302400 0 5.370713e-07
I6600 n1_m1_364800_307200 0 9.943301e-07
I6601 n1_m1_364800_312000 0 1.164761e-06
I6602 n1_m1_364800_316800 0 5.100000e-07
I6603 n1_m1_364800_321600 0 1.453361e-06
I6604 n1_m1_364800_326400 0 5.596665e-07
I6605 n1_m1_364800_331200 0 1.525285e-06
I6606 n1_m1_364800_336000 0 2.381085e-06
I6607 n1_m1_364800_340800 0 1.088067e-06
I6608 n1_m1_364800_345600 0 1.920868e-06
I6609 n1_m1_364800_350400 0 9.658571e-07
I6610 n1_m1_364800_355200 0 1.359212e-06
I6611 n1_m1_364800_360000 0 9.564838e-07
I6612 n1_m1_364800_364800 0 4.136241e-07
I6613 n1_m1_364800_369600 0 1.683277e-06
I6614 n1_m1_364800_374400 0 8.016667e-07
I6615 n1_m1_364800_379200 0 6.266429e-07
I6616 n1_m1_364800_384000 0 1.667679e-06
I6617 n1_m1_364800_388800 0 1.132832e-06
I6618 n1_m1_364800_393600 0 1.466421e-06
I6619 n1_m1_364800_398400 0 1.108370e-06
I6620 n1_m1_364800_403200 0 3.273000e-07
I6621 n1_m1_364800_408000 0 4.417286e-07
I6622 n1_m1_364800_412800 0 2.526286e-07
I6623 n1_m1_364800_417600 0 1.433048e-07
I6624 n1_m1_364800_422400 0 1.322762e-07
I6625 n1_m1_364800_427200 0 2.895657e-07
I6626 n1_m1_364800_432000 0 2.107561e-07
I6627 n1_m1_364800_436800 0 5.999559e-08
I6628 n1_m1_364800_441600 0 1.145829e-07
I6629 n1_m1_364800_446400 0 1.199571e-07
I6630 n1_m1_364800_451200 0 6.016203e-07
I6631 n1_m1_364800_456000 0 1.858381e-07
I6632 n1_m1_364800_460800 0 1.244881e-07
I6633 n1_m1_364800_465600 0 1.006571e-07
I6634 n1_m1_364800_470400 0 9.021143e-08
I6635 n1_m1_364800_475200 0 8.475238e-08
I6636 n1_m1_364800_480000 0 2.114139e-07
I6637 n1_m1_364800_484800 0 1.891120e-07
I6638 n1_m1_364800_489600 0 2.916245e-07
I6639 n1_m1_364800_494400 0 1.252571e-07
I6640 n1_m1_364800_499200 0 1.550857e-07
I6641 n1_m1_364800_504000 0 1.824224e-07
I6642 n1_m1_364800_508800 0 1.224490e-07
I6643 n1_m1_364800_513600 0 4.200000e-08
I6644 n1_m1_364800_518400 0 9.184135e-08
I6645 n1_m1_364800_523200 0 7.773187e-08
I6646 n1_m1_364800_528000 0 1.748643e-07
I6647 n1_m1_364800_532800 0 5.715128e-08
I6648 n1_m1_364800_537600 0 1.398423e-07
I6649 n1_m1_364800_542400 0 9.152308e-08
I6650 n1_m1_364800_547200 0 8.538308e-08
I6651 n1_m1_364800_552000 0 1.929919e-07
I6652 n1_m1_364800_556800 0 1.084808e-07
I6653 n1_m1_364800_576000 0 8.337662e-08
I6654 n1_m1_364800_580800 0 8.791059e-07
I6655 n1_m1_364800_585600 0 2.367788e-07
I6656 n1_m1_369600_4800 0 1.975385e-08
I6657 n1_m1_369600_9600 0 1.313209e-06
I6658 n1_m1_369600_14400 0 1.207143e-07
I6659 n1_m1_369600_48000 0 4.972381e-08
I6660 n1_m1_369600_52800 0 3.729286e-08
I6661 n1_m1_369600_57600 0 2.864857e-07
I6662 n1_m1_369600_62400 0 1.177714e-07
I6663 n1_m1_369600_67200 0 7.043036e-08
I6664 n1_m1_369600_72000 0 3.178833e-07
I6665 n1_m1_369600_76800 0 7.891429e-08
I6666 n1_m1_369600_81600 0 7.596262e-07
I6667 n1_m1_369600_86400 0 9.022747e-08
I6668 n1_m1_369600_91200 0 5.808681e-08
I6669 n1_m1_369600_96000 0 1.326000e-07
I6670 n1_m1_369600_100800 0 9.325357e-08
I6671 n1_m1_369600_105600 0 3.376548e-07
I6672 n1_m1_369600_110400 0 3.478571e-07
I6673 n1_m1_369600_115200 0 9.587143e-08
I6674 n1_m1_369600_120000 0 9.878571e-08
I6675 n1_m1_369600_124800 0 5.521429e-08
I6676 n1_m1_369600_129600 0 1.725000e-07
I6677 n1_m1_369600_134400 0 4.619595e-07
I6678 n1_m1_369600_139200 0 8.657143e-08
I6679 n1_m1_369600_144000 0 7.158429e-07
I6680 n1_m1_369600_148800 0 2.503000e-06
I6681 n1_m1_369600_153600 0 5.896395e-06
I6682 n1_m1_369600_158400 0 2.117286e-07
I6683 n1_m1_369600_163200 0 6.176905e-08
I6684 n1_m1_369600_168000 0 7.200000e-08
I6685 n1_m1_369600_172800 0 1.374714e-07
I6686 n1_m1_369600_177600 0 7.338571e-08
I6687 n1_m1_369600_182400 0 7.250000e-08
I6688 n1_m1_369600_187200 0 6.565714e-08
I6689 n1_m1_369600_192000 0 1.575845e-07
I6690 n1_m1_369600_196800 0 2.611429e-08
I6691 n1_m1_369600_201600 0 1.369315e-07
I6692 n1_m1_369600_206400 0 1.080000e-07
I6693 n1_m1_369600_211200 0 7.201905e-08
I6694 n1_m1_369600_216000 0 1.407524e-07
I6695 n1_m1_369600_220800 0 5.562857e-08
I6696 n1_m1_369600_225600 0 2.706429e-07
I6697 n1_m1_369600_230400 0 6.438286e-07
I6698 n1_m1_369600_235200 0 1.375786e-07
I6699 n1_m1_369600_240000 0 1.348689e-06
I6700 n1_m1_369600_244800 0 4.012182e-07
I6701 n1_m1_369600_249600 0 1.581405e-06
I6702 n1_m1_369600_254400 0 1.070173e-06
I6703 n1_m1_369600_259200 0 1.683571e-06
I6704 n1_m1_369600_264000 0 2.177044e-06
I6705 n1_m1_369600_268800 0 5.845737e-07
I6706 n1_m1_369600_273600 0 6.885893e-07
I6707 n1_m1_369600_278400 0 5.942381e-07
I6708 n1_m1_369600_283200 0 1.366635e-06
I6709 n1_m1_369600_288000 0 9.246767e-07
I6710 n1_m1_369600_292800 0 7.640714e-07
I6711 n1_m1_369600_297600 0 2.779708e-06
I6712 n1_m1_369600_302400 0 2.236254e-06
I6713 n1_m1_369600_307200 0 2.406712e-06
I6714 n1_m1_369600_312000 0 9.168275e-07
I6715 n1_m1_369600_316800 0 3.328929e-07
I6716 n1_m1_369600_321600 0 1.428212e-06
I6717 n1_m1_369600_326400 0 2.452702e-07
I6718 n1_m1_369600_331200 0 1.917679e-08
I6719 n1_m1_369600_336000 0 4.458000e-07
I6720 n1_m1_369600_340800 0 1.257395e-07
I6721 n1_m1_369600_345600 0 2.005723e-06
I6722 n1_m1_369600_350400 0 8.974127e-07
I6723 n1_m1_369600_355200 0 9.388571e-07
I6724 n1_m1_369600_360000 0 1.460960e-06
I6725 n1_m1_369600_364800 0 1.316981e-07
I6726 n1_m1_369600_369600 0 1.217426e-06
I6727 n1_m1_369600_374400 0 1.330238e-06
I6728 n1_m1_369600_379200 0 3.125000e-07
I6729 n1_m1_369600_384000 0 1.440294e-06
I6730 n1_m1_369600_388800 0 8.824706e-07
I6731 n1_m1_369600_393600 0 1.280452e-06
I6732 n1_m1_369600_398400 0 1.000031e-06
I6733 n1_m1_369600_403200 0 7.331064e-07
I6734 n1_m1_369600_408000 0 9.009643e-08
I6735 n1_m1_369600_412800 0 1.644452e-07
I6736 n1_m1_369600_417600 0 2.733843e-07
I6737 n1_m1_369600_422400 0 1.805667e-07
I6738 n1_m1_369600_427200 0 2.136190e-07
I6739 n1_m1_369600_432000 0 3.167321e-07
I6740 n1_m1_369600_436800 0 4.202857e-08
I6741 n1_m1_369600_441600 0 1.053238e-07
I6742 n1_m1_369600_446400 0 1.130357e-07
I6743 n1_m1_369600_451200 0 9.194286e-08
I6744 n1_m1_369600_456000 0 4.631714e-07
I6745 n1_m1_369600_460800 0 6.885714e-08
I6746 n1_m1_369600_465600 0 5.728929e-08
I6747 n1_m1_369600_470400 0 6.414048e-08
I6748 n1_m1_369600_475200 0 4.600000e-08
I6749 n1_m1_369600_480000 0 2.213429e-07
I6750 n1_m1_369600_484800 0 2.071143e-07
I6751 n1_m1_369600_489600 0 1.589843e-06
I6752 n1_m1_369600_494400 0 1.597214e-06
I6753 n1_m1_369600_499200 0 3.131357e-07
I6754 n1_m1_369600_504000 0 4.416370e-07
I6755 n1_m1_369600_508800 0 2.350714e-07
I6756 n1_m1_369600_513600 0 3.713690e-07
I6757 n1_m1_369600_518400 0 5.562308e-08
I6758 n1_m1_369600_523200 0 7.249359e-08
I6759 n1_m1_369600_528000 0 1.319417e-07
I6760 n1_m1_369600_532800 0 2.307692e-09
I6761 n1_m1_369600_537600 0 1.321154e-07
I6762 n1_m1_369600_542400 0 4.915192e-08
I6763 n1_m1_369600_547200 0 3.930462e-07
I6764 n1_m1_369600_552000 0 2.402872e-07
I6765 n1_m1_369600_571200 0 1.440000e-08
I6766 n1_m1_369600_576000 0 2.057143e-09
I6767 n1_m1_369600_580800 0 3.460352e-07
I6768 n1_m1_369600_585600 0 2.477910e-07
I6769 n1_m1_374400_4800 0 3.089231e-08
I6770 n1_m1_374400_9600 0 6.169494e-07
I6771 n1_m1_374400_14400 0 2.600000e-07
I6772 n1_m1_374400_48000 0 8.094286e-08
I6773 n1_m1_374400_52800 0 9.120714e-08
I6774 n1_m1_374400_57600 0 6.350000e-08
I6775 n1_m1_374400_62400 0 1.446000e-07
I6776 n1_m1_374400_67200 0 4.181250e-08
I6777 n1_m1_374400_72000 0 1.744205e-07
I6778 n1_m1_374400_76800 0 1.732938e-07
I6779 n1_m1_374400_81600 0 9.074500e-07
I6780 n1_m1_374400_86400 0 2.858626e-07
I6781 n1_m1_374400_91200 0 1.076374e-07
I6782 n1_m1_374400_96000 0 3.760571e-07
I6783 n1_m1_374400_100800 0 8.291786e-08
I6784 n1_m1_374400_105600 0 3.598024e-07
I6785 n1_m1_374400_110400 0 3.854464e-07
I6786 n1_m1_374400_115200 0 1.406786e-07
I6787 n1_m1_374400_120000 0 1.569429e-07
I6788 n1_m1_374400_124800 0 1.203571e-07
I6789 n1_m1_374400_129600 0 2.201762e-07
I6790 n1_m1_374400_134400 0 6.475476e-08
I6791 n1_m1_374400_139200 0 4.485714e-08
I6792 n1_m1_374400_144000 0 1.245857e-07
I6793 n1_m1_374400_148800 0 1.606429e-07
I6794 n1_m1_374400_153600 0 3.096000e-06
I6795 n1_m1_374400_158400 0 1.632143e-07
I6796 n1_m1_374400_163200 0 1.601774e-07
I6797 n1_m1_374400_168000 0 6.937143e-08
I6798 n1_m1_374400_172800 0 9.883571e-08
I6799 n1_m1_374400_177600 0 1.807845e-07
I6800 n1_m1_374400_182400 0 5.998571e-08
I6801 n1_m1_374400_187200 0 3.422143e-08
I6802 n1_m1_374400_192000 0 2.765429e-07
I6803 n1_m1_374400_196800 0 2.982857e-07
I6804 n1_m1_374400_201600 0 2.183875e-07
I6805 n1_m1_374400_206400 0 4.151143e-07
I6806 n1_m1_374400_211200 0 2.649429e-07
I6807 n1_m1_374400_216000 0 1.536238e-07
I6808 n1_m1_374400_220800 0 6.123000e-07
I6809 n1_m1_374400_225600 0 2.618571e-07
I6810 n1_m1_374400_230400 0 1.806571e-07
I6811 n1_m1_374400_235200 0 3.991357e-07
I6812 n1_m1_374400_240000 0 1.284248e-06
I6813 n1_m1_374400_244800 0 5.809516e-07
I6814 n1_m1_374400_249600 0 1.371570e-06
I6815 n1_m1_374400_254400 0 1.461928e-06
I6816 n1_m1_374400_259200 0 5.630649e-07
I6817 n1_m1_374400_264000 0 2.371901e-06
I6818 n1_m1_374400_268800 0 9.838120e-07
I6819 n1_m1_374400_273600 0 1.744586e-06
I6820 n1_m1_374400_278400 0 2.237143e-06
I6821 n1_m1_374400_283200 0 1.165389e-06
I6822 n1_m1_374400_288000 0 2.406014e-06
I6823 n1_m1_374400_292800 0 2.299286e-06
I6824 n1_m1_374400_297600 0 1.220000e-06
I6825 n1_m1_374400_302400 0 1.242447e-06
I6826 n1_m1_374400_307200 0 2.306863e-06
I6827 n1_m1_374400_312000 0 5.000762e-07
I6828 n1_m1_374400_316800 0 2.736660e-07
I6829 n1_m1_374400_321600 0 7.752214e-07
I6830 n1_m1_374400_326400 0 4.721751e-07
I6831 n1_m1_374400_331200 0 2.137832e-07
I6832 n1_m1_374400_336000 0 4.040095e-07
I6833 n1_m1_374400_340800 0 5.166891e-07
I6834 n1_m1_374400_345600 0 1.252027e-06
I6835 n1_m1_374400_350400 0 1.247029e-06
I6836 n1_m1_374400_355200 0 1.519143e-07
I6837 n1_m1_374400_360000 0 2.374964e-07
I6838 n1_m1_374400_364800 0 1.310500e-07
I6839 n1_m1_374400_369600 0 7.319048e-07
I6840 n1_m1_374400_374400 0 4.840536e-07
I6841 n1_m1_374400_379200 0 3.728571e-08
I6842 n1_m1_374400_384000 0 1.121515e-06
I6843 n1_m1_374400_388800 0 1.149630e-06
I6844 n1_m1_374400_393600 0 1.913108e-06
I6845 n1_m1_374400_398400 0 9.043903e-07
I6846 n1_m1_374400_403200 0 7.585406e-07
I6847 n1_m1_374400_408000 0 6.180560e-07
I6848 n1_m1_374400_412800 0 2.404405e-07
I6849 n1_m1_374400_417600 0 1.042300e-07
I6850 n1_m1_374400_422400 0 1.930333e-07
I6851 n1_m1_374400_427200 0 6.791429e-08
I6852 n1_m1_374400_432000 0 3.560143e-07
I6853 n1_m1_374400_436800 0 1.732029e-07
I6854 n1_m1_374400_441600 0 4.389171e-07
I6855 n1_m1_374400_446400 0 3.015714e-07
I6856 n1_m1_374400_451200 0 1.494571e-07
I6857 n1_m1_374400_456000 0 1.202871e-06
I6858 n1_m1_374400_460800 0 1.248571e-07
I6859 n1_m1_374400_465600 0 1.685429e-07
I6860 n1_m1_374400_470400 0 9.546905e-08
I6861 n1_m1_374400_475200 0 1.887143e-07
I6862 n1_m1_374400_480000 0 5.462857e-08
I6863 n1_m1_374400_489600 0 9.905143e-07
I6864 n1_m1_374400_494400 0 1.387414e-06
I6865 n1_m1_374400_499200 0 4.929286e-08
I6866 n1_m1_374400_504000 0 1.085407e-06
I6867 n1_m1_374400_508800 0 1.376143e-07
I6868 n1_m1_374400_513600 0 6.701738e-07
I6869 n1_m1_374400_518400 0 6.120769e-08
I6870 n1_m1_374400_523200 0 1.377852e-07
I6871 n1_m1_374400_528000 0 2.565155e-07
I6872 n1_m1_374400_532800 0 8.731538e-08
I6873 n1_m1_374400_537600 0 1.157846e-07
I6874 n1_m1_374400_542400 0 5.222500e-08
I6875 n1_m1_374400_547200 0 4.398923e-07
I6876 n1_m1_374400_552000 0 5.707692e-09
I6877 n1_m1_374400_580800 0 2.974615e-07
I6878 n1_m1_374400_585600 0 2.928801e-07
I6879 n1_m1_379200_4800 0 1.544615e-08
I6880 n1_m1_379200_9600 0 4.187179e-09
I6881 n1_m1_379200_48000 0 3.548571e-08
I6882 n1_m1_379200_52800 0 1.618143e-07
I6883 n1_m1_379200_57600 0 8.634048e-08
I6884 n1_m1_379200_62400 0 1.177429e-07
I6885 n1_m1_379200_67200 0 9.343750e-08
I6886 n1_m1_379200_72000 0 1.055564e-07
I6887 n1_m1_379200_76800 0 1.438864e-07
I6888 n1_m1_379200_81600 0 8.002619e-08
I6889 n1_m1_379200_86400 0 5.571172e-08
I6890 n1_m1_379200_91200 0 1.128835e-07
I6891 n1_m1_379200_96000 0 5.374821e-07
I6892 n1_m1_379200_100800 0 2.337286e-07
I6893 n1_m1_379200_105600 0 2.118000e-07
I6894 n1_m1_379200_110400 0 9.713690e-08
I6895 n1_m1_379200_115200 0 2.399333e-07
I6896 n1_m1_379200_120000 0 1.237714e-07
I6897 n1_m1_379200_124800 0 1.212946e-07
I6898 n1_m1_379200_129600 0 1.894274e-07
I6899 n1_m1_379200_134400 0 6.744048e-08
I6900 n1_m1_379200_139200 0 6.185714e-08
I6901 n1_m1_379200_144000 0 1.435286e-07
I6902 n1_m1_379200_148800 0 1.615143e-07
I6903 n1_m1_379200_153600 0 3.033225e-06
I6904 n1_m1_379200_158400 0 6.007143e-07
I6905 n1_m1_379200_163200 0 6.871071e-08
I6906 n1_m1_379200_168000 0 1.358364e-06
I6907 n1_m1_379200_172800 0 3.278024e-07
I6908 n1_m1_379200_177600 0 1.114417e-07
I6909 n1_m1_379200_182400 0 1.167143e-07
I6910 n1_m1_379200_187200 0 7.100714e-08
I6911 n1_m1_379200_192000 0 1.487286e-07
I6912 n1_m1_379200_196800 0 6.118571e-08
I6913 n1_m1_379200_201600 0 3.906152e-07
I6914 n1_m1_379200_206400 0 1.938757e-07
I6915 n1_m1_379200_211200 0 4.290714e-07
I6916 n1_m1_379200_216000 0 2.137696e-07
I6917 n1_m1_379200_220800 0 4.230548e-07
I6918 n1_m1_379200_225600 0 5.338929e-07
I6919 n1_m1_379200_230400 0 1.569571e-07
I6920 n1_m1_379200_235200 0 2.145333e-07
I6921 n1_m1_379200_240000 0 1.946387e-06
I6922 n1_m1_379200_244800 0 1.379529e-06
I6923 n1_m1_379200_249600 0 1.583890e-06
I6924 n1_m1_379200_254400 0 3.351818e-07
I6925 n1_m1_379200_259200 0 7.187481e-07
I6926 n1_m1_379200_264000 0 1.794259e-06
I6927 n1_m1_379200_268800 0 1.760563e-06
I6928 n1_m1_379200_273600 0 1.879571e-06
I6929 n1_m1_379200_278400 0 2.221310e-06
I6930 n1_m1_379200_283200 0 6.569635e-07
I6931 n1_m1_379200_288000 0 1.417024e-06
I6932 n1_m1_379200_292800 0 9.550000e-07
I6933 n1_m1_379200_297600 0 2.654286e-06
I6934 n1_m1_379200_302400 0 1.513209e-06
I6935 n1_m1_379200_307200 0 1.440266e-06
I6936 n1_m1_379200_312000 0 3.858976e-07
I6937 n1_m1_379200_316800 0 3.562161e-07
I6938 n1_m1_379200_321600 0 2.839702e-06
I6939 n1_m1_379200_326400 0 4.643332e-07
I6940 n1_m1_379200_331200 0 1.338472e-07
I6941 n1_m1_379200_336000 0 2.585405e-07
I6942 n1_m1_379200_340800 0 8.440286e-07
I6943 n1_m1_379200_345600 0 8.981279e-07
I6944 n1_m1_379200_350400 0 5.709205e-07
I6945 n1_m1_379200_355200 0 1.127214e-07
I6946 n1_m1_379200_360000 0 1.776250e-07
I6947 n1_m1_379200_364800 0 1.156732e-07
I6948 n1_m1_379200_369600 0 5.728168e-07
I6949 n1_m1_379200_374400 0 1.047107e-07
I6950 n1_m1_379200_379200 0 1.643143e-07
I6951 n1_m1_379200_384000 0 4.929905e-07
I6952 n1_m1_379200_388800 0 1.340605e-06
I6953 n1_m1_379200_393600 0 1.342645e-06
I6954 n1_m1_379200_398400 0 9.476190e-07
I6955 n1_m1_379200_403200 0 4.266403e-07
I6956 n1_m1_379200_408000 0 1.060262e-07
I6957 n1_m1_379200_412800 0 1.512571e-07
I6958 n1_m1_379200_417600 0 8.840238e-08
I6959 n1_m1_379200_422400 0 6.205952e-08
I6960 n1_m1_379200_427200 0 1.422000e-07
I6961 n1_m1_379200_432000 0 1.253714e-07
I6962 n1_m1_379200_436800 0 3.651857e-08
I6963 n1_m1_379200_441600 0 2.471829e-07
I6964 n1_m1_379200_446400 0 1.002500e-07
I6965 n1_m1_379200_451200 0 3.124714e-07
I6966 n1_m1_379200_456000 0 1.869571e-07
I6967 n1_m1_379200_460800 0 5.039286e-08
I6968 n1_m1_379200_465600 0 6.207143e-08
I6969 n1_m1_379200_470400 0 5.588571e-08
I6970 n1_m1_379200_475200 0 1.454286e-07
I6971 n1_m1_379200_480000 0 4.277143e-08
I6972 n1_m1_379200_494400 0 9.000000e-08
I6973 n1_m1_379200_499200 0 8.943277e-07
I6974 n1_m1_379200_504000 0 5.553112e-06
I6975 n1_m1_379200_508800 0 8.693429e-07
I6976 n1_m1_379200_513600 0 5.597143e-07
I6977 n1_m1_379200_518400 0 7.035385e-07
I6978 n1_m1_379200_523200 0 5.734615e-07
I6979 n1_m1_379200_528000 0 2.708000e-07
I6980 n1_m1_379200_532800 0 2.561538e-08
I6981 n1_m1_379200_537600 0 1.163846e-07
I6982 n1_m1_379200_547200 0 3.715000e-07
I6983 n1_m1_379200_580800 0 3.792308e-07
I6984 n1_m1_379200_585600 0 2.370192e-07
I6985 n1_m1_384000_4800 0 1.975385e-08
I6986 n1_m1_384000_9600 0 5.160070e-08
I6987 n1_m1_384000_48000 0 1.629714e-07
I6988 n1_m1_384000_52800 0 9.122857e-08
I6989 n1_m1_384000_57600 0 1.922976e-07
I6990 n1_m1_384000_62400 0 6.636571e-08
I6991 n1_m1_384000_67200 0 1.041725e-07
I6992 n1_m1_384000_72000 0 2.723721e-07
I6993 n1_m1_384000_76800 0 1.141989e-07
I6994 n1_m1_384000_81600 0 2.505119e-07
I6995 n1_m1_384000_86400 0 2.289346e-07
I6996 n1_m1_384000_91200 0 1.210292e-07
I6997 n1_m1_384000_96000 0 2.484970e-07
I6998 n1_m1_384000_100800 0 2.660095e-07
I6999 n1_m1_384000_105600 0 5.109400e-07
I7000 n1_m1_384000_110400 0 1.346310e-07
I7001 n1_m1_384000_115200 0 3.046595e-07
I7002 n1_m1_384000_120000 0 3.502257e-07
I7003 n1_m1_384000_124800 0 1.455196e-07
I7004 n1_m1_384000_129600 0 4.969107e-07
I7005 n1_m1_384000_134400 0 1.614548e-07
I7006 n1_m1_384000_139200 0 1.721125e-07
I7007 n1_m1_384000_144000 0 3.696486e-07
I7008 n1_m1_384000_148800 0 5.302000e-07
I7009 n1_m1_384000_153600 0 1.426104e-06
I7010 n1_m1_384000_158400 0 4.782857e-08
I7011 n1_m1_384000_163200 0 2.346429e-07
I7012 n1_m1_384000_168000 0 8.882100e-07
I7013 n1_m1_384000_172800 0 2.944905e-07
I7014 n1_m1_384000_177600 0 5.225476e-07
I7015 n1_m1_384000_182400 0 1.223286e-07
I7016 n1_m1_384000_187200 0 9.580000e-08
I7017 n1_m1_384000_192000 0 1.866964e-07
I7018 n1_m1_384000_196800 0 2.825971e-07
I7019 n1_m1_384000_201600 0 2.540392e-07
I7020 n1_m1_384000_206400 0 1.499222e-07
I7021 n1_m1_384000_211200 0 1.998571e-07
I7022 n1_m1_384000_216000 0 2.822018e-07
I7023 n1_m1_384000_220800 0 1.137452e-07
I7024 n1_m1_384000_225600 0 6.503500e-07
I7025 n1_m1_384000_230400 0 2.472143e-07
I7026 n1_m1_384000_235200 0 3.291524e-07
I7027 n1_m1_384000_240000 0 8.820952e-07
I7028 n1_m1_384000_244800 0 1.362645e-06
I7029 n1_m1_384000_249600 0 2.090163e-06
I7030 n1_m1_384000_254400 0 7.483508e-07
I7031 n1_m1_384000_259200 0 1.487362e-06
I7032 n1_m1_384000_264000 0 1.590532e-06
I7033 n1_m1_384000_268800 0 2.126302e-06
I7034 n1_m1_384000_273600 0 1.836767e-06
I7035 n1_m1_384000_278400 0 2.897262e-06
I7036 n1_m1_384000_283200 0 1.082276e-06
I7037 n1_m1_384000_288000 0 4.366000e-06
I7038 n1_m1_384000_292800 0 4.433571e-06
I7039 n1_m1_384000_297600 0 4.262971e-06
I7040 n1_m1_384000_302400 0 1.489856e-06
I7041 n1_m1_384000_307200 0 7.991501e-07
I7042 n1_m1_384000_312000 0 3.633806e-07
I7043 n1_m1_384000_316800 0 8.489853e-07
I7044 n1_m1_384000_321600 0 3.248624e-06
I7045 n1_m1_384000_326400 0 7.748929e-07
I7046 n1_m1_384000_331200 0 1.177473e-06
I7047 n1_m1_384000_336000 0 4.077051e-07
I7048 n1_m1_384000_340800 0 6.054000e-07
I7049 n1_m1_384000_345600 0 8.616089e-07
I7050 n1_m1_384000_350400 0 4.311518e-07
I7051 n1_m1_384000_355200 0 2.426679e-07
I7052 n1_m1_384000_360000 0 4.573804e-07
I7053 n1_m1_384000_364800 0 5.122898e-07
I7054 n1_m1_384000_369600 0 1.198753e-06
I7055 n1_m1_384000_374400 0 5.149750e-07
I7056 n1_m1_384000_379200 0 4.048286e-07
I7057 n1_m1_384000_384000 0 5.969429e-07
I7058 n1_m1_384000_388800 0 1.329008e-06
I7059 n1_m1_384000_393600 0 2.253464e-06
I7060 n1_m1_384000_398400 0 1.117787e-06
I7061 n1_m1_384000_403200 0 7.316286e-07
I7062 n1_m1_384000_408000 0 9.986214e-07
I7063 n1_m1_384000_412800 0 1.803714e-07
I7064 n1_m1_384000_417600 0 1.820833e-07
I7065 n1_m1_384000_422400 0 5.663929e-07
I7066 n1_m1_384000_427200 0 1.169457e-06
I7067 n1_m1_384000_432000 0 5.727857e-07
I7068 n1_m1_384000_436800 0 5.563643e-07
I7069 n1_m1_384000_441600 0 3.180405e-07
I7070 n1_m1_384000_446400 0 1.854167e-07
I7071 n1_m1_384000_451200 0 2.342453e-07
I7072 n1_m1_384000_456000 0 3.295109e-07
I7073 n1_m1_384000_460800 0 2.448405e-07
I7074 n1_m1_384000_465600 0 6.289886e-07
I7075 n1_m1_384000_470400 0 2.328143e-07
I7076 n1_m1_384000_475200 0 2.061429e-07
I7077 n1_m1_384000_480000 0 3.496886e-07
I7078 n1_m1_384000_484800 0 8.944589e-08
I7079 n1_m1_384000_489600 0 2.575758e-08
I7080 n1_m1_384000_499200 0 5.495798e-08
I7081 n1_m1_384000_504000 0 1.024395e-06
I7082 n1_m1_384000_580800 0 1.896154e-07
I7083 n1_m1_384000_585600 0 1.695096e-07
I7084 n1_m1_388800_9600 0 7.940909e-07
I7085 n1_m1_388800_14400 0 1.140000e-07
I7086 n1_m1_388800_19200 0 1.520000e-07
I7087 n1_m1_388800_48000 0 2.746286e-08
I7088 n1_m1_388800_52800 0 5.629714e-08
I7089 n1_m1_388800_57600 0 1.847429e-07
I7090 n1_m1_388800_62400 0 1.012343e-07
I7091 n1_m1_388800_67200 0 1.456757e-07
I7092 n1_m1_388800_72000 0 7.261769e-08
I7093 n1_m1_388800_76800 0 6.505557e-08
I7094 n1_m1_388800_81600 0 8.076531e-08
I7095 n1_m1_388800_86400 0 1.718625e-07
I7096 n1_m1_388800_91200 0 3.410744e-07
I7097 n1_m1_388800_96000 0 7.547491e-07
I7098 n1_m1_388800_100800 0 9.934762e-08
I7099 n1_m1_388800_105600 0 1.228743e-07
I7100 n1_m1_388800_110400 0 5.757143e-08
I7101 n1_m1_388800_115200 0 1.411143e-07
I7102 n1_m1_388800_120000 0 1.099086e-07
I7103 n1_m1_388800_124800 0 1.915810e-07
I7104 n1_m1_388800_129600 0 1.995810e-07
I7105 n1_m1_388800_134400 0 8.264762e-08
I7106 n1_m1_388800_139200 0 1.246732e-07
I7107 n1_m1_388800_144000 0 2.933086e-07
I7108 n1_m1_388800_148800 0 2.825000e-07
I7109 n1_m1_388800_153600 0 1.297008e-06
I7110 n1_m1_388800_158400 0 9.007810e-07
I7111 n1_m1_388800_163200 0 2.368492e-07
I7112 n1_m1_388800_168000 0 1.430971e-07
I7113 n1_m1_388800_172800 0 6.725714e-08
I7114 n1_m1_388800_177600 0 7.233929e-07
I7115 n1_m1_388800_182400 0 8.087143e-08
I7116 n1_m1_388800_187200 0 1.176571e-07
I7117 n1_m1_388800_192000 0 1.525714e-07
I7118 n1_m1_388800_196800 0 6.788857e-08
I7119 n1_m1_388800_201600 0 2.068170e-07
I7120 n1_m1_388800_206400 0 2.095592e-07
I7121 n1_m1_388800_216000 0 2.777143e-07
I7122 n1_m1_388800_220800 0 5.558571e-08
I7123 n1_m1_388800_225600 0 8.207551e-08
I7124 n1_m1_388800_230400 0 1.427388e-07
I7125 n1_m1_388800_235200 0 8.589643e-08
I7126 n1_m1_388800_240000 0 2.921857e-07
I7127 n1_m1_388800_244800 0 1.458342e-06
I7128 n1_m1_388800_249600 0 2.166613e-06
I7129 n1_m1_388800_254400 0 6.872393e-07
I7130 n1_m1_388800_259200 0 9.645395e-07
I7131 n1_m1_388800_264000 0 1.399699e-06
I7132 n1_m1_388800_268800 0 1.750205e-06
I7133 n1_m1_388800_273600 0 3.053722e-06
I7134 n1_m1_388800_278400 0 2.568163e-06
I7135 n1_m1_388800_283200 0 2.078118e-06
I7136 n1_m1_388800_288000 0 2.335524e-06
I7137 n1_m1_388800_292800 0 1.463095e-06
I7138 n1_m1_388800_297600 0 1.688743e-06
I7139 n1_m1_388800_302400 0 1.300437e-06
I7140 n1_m1_388800_307200 0 1.531306e-07
I7141 n1_m1_388800_312000 0 2.844980e-07
I7142 n1_m1_388800_316800 0 1.349111e-07
I7143 n1_m1_388800_321600 0 3.766738e-07
I7144 n1_m1_388800_326400 0 1.036551e-07
I7145 n1_m1_388800_331200 0 6.481190e-08
I7146 n1_m1_388800_336000 0 2.335878e-07
I7147 n1_m1_388800_340800 0 1.082857e-07
I7148 n1_m1_388800_345600 0 4.817179e-07
I7149 n1_m1_388800_350400 0 2.001429e-08
I7150 n1_m1_388800_355200 0 6.381071e-08
I7151 n1_m1_388800_360000 0 1.215875e-07
I7152 n1_m1_388800_364800 0 1.989084e-07
I7153 n1_m1_388800_369600 0 3.054017e-07
I7154 n1_m1_388800_374400 0 1.377464e-07
I7155 n1_m1_388800_379200 0 1.858057e-07
I7156 n1_m1_388800_384000 0 1.262552e-07
I7157 n1_m1_388800_388800 0 4.277000e-07
I7158 n1_m1_388800_393600 0 8.224086e-07
I7159 n1_m1_388800_398400 0 4.914419e-07
I7160 n1_m1_388800_403200 0 2.010429e-07
I7161 n1_m1_388800_408000 0 1.232143e-07
I7162 n1_m1_388800_412800 0 9.247143e-08
I7163 n1_m1_388800_417600 0 1.224393e-07
I7164 n1_m1_388800_422400 0 2.055306e-07
I7165 n1_m1_388800_427200 0 9.944082e-08
I7166 n1_m1_388800_432000 0 4.705786e-07
I7167 n1_m1_388800_436800 0 4.733000e-07
I7168 n1_m1_388800_441600 0 2.888167e-07
I7169 n1_m1_388800_446400 0 3.690476e-08
I7170 n1_m1_388800_451200 0 8.658327e-08
I7171 n1_m1_388800_456000 0 8.617959e-08
I7172 n1_m1_388800_460800 0 2.504571e-07
I7173 n1_m1_388800_465600 0 7.432571e-08
I7174 n1_m1_388800_470400 0 1.093571e-07
I7175 n1_m1_388800_475200 0 1.829286e-07
I7176 n1_m1_388800_480000 0 1.763943e-07
I7177 n1_m1_388800_484800 0 4.780606e-07
I7178 n1_m1_388800_489600 0 5.151515e-07
I7179 n1_m1_388800_585600 0 7.133333e-09
I7180 n1_m1_393600_4800 0 9.876923e-09
I7181 n1_m1_393600_9600 0 4.741976e-07
I7182 n1_m1_393600_14400 0 1.460000e-07
I7183 n1_m1_393600_48000 0 5.253714e-08
I7184 n1_m1_393600_52800 0 1.413029e-07
I7185 n1_m1_393600_57600 0 9.469429e-08
I7186 n1_m1_393600_62400 0 7.188571e-08
I7187 n1_m1_393600_67200 0 8.569714e-08
I7188 n1_m1_393600_72000 0 1.560038e-07
I7189 n1_m1_393600_76800 0 1.182829e-07
I7190 n1_m1_393600_81600 0 1.097061e-07
I7191 n1_m1_393600_86400 0 1.079132e-07
I7192 n1_m1_393600_91200 0 4.360623e-07
I7193 n1_m1_393600_96000 0 3.511200e-07
I7194 n1_m1_393600_100800 0 6.946786e-08
I7195 n1_m1_393600_105600 0 1.722679e-07
I7196 n1_m1_393600_110400 0 1.251250e-07
I7197 n1_m1_393600_115200 0 1.178482e-07
I7198 n1_m1_393600_120000 0 6.512800e-07
I7199 n1_m1_393600_124800 0 9.567619e-08
I7200 n1_m1_393600_129600 0 8.984524e-08
I7201 n1_m1_393600_134400 0 9.046296e-08
I7202 n1_m1_393600_139200 0 8.038776e-08
I7203 n1_m1_393600_144000 0 1.884000e-07
I7204 n1_m1_393600_148800 0 3.688159e-07
I7205 n1_m1_393600_153600 0 2.018975e-06
I7206 n1_m1_393600_158400 0 4.023048e-07
I7207 n1_m1_393600_163200 0 1.013008e-07
I7208 n1_m1_393600_168000 0 1.269429e-07
I7209 n1_m1_393600_172800 0 5.203265e-08
I7210 n1_m1_393600_177600 0 1.875531e-07
I7211 n1_m1_393600_182400 0 1.439429e-07
I7212 n1_m1_393600_187200 0 2.046857e-07
I7213 n1_m1_393600_192000 0 4.231714e-07
I7214 n1_m1_393600_196800 0 1.567500e-07
I7215 n1_m1_393600_201600 0 2.494810e-07
I7216 n1_m1_393600_206400 0 3.287857e-07
I7217 n1_m1_393600_211200 0 1.677200e-07
I7218 n1_m1_393600_216000 0 2.106000e-07
I7219 n1_m1_393600_220800 0 1.611000e-07
I7220 n1_m1_393600_225600 0 2.506204e-07
I7221 n1_m1_393600_230400 0 8.852959e-08
I7222 n1_m1_393600_235200 0 1.178232e-07
I7223 n1_m1_393600_240000 0 1.979564e-06
I7224 n1_m1_393600_244800 0 1.999102e-07
I7225 n1_m1_393600_249600 0 1.592455e-07
I7226 n1_m1_393600_254400 0 9.647899e-07
I7227 n1_m1_393600_259200 0 1.190950e-06
I7228 n1_m1_393600_264000 0 2.709158e-06
I7229 n1_m1_393600_268800 0 6.217143e-07
I7230 n1_m1_393600_273600 0 1.000653e-06
I7231 n1_m1_393600_278400 0 2.026122e-06
I7232 n1_m1_393600_283200 0 1.929510e-06
I7233 n1_m1_393600_288000 0 2.309333e-06
I7234 n1_m1_393600_292800 0 4.652976e-06
I7235 n1_m1_393600_297600 0 3.712381e-06
I7236 n1_m1_393600_302400 0 1.310348e-06
I7237 n1_m1_393600_307200 0 1.058412e-07
I7238 n1_m1_393600_312000 0 3.235943e-07
I7239 n1_m1_393600_316800 0 2.603238e-07
I7240 n1_m1_393600_321600 0 1.353714e-07
I7241 n1_m1_393600_326400 0 1.586163e-07
I7242 n1_m1_393600_331200 0 1.861432e-07
I7243 n1_m1_393600_336000 0 3.331643e-07
I7244 n1_m1_393600_340800 0 1.074143e-07
I7245 n1_m1_393600_345600 0 4.910429e-07
I7246 n1_m1_393600_350400 0 1.764524e-07
I7247 n1_m1_393600_355200 0 1.985841e-07
I7248 n1_m1_393600_360000 0 1.046286e-06
I7249 n1_m1_393600_364800 0 1.997057e-07
I7250 n1_m1_393600_369600 0 1.112286e-07
I7251 n1_m1_393600_374400 0 9.180000e-08
I7252 n1_m1_393600_379200 0 1.277086e-07
I7253 n1_m1_393600_384000 0 1.465198e-07
I7254 n1_m1_393600_388800 0 1.620000e-08
I7255 n1_m1_393600_393600 0 2.865143e-07
I7256 n1_m1_393600_398400 0 1.281714e-07
I7257 n1_m1_393600_403200 0 6.411429e-08
I7258 n1_m1_393600_408000 0 2.100690e-07
I7259 n1_m1_393600_412800 0 5.887143e-08
I7260 n1_m1_393600_417600 0 3.597250e-07
I7261 n1_m1_393600_422400 0 1.223033e-07
I7262 n1_m1_393600_427200 0 1.473878e-07
I7263 n1_m1_393600_432000 0 1.511459e-07
I7264 n1_m1_393600_436800 0 7.708980e-08
I7265 n1_m1_393600_441600 0 1.361286e-07
I7266 n1_m1_393600_446400 0 1.426429e-07
I7267 n1_m1_393600_451200 0 1.277143e-07
I7268 n1_m1_393600_456000 0 1.745124e-07
I7269 n1_m1_393600_460800 0 1.152810e-07
I7270 n1_m1_393600_465600 0 1.558714e-07
I7271 n1_m1_393600_470400 0 1.125714e-07
I7272 n1_m1_393600_475200 0 9.650000e-08
I7273 n1_m1_393600_480000 0 4.176000e-08
I7274 n1_m1_393600_484800 0 1.236364e-07
I7275 n1_m1_393600_489600 0 3.090909e-07
I7276 n1_m1_393600_580800 0 2.461538e-07
I7277 n1_m1_393600_585600 0 1.681128e-07
I7278 n1_m1_398400_48000 0 5.284762e-07
I7279 n1_m1_398400_52800 0 5.870714e-08
I7280 n1_m1_398400_57600 0 8.539167e-08
I7281 n1_m1_398400_62400 0 3.657143e-08
I7282 n1_m1_398400_67200 0 9.537857e-08
I7283 n1_m1_398400_72000 0 1.313551e-07
I7284 n1_m1_398400_76800 0 1.266615e-07
I7285 n1_m1_398400_81600 0 1.760714e-07
I7286 n1_m1_398400_86400 0 1.405209e-07
I7287 n1_m1_398400_91200 0 8.352198e-08
I7288 n1_m1_398400_96000 0 1.412423e-07
I7289 n1_m1_398400_100800 0 7.709643e-08
I7290 n1_m1_398400_105600 0 1.191048e-07
I7291 n1_m1_398400_110400 0 2.607143e-08
I7292 n1_m1_398400_115200 0 1.189161e-07
I7293 n1_m1_398400_120000 0 3.231107e-07
I7294 n1_m1_398400_124800 0 3.775714e-07
I7295 n1_m1_398400_129600 0 1.262143e-07
I7296 n1_m1_398400_134400 0 9.896000e-07
I7297 n1_m1_398400_139200 0 3.807143e-08
I7298 n1_m1_398400_144000 0 1.252886e-06
I7299 n1_m1_398400_148800 0 3.893000e-06
I7300 n1_m1_398400_153600 0 2.907143e-06
I7301 n1_m1_398400_158400 0 4.611429e-08
I7302 n1_m1_398400_163200 0 1.135000e-07
I7303 n1_m1_398400_168000 0 3.128914e-07
I7304 n1_m1_398400_172800 0 5.638857e-08
I7305 n1_m1_398400_177600 0 2.208857e-07
I7306 n1_m1_398400_182400 0 1.497143e-07
I7307 n1_m1_398400_187200 0 1.357714e-07
I7308 n1_m1_398400_192000 0 1.067243e-07
I7309 n1_m1_398400_196800 0 2.079333e-07
I7310 n1_m1_398400_201600 0 1.355163e-07
I7311 n1_m1_398400_206400 0 5.947122e-07
I7312 n1_m1_398400_211200 0 1.909429e-07
I7313 n1_m1_398400_216000 0 1.098162e-06
I7314 n1_m1_398400_220800 0 2.494952e-07
I7315 n1_m1_398400_225600 0 1.370667e-07
I7316 n1_m1_398400_230400 0 2.092000e-07
I7317 n1_m1_398400_235200 0 3.454000e-07
I7318 n1_m1_398400_240000 0 6.849625e-07
I7319 n1_m1_398400_244800 0 6.246893e-07
I7320 n1_m1_398400_249600 0 9.661000e-07
I7321 n1_m1_398400_254400 0 1.357220e-06
I7322 n1_m1_398400_259200 0 1.229143e-06
I7323 n1_m1_398400_264000 0 2.535857e-06
I7324 n1_m1_398400_268800 0 1.740714e-06
I7325 n1_m1_398400_273600 0 3.555000e-06
I7326 n1_m1_398400_278400 0 2.567381e-06
I7327 n1_m1_398400_283200 0 1.463101e-06
I7328 n1_m1_398400_288000 0 2.027012e-06
I7329 n1_m1_398400_292800 0 1.948452e-06
I7330 n1_m1_398400_297600 0 1.414401e-06
I7331 n1_m1_398400_302400 0 1.918050e-07
I7332 n1_m1_398400_307200 0 9.237582e-07
I7333 n1_m1_398400_312000 0 3.466527e-07
I7334 n1_m1_398400_316800 0 7.438112e-08
I7335 n1_m1_398400_321600 0 9.707560e-07
I7336 n1_m1_398400_326400 0 1.732937e-07
I7337 n1_m1_398400_331200 0 9.130714e-07
I7338 n1_m1_398400_336000 0 1.700973e-06
I7339 n1_m1_398400_340800 0 1.332286e-07
I7340 n1_m1_398400_345600 0 6.762326e-07
I7341 n1_m1_398400_350400 0 3.437196e-06
I7342 n1_m1_398400_355200 0 4.570264e-06
I7343 n1_m1_398400_360000 0 3.062071e-07
I7344 n1_m1_398400_364800 0 1.261815e-07
I7345 n1_m1_398400_369600 0 1.765714e-07
I7346 n1_m1_398400_374400 0 1.740000e-08
I7347 n1_m1_398400_379200 0 7.984464e-08
I7348 n1_m1_398400_384000 0 1.052262e-07
I7349 n1_m1_398400_388800 0 4.293333e-07
I7350 n1_m1_398400_393600 0 2.121343e-06
I7351 n1_m1_398400_398400 0 1.147286e-07
I7352 n1_m1_398400_403200 0 5.819524e-08
I7353 n1_m1_398400_408000 0 4.066036e-07
I7354 n1_m1_398400_412800 0 7.342286e-07
I7355 n1_m1_398400_417600 0 9.632381e-07
I7356 n1_m1_398400_422400 0 1.439429e-07
I7357 n1_m1_398400_427200 0 6.078286e-07
I7358 n1_m1_398400_432000 0 1.952839e-07
I7359 n1_m1_398400_436800 0 3.852500e-08
I7360 n1_m1_398400_441600 0 1.261224e-07
I7361 n1_m1_398400_446400 0 6.619898e-08
I7362 n1_m1_398400_451200 0 3.256929e-07
I7363 n1_m1_398400_456000 0 1.590000e-07
I7364 n1_m1_398400_460800 0 1.116310e-07
I7365 n1_m1_398400_465600 0 3.086667e-07
I7366 n1_m1_398400_470400 0 9.874286e-08
I7367 n1_m1_398400_475200 0 1.241429e-07
I7368 n1_m1_398400_480000 0 1.554429e-07
I7369 n1_m1_398400_484800 0 2.204444e-07
I7370 n1_m1_398400_576000 0 2.254945e-08
I7371 n1_m1_398400_580800 0 5.359805e-07
I7372 n1_m1_398400_585600 0 2.718274e-07
I7373 n1_m1_403200_4800 0 1.975385e-08
I7374 n1_m1_403200_9600 0 3.644615e-08
I7375 n1_m1_403200_48000 0 8.972571e-08
I7376 n1_m1_403200_52800 0 1.538371e-07
I7377 n1_m1_403200_57600 0 6.413929e-08
I7378 n1_m1_403200_62400 0 7.532571e-08
I7379 n1_m1_403200_67200 0 5.868000e-08
I7380 n1_m1_403200_72000 0 2.726330e-07
I7381 n1_m1_403200_76800 0 1.059385e-07
I7382 n1_m1_403200_81600 0 9.639429e-07
I7383 n1_m1_403200_86400 0 4.103492e-07
I7384 n1_m1_403200_91200 0 1.040022e-07
I7385 n1_m1_403200_96000 0 8.258810e-08
I7386 n1_m1_403200_100800 0 3.458036e-08
I7387 n1_m1_403200_105600 0 2.862951e-07
I7388 n1_m1_403200_110400 0 2.934082e-07
I7389 n1_m1_403200_115200 0 1.416837e-07
I7390 n1_m1_403200_120000 0 8.337143e-08
I7391 n1_m1_403200_124800 0 1.766571e-06
I7392 n1_m1_403200_129600 0 1.123057e-06
I7393 n1_m1_403200_134400 0 8.504571e-07
I7394 n1_m1_403200_139200 0 4.364286e-08
I7395 n1_m1_403200_144000 0 1.033654e-06
I7396 n1_m1_403200_148800 0 2.203546e-06
I7397 n1_m1_403200_153600 0 2.164286e-06
I7398 n1_m1_403200_158400 0 8.794286e-08
I7399 n1_m1_403200_163200 0 1.373105e-07
I7400 n1_m1_403200_168000 0 2.262918e-07
I7401 n1_m1_403200_172800 0 1.481592e-07
I7402 n1_m1_403200_177600 0 1.656265e-07
I7403 n1_m1_403200_182400 0 1.765048e-07
I7404 n1_m1_403200_187200 0 9.027302e-08
I7405 n1_m1_403200_192000 0 1.234000e-07
I7406 n1_m1_403200_196800 0 2.271429e-07
I7407 n1_m1_403200_201600 0 2.767122e-07
I7408 n1_m1_403200_206400 0 1.983763e-07
I7409 n1_m1_403200_211200 0 1.937429e-07
I7410 n1_m1_403200_216000 0 4.937981e-07
I7411 n1_m1_403200_220800 0 2.955946e-07
I7412 n1_m1_403200_225600 0 1.566819e-07
I7413 n1_m1_403200_230400 0 2.085899e-07
I7414 n1_m1_403200_235200 0 5.680639e-07
I7415 n1_m1_403200_240000 0 6.471714e-07
I7416 n1_m1_403200_244800 0 9.203025e-07
I7417 n1_m1_403200_249600 0 1.477916e-06
I7418 n1_m1_403200_254400 0 1.518525e-06
I7419 n1_m1_403200_259200 0 1.990009e-06
I7420 n1_m1_403200_264000 0 2.471086e-06
I7421 n1_m1_403200_268800 0 1.909667e-06
I7422 n1_m1_403200_273600 0 3.652857e-07
I7423 n1_m1_403200_278400 0 9.485714e-07
I7424 n1_m1_403200_283200 0 1.987248e-06
I7425 n1_m1_403200_288000 0 3.470981e-06
I7426 n1_m1_403200_292800 0 1.388810e-06
I7427 n1_m1_403200_297600 0 1.344727e-06
I7428 n1_m1_403200_302400 0 1.449641e-06
I7429 n1_m1_403200_307200 0 1.292454e-06
I7430 n1_m1_403200_312000 0 1.316197e-06
I7431 n1_m1_403200_316800 0 1.047869e-07
I7432 n1_m1_403200_321600 0 3.404517e-07
I7433 n1_m1_403200_326400 0 2.459635e-07
I7434 n1_m1_403200_331200 0 9.973571e-08
I7435 n1_m1_403200_336000 0 1.543106e-07
I7436 n1_m1_403200_340800 0 7.308571e-08
I7437 n1_m1_403200_345600 0 1.131936e-06
I7438 n1_m1_403200_350400 0 9.822262e-07
I7439 n1_m1_403200_355200 0 8.440000e-07
I7440 n1_m1_403200_360000 0 3.311857e-07
I7441 n1_m1_403200_364800 0 8.344185e-07
I7442 n1_m1_403200_369600 0 1.390143e-07
I7443 n1_m1_403200_374400 0 7.460571e-08
I7444 n1_m1_403200_379200 0 3.474232e-07
I7445 n1_m1_403200_384000 0 2.796943e-07
I7446 n1_m1_403200_388800 0 5.770000e-08
I7447 n1_m1_403200_393600 0 1.121312e-06
I7448 n1_m1_403200_398400 0 6.694286e-08
I7449 n1_m1_403200_403200 0 9.626190e-08
I7450 n1_m1_403200_408000 0 1.883000e-07
I7451 n1_m1_403200_412800 0 2.029143e-07
I7452 n1_m1_403200_417600 0 6.035429e-07
I7453 n1_m1_403200_422400 0 1.855333e-07
I7454 n1_m1_403200_427200 0 5.988571e-07
I7455 n1_m1_403200_432000 0 3.299107e-07
I7456 n1_m1_403200_436800 0 1.292429e-07
I7457 n1_m1_403200_441600 0 1.349833e-07
I7458 n1_m1_403200_446400 0 7.342245e-08
I7459 n1_m1_403200_451200 0 7.887143e-08
I7460 n1_m1_403200_456000 0 7.109048e-08
I7461 n1_m1_403200_460800 0 4.970952e-07
I7462 n1_m1_403200_465600 0 3.134705e-07
I7463 n1_m1_403200_470400 0 5.741048e-08
I7464 n1_m1_403200_475200 0 4.825714e-08
I7465 n1_m1_403200_480000 0 1.930286e-08
I7466 n1_m1_403200_576000 0 2.255102e-08
I7467 n1_m1_403200_580800 0 6.618018e-07
I7468 n1_m1_403200_585600 0 3.418998e-07
I7469 n1_m1_408000_4800 0 9.876923e-09
I7470 n1_m1_408000_9600 0 1.532308e-08
I7471 n1_m1_408000_48000 0 2.633143e-08
I7472 n1_m1_408000_52800 0 1.037057e-07
I7473 n1_m1_408000_57600 0 5.287143e-08
I7474 n1_m1_408000_62400 0 1.174171e-07
I7475 n1_m1_408000_67200 0 6.489143e-08
I7476 n1_m1_408000_72000 0 3.629363e-07
I7477 n1_m1_408000_76800 0 1.526923e-07
I7478 n1_m1_408000_81600 0 3.540857e-07
I7479 n1_m1_408000_86400 0 1.848799e-07
I7480 n1_m1_408000_91200 0 1.042695e-07
I7481 n1_m1_408000_96000 0 2.451863e-07
I7482 n1_m1_408000_100800 0 2.316143e-07
I7483 n1_m1_408000_105600 0 5.174526e-07
I7484 n1_m1_408000_110400 0 4.845918e-07
I7485 n1_m1_408000_115200 0 4.350592e-07
I7486 n1_m1_408000_120000 0 6.336571e-07
I7487 n1_m1_408000_124800 0 3.466160e-06
I7488 n1_m1_408000_129600 0 1.688164e-06
I7489 n1_m1_408000_134400 0 2.097343e-06
I7490 n1_m1_408000_139200 0 4.325143e-06
I7491 n1_m1_408000_144000 0 4.474716e-06
I7492 n1_m1_408000_148800 0 2.537691e-06
I7493 n1_m1_408000_153600 0 1.224043e-06
I7494 n1_m1_408000_158400 0 3.555143e-07
I7495 n1_m1_408000_163200 0 1.832966e-07
I7496 n1_m1_408000_168000 0 1.767437e-06
I7497 n1_m1_408000_172800 0 2.410898e-06
I7498 n1_m1_408000_177600 0 8.653163e-07
I7499 n1_m1_408000_182400 0 4.063363e-07
I7500 n1_m1_408000_187200 0 1.834627e-07
I7501 n1_m1_408000_192000 0 3.591357e-07
I7502 n1_m1_408000_196800 0 5.385576e-07
I7503 n1_m1_408000_201600 0 6.061768e-07
I7504 n1_m1_408000_206400 0 2.375400e-07
I7505 n1_m1_408000_211200 0 4.690619e-07
I7506 n1_m1_408000_216000 0 5.236114e-07
I7507 n1_m1_408000_220800 0 8.296494e-07
I7508 n1_m1_408000_225600 0 1.490517e-06
I7509 n1_m1_408000_230400 0 9.374454e-07
I7510 n1_m1_408000_235200 0 6.533412e-07
I7511 n1_m1_408000_240000 0 2.040482e-06
I7512 n1_m1_408000_244800 0 2.065143e-06
I7513 n1_m1_408000_249600 0 2.279425e-06
I7514 n1_m1_408000_254400 0 2.260570e-06
I7515 n1_m1_408000_259200 0 2.054563e-06
I7516 n1_m1_408000_264000 0 2.644057e-06
I7517 n1_m1_408000_268800 0 3.671048e-06
I7518 n1_m1_408000_273600 0 2.713024e-06
I7519 n1_m1_408000_278400 0 1.462054e-06
I7520 n1_m1_408000_283200 0 1.607193e-06
I7521 n1_m1_408000_288000 0 2.254614e-06
I7522 n1_m1_408000_292800 0 1.428601e-06
I7523 n1_m1_408000_297600 0 1.176416e-06
I7524 n1_m1_408000_302400 0 2.297239e-06
I7525 n1_m1_408000_307200 0 1.778956e-06
I7526 n1_m1_408000_312000 0 1.907705e-06
I7527 n1_m1_408000_316800 0 2.074122e-07
I7528 n1_m1_408000_321600 0 1.009398e-06
I7529 n1_m1_408000_326400 0 4.414286e-08
I7530 n1_m1_408000_331200 0 1.029881e-06
I7531 n1_m1_408000_336000 0 3.935310e-07
I7532 n1_m1_408000_340800 0 8.176786e-08
I7533 n1_m1_408000_345600 0 5.470048e-07
I7534 n1_m1_408000_350400 0 9.818325e-07
I7535 n1_m1_408000_355200 0 1.884000e-07
I7536 n1_m1_408000_360000 0 1.719466e-07
I7537 n1_m1_408000_364800 0 3.301736e-06
I7538 n1_m1_408000_369600 0 5.543143e-07
I7539 n1_m1_408000_374400 0 5.390857e-08
I7540 n1_m1_408000_379200 0 5.776821e-07
I7541 n1_m1_408000_384000 0 9.320986e-07
I7542 n1_m1_408000_388800 0 3.800143e-07
I7543 n1_m1_408000_393600 0 2.359310e-07
I7544 n1_m1_408000_398400 0 1.004857e-07
I7545 n1_m1_408000_403200 0 5.895000e-07
I7546 n1_m1_408000_408000 0 1.370643e-07
I7547 n1_m1_408000_412800 0 3.205000e-07
I7548 n1_m1_408000_417600 0 1.288736e-06
I7549 n1_m1_408000_422400 0 8.865060e-08
I7550 n1_m1_408000_427200 0 1.358464e-07
I7551 n1_m1_408000_432000 0 2.123083e-07
I7552 n1_m1_408000_436800 0 2.147619e-07
I7553 n1_m1_408000_441600 0 3.055425e-07
I7554 n1_m1_408000_446400 0 2.065571e-07
I7555 n1_m1_408000_451200 0 2.532429e-07
I7556 n1_m1_408000_456000 0 2.412857e-07
I7557 n1_m1_408000_460800 0 1.272738e-07
I7558 n1_m1_408000_465600 0 1.056557e-07
I7559 n1_m1_408000_470400 0 1.441086e-07
I7560 n1_m1_408000_475200 0 1.186595e-07
I7561 n1_m1_408000_480000 0 2.876710e-07
I7562 n1_m1_408000_484800 0 1.885714e-08
I7563 n1_m1_408000_576000 0 1.734694e-09
I7564 n1_m1_408000_580800 0 3.263056e-07
I7565 n1_m1_408000_585600 0 2.059959e-07
I7566 n1_m1_412800_4800 0 9.876923e-09
I7567 n1_m1_412800_9600 0 5.772856e-07
I7568 n1_m1_412800_62400 0 3.771429e-09
I7569 n1_m1_412800_67200 0 2.828571e-09
I7570 n1_m1_412800_72000 0 1.940000e-07
I7571 n1_m1_412800_76800 0 5.245714e-08
I7572 n1_m1_412800_81600 0 1.415000e-07
I7573 n1_m1_412800_86400 0 7.619286e-08
I7574 n1_m1_412800_91200 0 2.160635e-08
I7575 n1_m1_412800_96000 0 1.994226e-08
I7576 n1_m1_412800_100800 0 4.836250e-08
I7577 n1_m1_412800_105600 0 8.789048e-08
I7578 n1_m1_412800_110400 0 8.047619e-08
I7579 n1_m1_412800_115200 0 8.169286e-07
I7580 n1_m1_412800_120000 0 1.227048e-06
I7581 n1_m1_412800_124800 0 2.107150e-06
I7582 n1_m1_412800_129600 0 8.326457e-07
I7583 n1_m1_412800_134400 0 1.118848e-06
I7584 n1_m1_412800_139200 0 1.967952e-06
I7585 n1_m1_412800_144000 0 1.962639e-06
I7586 n1_m1_412800_148800 0 1.504825e-06
I7587 n1_m1_412800_153600 0 2.533810e-06
I7588 n1_m1_412800_158400 0 1.065143e-06
I7589 n1_m1_412800_163200 0 8.913571e-08
I7590 n1_m1_412800_168000 0 1.611143e-07
I7591 n1_m1_412800_172800 0 2.534286e-07
I7592 n1_m1_412800_177600 0 1.866321e-07
I7593 n1_m1_412800_182400 0 2.248446e-07
I7594 n1_m1_412800_187200 0 1.222071e-07
I7595 n1_m1_412800_192000 0 5.074357e-07
I7596 n1_m1_412800_196800 0 9.027101e-08
I7597 n1_m1_412800_201600 0 1.901661e-07
I7598 n1_m1_412800_206400 0 2.832857e-08
I7599 n1_m1_412800_211200 0 7.916667e-08
I7600 n1_m1_412800_216000 0 2.213643e-07
I7601 n1_m1_412800_220800 0 1.415607e-07
I7602 n1_m1_412800_225600 0 9.544773e-07
I7603 n1_m1_412800_230400 0 2.656904e-07
I7604 n1_m1_412800_235200 0 7.364464e-07
I7605 n1_m1_412800_240000 0 1.083346e-06
I7606 n1_m1_412800_244800 0 1.910756e-06
I7607 n1_m1_412800_249600 0 2.369924e-06
I7608 n1_m1_412800_254400 0 6.193810e-07
I7609 n1_m1_412800_259200 0 1.971714e-06
I7610 n1_m1_412800_264000 0 2.203357e-06
I7611 n1_m1_412800_268800 0 4.646667e-07
I7612 n1_m1_412800_273600 0 8.451190e-07
I7613 n1_m1_412800_278400 0 1.327708e-06
I7614 n1_m1_412800_283200 0 1.111798e-06
I7615 n1_m1_412800_288000 0 2.688214e-06
I7616 n1_m1_412800_292800 0 2.930685e-06
I7617 n1_m1_412800_297600 0 1.710667e-06
I7618 n1_m1_412800_302400 0 1.390378e-06
I7619 n1_m1_412800_307200 0 9.105462e-07
I7620 n1_m1_412800_312000 0 1.234362e-06
I7621 n1_m1_412800_316800 0 9.150725e-07
I7622 n1_m1_412800_321600 0 2.884982e-07
I7623 n1_m1_412800_326400 0 6.132857e-08
I7624 n1_m1_412800_331200 0 1.212548e-07
I7625 n1_m1_412800_336000 0 4.421000e-07
I7626 n1_m1_412800_340800 0 1.834036e-07
I7627 n1_m1_412800_345600 0 3.550649e-07
I7628 n1_m1_412800_350400 0 1.299508e-07
I7629 n1_m1_412800_355200 0 8.168571e-08
I7630 n1_m1_412800_360000 0 3.049010e-07
I7631 n1_m1_412800_364800 0 6.677214e-07
I7632 n1_m1_412800_369600 0 6.228000e-07
I7633 n1_m1_412800_374400 0 8.975286e-07
I7634 n1_m1_412800_379200 0 6.717518e-07
I7635 n1_m1_412800_384000 0 9.762119e-07
I7636 n1_m1_412800_388800 0 5.928571e-07
I7637 n1_m1_412800_393600 0 1.803595e-07
I7638 n1_m1_412800_398400 0 2.065429e-07
I7639 n1_m1_412800_403200 0 1.757143e-07
I7640 n1_m1_412800_408000 0 2.230357e-07
I7641 n1_m1_412800_412800 0 2.451000e-07
I7642 n1_m1_412800_417600 0 2.032119e-07
I7643 n1_m1_412800_422400 0 4.598036e-08
I7644 n1_m1_412800_427200 0 9.616786e-08
I7645 n1_m1_412800_432000 0 1.770238e-07
I7646 n1_m1_412800_436800 0 1.263095e-07
I7647 n1_m1_412800_441600 0 8.650417e-08
I7648 n1_m1_412800_446400 0 3.700000e-08
I7649 n1_m1_412800_451200 0 1.331952e-07
I7650 n1_m1_412800_456000 0 1.365286e-07
I7651 n1_m1_412800_460800 0 1.123452e-07
I7652 n1_m1_412800_465600 0 8.655476e-08
I7653 n1_m1_412800_470400 0 9.252381e-08
I7654 n1_m1_412800_475200 0 1.105833e-07
I7655 n1_m1_412800_480000 0 6.353571e-08
I7656 n1_m1_412800_580800 0 2.141538e-08
I7657 n1_m1_412800_585600 0 3.478462e-08
I7658 n1_m1_417600_4800 0 4.356923e-08
I7659 n1_m1_417600_9600 0 8.015058e-07
I7660 n1_m1_417600_86400 0 8.331385e-07
I7661 n1_m1_417600_91200 0 6.262440e-08
I7662 n1_m1_417600_96000 0 1.091286e-07
I7663 n1_m1_417600_100800 0 2.130143e-07
I7664 n1_m1_417600_105600 0 3.554095e-07
I7665 n1_m1_417600_110400 0 4.049667e-07
I7666 n1_m1_417600_115200 0 4.092086e-07
I7667 n1_m1_417600_120000 0 1.322270e-06
I7668 n1_m1_417600_124800 0 1.032333e-07
I7669 n1_m1_417600_129600 0 4.550048e-07
I7670 n1_m1_417600_134400 0 3.552952e-07
I7671 n1_m1_417600_139200 0 7.906190e-07
I7672 n1_m1_417600_144000 0 1.526382e-06
I7673 n1_m1_417600_148800 0 1.535266e-06
I7674 n1_m1_417600_153600 0 2.199938e-06
I7675 n1_m1_417600_158400 0 2.702571e-07
I7676 n1_m1_417600_163200 0 1.296673e-07
I7677 n1_m1_417600_168000 0 5.126904e-06
I7678 n1_m1_417600_172800 0 1.227143e-07
I7679 n1_m1_417600_177600 0 1.959964e-07
I7680 n1_m1_417600_182400 0 2.439229e-07
I7681 n1_m1_417600_187200 0 1.939257e-07
I7682 n1_m1_417600_192000 0 9.057714e-07
I7683 n1_m1_417600_196800 0 2.984327e-07
I7684 n1_m1_417600_201600 0 3.882673e-07
I7685 n1_m1_417600_206400 0 1.106429e-07
I7686 n1_m1_417600_211200 0 2.490571e-07
I7687 n1_m1_417600_216000 0 4.793119e-07
I7688 n1_m1_417600_220800 0 1.026776e-07
I7689 n1_m1_417600_225600 0 2.180857e-07
I7690 n1_m1_417600_230400 0 3.268171e-07
I7691 n1_m1_417600_235200 0 4.294771e-07
I7692 n1_m1_417600_240000 0 8.528379e-06
I7693 n1_m1_417600_244800 0 2.497067e-06
I7694 n1_m1_417600_249600 0 3.625122e-06
I7695 n1_m1_417600_254400 0 2.623029e-06
I7696 n1_m1_417600_259200 0 2.264571e-06
I7697 n1_m1_417600_264000 0 4.816175e-06
I7698 n1_m1_417600_268800 0 3.031762e-06
I7699 n1_m1_417600_273600 0 3.518286e-06
I7700 n1_m1_417600_278400 0 2.105238e-06
I7701 n1_m1_417600_283200 0 2.444438e-06
I7702 n1_m1_417600_288000 0 2.383070e-06
I7703 n1_m1_417600_292800 0 1.280643e-05
I7704 n1_m1_417600_297600 0 6.194143e-06
I7705 n1_m1_417600_302400 0 1.775678e-06
I7706 n1_m1_417600_307200 0 1.378123e-06
I7707 n1_m1_417600_312000 0 1.767440e-06
I7708 n1_m1_417600_316800 0 1.334679e-06
I7709 n1_m1_417600_321600 0 9.988714e-07
I7710 n1_m1_417600_326400 0 2.329714e-07
I7711 n1_m1_417600_331200 0 2.548531e-07
I7712 n1_m1_417600_336000 0 8.335755e-07
I7713 n1_m1_417600_340800 0 1.508076e-06
I7714 n1_m1_417600_345600 0 1.062776e-06
I7715 n1_m1_417600_350400 0 5.039210e-07
I7716 n1_m1_417600_355200 0 1.357103e-06
I7717 n1_m1_417600_360000 0 2.998940e-07
I7718 n1_m1_417600_364800 0 1.571143e-07
I7719 n1_m1_417600_369600 0 1.784000e-07
I7720 n1_m1_417600_374400 0 3.004286e-08
I7721 n1_m1_417600_379200 0 8.258971e-07
I7722 n1_m1_417600_384000 0 4.533381e-07
I7723 n1_m1_417600_388800 0 2.677655e-07
I7724 n1_m1_417600_393600 0 9.497378e-07
I7725 n1_m1_417600_398400 0 5.786457e-07
I7726 n1_m1_417600_403200 0 3.829200e-07
I7727 n1_m1_417600_408000 0 2.532400e-07
I7728 n1_m1_417600_412800 0 5.567563e-07
I7729 n1_m1_417600_417600 0 3.638768e-07
I7730 n1_m1_417600_422400 0 4.107071e-07
I7731 n1_m1_417600_427200 0 4.728429e-07
I7732 n1_m1_417600_432000 0 3.281714e-07
I7733 n1_m1_417600_436800 0 6.247429e-07
I7734 n1_m1_417600_441600 0 3.869048e-07
I7735 n1_m1_417600_446400 0 3.450714e-07
I7736 n1_m1_417600_451200 0 2.574190e-07
I7737 n1_m1_417600_456000 0 5.025238e-07
I7738 n1_m1_417600_460800 0 1.748571e-07
I7739 n1_m1_417600_465600 0 3.292190e-07
I7740 n1_m1_417600_470400 0 1.828333e-07
I7741 n1_m1_417600_475200 0 1.941633e-07
I7742 n1_m1_417600_480000 0 9.027007e-08
I7743 n1_m1_422400_9600 0 3.118750e-07
I7744 n1_m1_422400_76800 0 1.422857e-08
I7745 n1_m1_422400_81600 0 1.428143e-07
I7746 n1_m1_422400_86400 0 1.352341e-07
I7747 n1_m1_422400_91200 0 2.313555e-07
I7748 n1_m1_422400_96000 0 1.172810e-07
I7749 n1_m1_422400_100800 0 7.510000e-08
I7750 n1_m1_422400_105600 0 1.062857e-08
I7751 n1_m1_422400_110400 0 4.434286e-08
I7752 n1_m1_422400_115200 0 3.733905e-08
I7753 n1_m1_422400_120000 0 3.624952e-08
I7754 n1_m1_422400_124800 0 4.424286e-08
I7755 n1_m1_422400_129600 0 1.712857e-07
I7756 n1_m1_422400_134400 0 4.945714e-08
I7757 n1_m1_422400_139200 0 2.707143e-08
I7758 n1_m1_422400_144000 0 3.902387e-07
I7759 n1_m1_422400_148800 0 5.901008e-07
I7760 n1_m1_422400_153600 0 6.836639e-07
I7761 n1_m1_422400_158400 0 5.118319e-07
I7762 n1_m1_422400_163200 0 9.159358e-08
I7763 n1_m1_422400_168000 0 4.413520e-08
I7764 n1_m1_422400_172800 0 4.133333e-08
I7765 n1_m1_422400_177600 0 1.068952e-07
I7766 n1_m1_422400_182400 0 4.798200e-07
I7767 n1_m1_422400_187200 0 9.789333e-08
I7768 n1_m1_422400_192000 0 1.133333e-09
I7769 n1_m1_422400_196800 0 2.232245e-07
I7770 n1_m1_422400_201600 0 8.351837e-08
I7771 n1_m1_422400_206400 0 3.871429e-08
I7772 n1_m1_422400_211200 0 8.722857e-08
I7773 n1_m1_422400_216000 0 4.740804e-07
I7774 n1_m1_422400_220800 0 2.490816e-08
I7775 n1_m1_422400_225600 0 1.922857e-07
I7776 n1_m1_422400_230400 0 2.257524e-07
I7777 n1_m1_422400_235200 0 8.342857e-08
I7778 n1_m1_422400_240000 0 3.148734e-06
I7779 n1_m1_422400_244800 0 3.579832e-07
I7780 n1_m1_422400_249600 0 2.505840e-07
I7781 n1_m1_422400_254400 0 2.651143e-07
I7782 n1_m1_422400_259200 0 7.200000e-07
I7783 n1_m1_422400_264000 0 1.044182e-06
I7784 n1_m1_422400_273600 0 1.451429e-07
I7785 n1_m1_422400_278400 0 6.200000e-07
I7786 n1_m1_422400_283200 0 4.417048e-07
I7787 n1_m1_422400_288000 0 9.503584e-07
I7788 n1_m1_422400_292800 0 3.669173e-07
I7789 n1_m1_422400_297600 0 2.972431e-07
I7790 n1_m1_422400_302400 0 3.524127e-07
I7791 n1_m1_422400_307200 0 6.866667e-07
I7792 n1_m1_422400_312000 0 1.147604e-06
I7793 n1_m1_422400_316800 0 1.123429e-07
I7794 n1_m1_422400_321600 0 4.668571e-08
I7795 n1_m1_422400_326400 0 4.237714e-07
I7796 n1_m1_422400_331200 0 3.716612e-07
I7797 n1_m1_422400_336000 0 1.743673e-07
I7798 n1_m1_422400_340800 0 2.243238e-07
I7799 n1_m1_422400_345600 0 1.415143e-07
I7800 n1_m1_422400_350400 0 2.608076e-07
I7801 n1_m1_422400_355200 0 2.588397e-07
I7802 n1_m1_422400_360000 0 3.039012e-07
I7803 n1_m1_422400_364800 0 6.005714e-08
I7804 n1_m1_422400_369600 0 1.034143e-07
I7805 n1_m1_422400_374400 0 3.362143e-08
I7806 n1_m1_422400_379200 0 5.396000e-08
I7807 n1_m1_422400_384000 0 8.780000e-08
I7808 n1_m1_422400_388800 0 2.605882e-07
I7809 n1_m1_422400_393600 0 1.079843e-06
I7810 n1_m1_422400_398400 0 3.007476e-07
I7811 n1_m1_422400_403200 0 1.186940e-07
I7812 n1_m1_422400_408000 0 1.119267e-07
I7813 n1_m1_422400_412800 0 1.710924e-07
I7814 n1_m1_422400_417600 0 2.081993e-07
I7815 n1_m1_422400_422400 0 7.117778e-08
I7816 n1_m1_422400_427200 0 3.766667e-07
I7817 n1_m1_422400_432000 0 6.280000e-08
I7818 n1_m1_422400_436800 0 3.615714e-08
I7819 n1_m1_422400_441600 0 8.167143e-08
I7820 n1_m1_422400_446400 0 3.571429e-08
I7821 n1_m1_422400_451200 0 4.435000e-08
I7822 n1_m1_422400_456000 0 3.568000e-07
I7823 n1_m1_422400_460800 0 1.467143e-07
I7824 n1_m1_422400_465600 0 5.882857e-08
I7825 n1_m1_422400_470400 0 5.373333e-08
I7826 n1_m1_422400_475200 0 7.562245e-08
I7827 n1_m1_422400_480000 0 6.106122e-09
I7828 n1_m1_427200_4800 0 3.746154e-08
I7829 n1_m1_427200_9600 0 3.121795e-09
I7830 n1_m1_427200_72000 0 6.405128e-09
I7831 n1_m1_427200_76800 0 7.042821e-08
I7832 n1_m1_427200_81600 0 1.020914e-07
I7833 n1_m1_427200_86400 0 1.484486e-07
I7834 n1_m1_427200_91200 0 6.133429e-08
I7835 n1_m1_427200_96000 0 8.206571e-08
I7836 n1_m1_427200_100800 0 5.249524e-08
I7837 n1_m1_427200_105600 0 2.121819e-07
I7838 n1_m1_427200_110400 0 1.276476e-07
I7839 n1_m1_427200_115200 0 1.098305e-07
I7840 n1_m1_427200_120000 0 1.193388e-07
I7841 n1_m1_427200_124800 0 6.668821e-08
I7842 n1_m1_427200_129600 0 2.144651e-07
I7843 n1_m1_427200_134400 0 3.941190e-08
I7844 n1_m1_427200_139200 0 8.579762e-08
I7845 n1_m1_427200_144000 0 8.024807e-07
I7846 n1_m1_427200_148800 0 1.219879e-06
I7847 n1_m1_427200_153600 0 2.130174e-06
I7848 n1_m1_427200_158400 0 8.476601e-07
I7849 n1_m1_427200_163200 0 1.744971e-07
I7850 n1_m1_427200_168000 0 4.446321e-07
I7851 n1_m1_427200_172800 0 1.081714e-07
I7852 n1_m1_427200_177600 0 9.384476e-08
I7853 n1_m1_427200_182400 0 1.206824e-07
I7854 n1_m1_427200_187200 0 1.211352e-07
I7855 n1_m1_427200_192000 0 1.670514e-07
I7856 n1_m1_427200_196800 0 6.261429e-08
I7857 n1_m1_427200_201600 0 2.299857e-07
I7858 n1_m1_427200_206400 0 4.331000e-07
I7859 n1_m1_427200_211200 0 2.311393e-07
I7860 n1_m1_427200_216000 0 1.370229e-07
I7861 n1_m1_427200_220800 0 1.284286e-07
I7862 n1_m1_427200_225600 0 1.722429e-07
I7863 n1_m1_427200_230400 0 1.010057e-07
I7864 n1_m1_427200_235200 0 1.196114e-07
I7865 n1_m1_427200_240000 0 1.840927e-07
I7866 n1_m1_427200_244800 0 1.645275e-06
I7867 n1_m1_427200_249600 0 1.367444e-06
I7868 n1_m1_427200_254400 0 3.630476e-07
I7869 n1_m1_427200_259200 0 9.494286e-07
I7870 n1_m1_427200_264000 0 2.312841e-06
I7871 n1_m1_427200_268800 0 1.235869e-06
I7872 n1_m1_427200_273600 0 1.902314e-06
I7873 n1_m1_427200_278400 0 6.107347e-07
I7874 n1_m1_427200_283200 0 3.386224e-07
I7875 n1_m1_427200_288000 0 7.442857e-07
I7876 n1_m1_427200_292800 0 1.335150e-06
I7877 n1_m1_427200_297600 0 2.305221e-06
I7878 n1_m1_427200_302400 0 3.682002e-07
I7879 n1_m1_427200_307200 0 1.204441e-06
I7880 n1_m1_427200_312000 0 2.074601e-06
I7881 n1_m1_427200_316800 0 1.170707e-07
I7882 n1_m1_427200_321600 0 3.002769e-07
I7883 n1_m1_427200_326400 0 1.134190e-07
I7884 n1_m1_427200_331200 0 1.582460e-07
I7885 n1_m1_427200_336000 0 2.880714e-07
I7886 n1_m1_427200_340800 0 2.556881e-07
I7887 n1_m1_427200_345600 0 4.785798e-07
I7888 n1_m1_427200_350400 0 1.714714e-07
I7889 n1_m1_427200_355200 0 1.349943e-07
I7890 n1_m1_427200_360000 0 4.185800e-07
I7891 n1_m1_427200_364800 0 6.124286e-08
I7892 n1_m1_427200_369600 0 2.118476e-07
I7893 n1_m1_427200_374400 0 1.903893e-07
I7894 n1_m1_427200_379200 0 1.422619e-07
I7895 n1_m1_427200_384000 0 1.593181e-07
I7896 n1_m1_427200_388800 0 2.353000e-07
I7897 n1_m1_427200_393600 0 7.372210e-07
I7898 n1_m1_427200_398400 0 6.407892e-07
I7899 n1_m1_427200_403200 0 7.978874e-07
I7900 n1_m1_427200_408000 0 5.161732e-07
I7901 n1_m1_427200_412800 0 1.099821e-07
I7902 n1_m1_427200_417600 0 3.073000e-07
I7903 n1_m1_427200_422400 0 9.406607e-08
I7904 n1_m1_427200_427200 0 1.318776e-07
I7905 n1_m1_427200_432000 0 1.594510e-07
I7906 n1_m1_427200_436800 0 1.197914e-07
I7907 n1_m1_427200_441600 0 3.084057e-07
I7908 n1_m1_427200_446400 0 7.221429e-08
I7909 n1_m1_427200_451200 0 1.382381e-07
I7910 n1_m1_427200_456000 0 2.754571e-07
I7911 n1_m1_427200_460800 0 5.324286e-08
I7912 n1_m1_427200_465600 0 2.063571e-07
I7913 n1_m1_427200_470400 0 8.518857e-08
I7914 n1_m1_427200_475200 0 8.585102e-08
I7915 n1_m1_427200_480000 0 2.471184e-08
I7916 n1_m1_432000_4800 0 1.975385e-08
I7917 n1_m1_432000_9600 0 4.154159e-07
I7918 n1_m1_432000_72000 0 4.108718e-08
I7919 n1_m1_432000_76800 0 1.212223e-07
I7920 n1_m1_432000_81600 0 2.379714e-07
I7921 n1_m1_432000_86400 0 2.321965e-07
I7922 n1_m1_432000_91200 0 2.112621e-07
I7923 n1_m1_432000_96000 0 1.796286e-07
I7924 n1_m1_432000_100800 0 1.480143e-07
I7925 n1_m1_432000_105600 0 2.533130e-07
I7926 n1_m1_432000_110400 0 3.883254e-07
I7927 n1_m1_432000_115200 0 1.596048e-07
I7928 n1_m1_432000_120000 0 1.197000e-07
I7929 n1_m1_432000_124800 0 1.757143e-07
I7930 n1_m1_432000_129600 0 2.753464e-07
I7931 n1_m1_432000_134400 0 1.882881e-07
I7932 n1_m1_432000_139200 0 1.808452e-07
I7933 n1_m1_432000_144000 0 1.177605e-06
I7934 n1_m1_432000_148800 0 1.771397e-06
I7935 n1_m1_432000_153600 0 2.245285e-06
I7936 n1_m1_432000_158400 0 1.032155e-06
I7937 n1_m1_432000_163200 0 4.313025e-06
I7938 n1_m1_432000_168000 0 9.942554e-07
I7939 n1_m1_432000_172800 0 2.781810e-07
I7940 n1_m1_432000_177600 0 1.406786e-07
I7941 n1_m1_432000_182400 0 1.439000e-07
I7942 n1_m1_432000_187200 0 1.752976e-07
I7943 n1_m1_432000_192000 0 2.332307e-07
I7944 n1_m1_432000_196800 0 1.979571e-07
I7945 n1_m1_432000_201600 0 3.674000e-07
I7946 n1_m1_432000_206400 0 9.954095e-07
I7947 n1_m1_432000_211200 0 2.197964e-07
I7948 n1_m1_432000_216000 0 5.440000e-07
I7949 n1_m1_432000_220800 0 3.824429e-07
I7950 n1_m1_432000_225600 0 3.495571e-07
I7951 n1_m1_432000_230400 0 7.676857e-07
I7952 n1_m1_432000_235200 0 6.927571e-07
I7953 n1_m1_432000_240000 0 3.285536e-07
I7954 n1_m1_432000_244800 0 1.456222e-06
I7955 n1_m1_432000_249600 0 2.960667e-06
I7956 n1_m1_432000_254400 0 2.857952e-06
I7957 n1_m1_432000_259200 0 3.008857e-06
I7958 n1_m1_432000_264000 0 5.593214e-06
I7959 n1_m1_432000_268800 0 2.247268e-06
I7960 n1_m1_432000_273600 0 2.103732e-06
I7961 n1_m1_432000_278400 0 1.754286e-06
I7962 n1_m1_432000_283200 0 4.956476e-06
I7963 n1_m1_432000_288000 0 3.718429e-06
I7964 n1_m1_432000_292800 0 2.069286e-06
I7965 n1_m1_432000_297600 0 2.797375e-06
I7966 n1_m1_432000_302400 0 2.435915e-06
I7967 n1_m1_432000_307200 0 1.562857e-06
I7968 n1_m1_432000_312000 0 9.246714e-07
I7969 n1_m1_432000_316800 0 2.863078e-07
I7970 n1_m1_432000_321600 0 1.447355e-06
I7971 n1_m1_432000_326400 0 1.920464e-07
I7972 n1_m1_432000_331200 0 2.058196e-07
I7973 n1_m1_432000_336000 0 4.232875e-07
I7974 n1_m1_432000_340800 0 1.539214e-07
I7975 n1_m1_432000_345600 0 2.124127e-06
I7976 n1_m1_432000_350400 0 2.753429e-07
I7977 n1_m1_432000_355200 0 9.708571e-07
I7978 n1_m1_432000_360000 0 2.538810e-07
I7979 n1_m1_432000_364800 0 1.519857e-07
I7980 n1_m1_432000_369600 0 3.305452e-07
I7981 n1_m1_432000_374400 0 9.625179e-08
I7982 n1_m1_432000_379200 0 2.011845e-07
I7983 n1_m1_432000_384000 0 1.626271e-07
I7984 n1_m1_432000_388800 0 1.660833e-06
I7985 n1_m1_432000_393600 0 1.991923e-06
I7986 n1_m1_432000_398400 0 2.695612e-06
I7987 n1_m1_432000_403200 0 1.519457e-06
I7988 n1_m1_432000_408000 0 1.627299e-06
I7989 n1_m1_432000_412800 0 5.486000e-07
I7990 n1_m1_432000_417600 0 1.815321e-07
I7991 n1_m1_432000_422400 0 6.835333e-07
I7992 n1_m1_432000_427200 0 2.520939e-07
I7993 n1_m1_432000_432000 0 4.952728e-07
I7994 n1_m1_432000_436800 0 3.875952e-07
I7995 n1_m1_432000_441600 0 3.078476e-07
I7996 n1_m1_432000_446400 0 7.979762e-08
I7997 n1_m1_432000_451200 0 6.600727e-07
I7998 n1_m1_432000_456000 0 1.609000e-07
I7999 n1_m1_432000_460800 0 1.784286e-07
I8000 n1_m1_432000_465600 0 2.470714e-07
I8001 n1_m1_432000_470400 0 5.988571e-08
I8002 n1_m1_432000_475200 0 1.634857e-07
I8003 n1_m1_432000_480000 0 2.836571e-08
I8004 n1_m1_436800_9600 0 6.170303e-07
I8005 n1_m1_436800_14400 0 6.215625e-07
I8006 n1_m1_436800_72000 0 5.436923e-08
I8007 n1_m1_436800_76800 0 1.620308e-07
I8008 n1_m1_436800_81600 0 6.304286e-08
I8009 n1_m1_436800_86400 0 1.151495e-07
I8010 n1_m1_436800_91200 0 8.245769e-08
I8011 n1_m1_436800_96000 0 8.884286e-08
I8012 n1_m1_436800_100800 0 1.116000e-07
I8013 n1_m1_436800_105600 0 1.661698e-07
I8014 n1_m1_436800_110400 0 1.810317e-07
I8015 n1_m1_436800_115200 0 5.668095e-08
I8016 n1_m1_436800_120000 0 3.344143e-07
I8017 n1_m1_436800_124800 0 2.247619e-07
I8018 n1_m1_436800_129600 0 1.708298e-07
I8019 n1_m1_436800_134400 0 1.511929e-07
I8020 n1_m1_436800_139200 0 6.885714e-08
I8021 n1_m1_436800_144000 0 3.649333e-07
I8022 n1_m1_436800_148800 0 4.166413e-07
I8023 n1_m1_436800_153600 0 7.315774e-07
I8024 n1_m1_436800_158400 0 3.580672e-07
I8025 n1_m1_436800_163200 0 3.086179e-07
I8026 n1_m1_436800_168000 0 9.564464e-08
I8027 n1_m1_436800_172800 0 9.861905e-08
I8028 n1_m1_436800_177600 0 2.612786e-07
I8029 n1_m1_436800_182400 0 7.200000e-08
I8030 n1_m1_436800_187200 0 2.062738e-07
I8031 n1_m1_436800_192000 0 1.232290e-07
I8032 n1_m1_436800_196800 0 1.429714e-07
I8033 n1_m1_436800_201600 0 1.249686e-07
I8034 n1_m1_436800_206400 0 1.110133e-07
I8035 n1_m1_436800_211200 0 2.266500e-07
I8036 n1_m1_436800_216000 0 1.106905e-07
I8037 n1_m1_436800_220800 0 1.874286e-08
I8038 n1_m1_436800_225600 0 2.537619e-07
I8039 n1_m1_436800_230400 0 1.729714e-07
I8040 n1_m1_436800_235200 0 7.860000e-08
I8041 n1_m1_436800_240000 0 1.684417e-07
I8042 n1_m1_436800_244800 0 1.000000e-06
I8043 n1_m1_436800_249600 0 1.185000e-06
I8044 n1_m1_436800_254400 0 1.815905e-06
I8045 n1_m1_436800_259200 0 7.014286e-07
I8046 n1_m1_436800_264000 0 1.036071e-06
I8047 n1_m1_436800_268800 0 4.955893e-07
I8048 n1_m1_436800_273600 0 1.766839e-06
I8049 n1_m1_436800_278400 0 1.878571e-06
I8050 n1_m1_436800_283200 0 3.683167e-06
I8051 n1_m1_436800_288000 0 3.574673e-06
I8052 n1_m1_436800_292800 0 1.076088e-06
I8053 n1_m1_436800_297600 0 2.303226e-06
I8054 n1_m1_436800_302400 0 7.566726e-07
I8055 n1_m1_436800_307200 0 9.500000e-07
I8056 n1_m1_436800_312000 0 5.231388e-07
I8057 n1_m1_436800_316800 0 1.067112e-07
I8058 n1_m1_436800_321600 0 1.442666e-06
I8059 n1_m1_436800_326400 0 3.863250e-07
I8060 n1_m1_436800_331200 0 1.119518e-07
I8061 n1_m1_436800_336000 0 6.679961e-07
I8062 n1_m1_436800_340800 0 2.720000e-08
I8063 n1_m1_436800_345600 0 2.832833e-07
I8064 n1_m1_436800_350400 0 1.553095e-07
I8065 n1_m1_436800_355200 0 2.267143e-07
I8066 n1_m1_436800_360000 0 1.531762e-07
I8067 n1_m1_436800_364800 0 6.697143e-08
I8068 n1_m1_436800_369600 0 4.119929e-07
I8069 n1_m1_436800_374400 0 4.233491e-07
I8070 n1_m1_436800_379200 0 2.706964e-07
I8071 n1_m1_436800_384000 0 7.984881e-07
I8072 n1_m1_436800_388800 0 1.789413e-06
I8073 n1_m1_436800_393600 0 2.356916e-06
I8074 n1_m1_436800_398400 0 5.646331e-07
I8075 n1_m1_436800_403200 0 1.432853e-06
I8076 n1_m1_436800_408000 0 8.365437e-07
I8077 n1_m1_436800_412800 0 2.409429e-07
I8078 n1_m1_436800_417600 0 1.295679e-07
I8079 n1_m1_436800_422400 0 1.609216e-07
I8080 n1_m1_436800_427200 0 7.024405e-07
I8081 n1_m1_436800_432000 0 3.155476e-07
I8082 n1_m1_436800_436800 0 3.764286e-08
I8083 n1_m1_436800_441600 0 2.135810e-07
I8084 n1_m1_436800_446400 0 3.086905e-08
I8085 n1_m1_436800_451200 0 1.628416e-07
I8086 n1_m1_436800_456000 0 1.639714e-07
I8087 n1_m1_436800_460800 0 1.767143e-07
I8088 n1_m1_436800_465600 0 7.737143e-08
I8089 n1_m1_436800_470400 0 4.740000e-08
I8090 n1_m1_436800_580800 0 4.758974e-09
I8091 n1_m1_436800_585600 0 2.974359e-09
I8092 n1_m1_441600_4800 0 6.609231e-08
I8093 n1_m1_441600_9600 0 1.079077e-07
I8094 n1_m1_441600_14400 0 6.774375e-07
I8095 n1_m1_441600_19200 0 1.720000e-07
I8096 n1_m1_441600_72000 0 9.742051e-08
I8097 n1_m1_441600_76800 0 1.501557e-07
I8098 n1_m1_441600_81600 0 1.685429e-07
I8099 n1_m1_441600_86400 0 4.054553e-07
I8100 n1_m1_441600_91200 0 1.365592e-06
I8101 n1_m1_441600_96000 0 2.409786e-07
I8102 n1_m1_441600_100800 0 1.845238e-07
I8103 n1_m1_441600_105600 0 4.520000e-07
I8104 n1_m1_441600_110400 0 4.236964e-07
I8105 n1_m1_441600_115200 0 1.822286e-07
I8106 n1_m1_441600_120000 0 2.567000e-07
I8107 n1_m1_441600_124800 0 3.860238e-07
I8108 n1_m1_441600_129600 0 8.280762e-07
I8109 n1_m1_441600_134400 0 8.724085e-07
I8110 n1_m1_441600_139200 0 1.130714e-07
I8111 n1_m1_441600_144000 0 3.205171e-06
I8112 n1_m1_441600_148800 0 5.852143e-07
I8113 n1_m1_441600_153600 0 6.562730e-07
I8114 n1_m1_441600_158400 0 5.361714e-07
I8115 n1_m1_441600_163200 0 2.150190e-06
I8116 n1_m1_441600_168000 0 1.825395e-06
I8117 n1_m1_441600_172800 0 1.522000e-07
I8118 n1_m1_441600_177600 0 2.974714e-07
I8119 n1_m1_441600_182400 0 9.548571e-08
I8120 n1_m1_441600_187200 0 1.144476e-07
I8121 n1_m1_441600_192000 0 2.212556e-07
I8122 n1_m1_441600_196800 0 1.440000e-07
I8123 n1_m1_441600_201600 0 1.306600e-07
I8124 n1_m1_441600_206400 0 1.274200e-07
I8125 n1_m1_441600_211200 0 3.351429e-07
I8126 n1_m1_441600_216000 0 2.303476e-07
I8127 n1_m1_441600_220800 0 5.154286e-08
I8128 n1_m1_441600_225600 0 1.940095e-07
I8129 n1_m1_441600_230400 0 1.305333e-07
I8130 n1_m1_441600_235200 0 1.108905e-07
I8131 n1_m1_441600_240000 0 1.077476e-06
I8132 n1_m1_441600_244800 0 2.869429e-06
I8133 n1_m1_441600_249600 0 4.221429e-06
I8134 n1_m1_441600_254400 0 3.645857e-06
I8135 n1_m1_441600_259200 0 3.000735e-06
I8136 n1_m1_441600_264000 0 5.128122e-06
I8137 n1_m1_441600_268800 0 3.212464e-06
I8138 n1_m1_441600_273600 0 4.281929e-06
I8139 n1_m1_441600_278400 0 1.360476e-06
I8140 n1_m1_441600_283200 0 3.893155e-06
I8141 n1_m1_441600_288000 0 2.598469e-06
I8142 n1_m1_441600_292800 0 2.674626e-06
I8143 n1_m1_441600_297600 0 6.600952e-06
I8144 n1_m1_441600_302400 0 2.487571e-06
I8145 n1_m1_441600_307200 0 2.381429e-06
I8146 n1_m1_441600_312000 0 2.993966e-06
I8147 n1_m1_441600_316800 0 1.996459e-07
I8148 n1_m1_441600_321600 0 1.068716e-06
I8149 n1_m1_441600_326400 0 2.261143e-07
I8150 n1_m1_441600_331200 0 3.646714e-07
I8151 n1_m1_441600_336000 0 1.133009e-06
I8152 n1_m1_441600_340800 0 2.198857e-07
I8153 n1_m1_441600_345600 0 3.798464e-07
I8154 n1_m1_441600_350400 0 5.622476e-07
I8155 n1_m1_441600_355200 0 5.161429e-07
I8156 n1_m1_441600_360000 0 2.723429e-07
I8157 n1_m1_441600_364800 0 2.275000e-07
I8158 n1_m1_441600_369600 0 5.525571e-07
I8159 n1_m1_441600_374400 0 3.834634e-07
I8160 n1_m1_441600_379200 0 2.212571e-07
I8161 n1_m1_441600_384000 0 1.961190e-06
I8162 n1_m1_441600_388800 0 1.362897e-06
I8163 n1_m1_441600_393600 0 3.061612e-06
I8164 n1_m1_441600_398400 0 2.062686e-06
I8165 n1_m1_441600_403200 0 1.428861e-06
I8166 n1_m1_441600_408000 0 6.026286e-07
I8167 n1_m1_441600_412800 0 8.017143e-08
I8168 n1_m1_441600_417600 0 3.965714e-07
I8169 n1_m1_441600_422400 0 2.929308e-07
I8170 n1_m1_441600_427200 0 3.635023e-07
I8171 n1_m1_441600_432000 0 3.279595e-07
I8172 n1_m1_441600_436800 0 1.435429e-07
I8173 n1_m1_441600_441600 0 1.887571e-07
I8174 n1_m1_441600_446400 0 2.627262e-07
I8175 n1_m1_441600_451200 0 5.799286e-07
I8176 n1_m1_441600_456000 0 1.714714e-07
I8177 n1_m1_441600_460800 0 1.397857e-07
I8178 n1_m1_441600_465600 0 2.282857e-08
I8179 n1_m1_441600_580800 0 3.696179e-07
I8180 n1_m1_441600_585600 0 2.524112e-07
I8181 n1_m1_446400_72000 0 3.117949e-07
I8182 n1_m1_446400_76800 0 1.088718e-07
I8183 n1_m1_446400_81600 0 3.239643e-07
I8184 n1_m1_446400_86400 0 5.094774e-07
I8185 n1_m1_446400_91200 0 4.351232e-07
I8186 n1_m1_446400_96000 0 2.399357e-07
I8187 n1_m1_446400_100800 0 3.462667e-07
I8188 n1_m1_446400_105600 0 5.677286e-07
I8189 n1_m1_446400_110400 0 1.170536e-07
I8190 n1_m1_446400_115200 0 1.044238e-07
I8191 n1_m1_446400_120000 0 2.281786e-07
I8192 n1_m1_446400_124800 0 1.420714e-07
I8193 n1_m1_446400_129600 0 3.064048e-07
I8194 n1_m1_446400_134400 0 6.816938e-07
I8195 n1_m1_446400_139200 0 1.415774e-07
I8196 n1_m1_446400_144000 0 2.685000e-07
I8197 n1_m1_446400_148800 0 1.087679e-07
I8198 n1_m1_446400_153600 0 3.770286e-07
I8199 n1_m1_446400_158400 0 7.637143e-07
I8200 n1_m1_446400_163200 0 3.001952e-06
I8201 n1_m1_446400_168000 0 5.658481e-07
I8202 n1_m1_446400_172800 0 9.094286e-08
I8203 n1_m1_446400_177600 0 1.661000e-07
I8204 n1_m1_446400_182400 0 2.561333e-07
I8205 n1_m1_446400_187200 0 2.151714e-07
I8206 n1_m1_446400_192000 0 1.882119e-07
I8207 n1_m1_446400_196800 0 2.007929e-07
I8208 n1_m1_446400_201600 0 2.055554e-07
I8209 n1_m1_446400_206400 0 5.528095e-08
I8210 n1_m1_446400_211200 0 1.047857e-07
I8211 n1_m1_446400_216000 0 1.859905e-07
I8212 n1_m1_446400_220800 0 1.242571e-07
I8213 n1_m1_446400_225600 0 3.176857e-07
I8214 n1_m1_446400_230400 0 1.346952e-07
I8215 n1_m1_446400_235200 0 1.870190e-07
I8216 n1_m1_446400_240000 0 6.174762e-07
I8217 n1_m1_446400_244800 0 2.775143e-06
I8218 n1_m1_446400_249600 0 2.962786e-06
I8219 n1_m1_446400_254400 0 2.051000e-06
I8220 n1_m1_446400_259200 0 4.414694e-06
I8221 n1_m1_446400_264000 0 3.144735e-06
I8222 n1_m1_446400_268800 0 1.837643e-06
I8223 n1_m1_446400_273600 0 3.186071e-06
I8224 n1_m1_446400_278400 0 1.072143e-06
I8225 n1_m1_446400_283200 0 1.485821e-06
I8226 n1_m1_446400_288000 0 2.584286e-06
I8227 n1_m1_446400_292800 0 3.395055e-06
I8228 n1_m1_446400_297600 0 3.311451e-06
I8229 n1_m1_446400_302400 0 2.277571e-06
I8230 n1_m1_446400_307200 0 1.445714e-06
I8231 n1_m1_446400_312000 0 1.286699e-06
I8232 n1_m1_446400_316800 0 7.906250e-08
I8233 n1_m1_446400_321600 0 3.954833e-07
I8234 n1_m1_446400_326400 0 1.662286e-07
I8235 n1_m1_446400_331200 0 7.920000e-08
I8236 n1_m1_446400_336000 0 8.230714e-08
I8237 n1_m1_446400_340800 0 6.262190e-07
I8238 n1_m1_446400_345600 0 4.084794e-07
I8239 n1_m1_446400_350400 0 4.389494e-07
I8240 n1_m1_446400_355200 0 2.454329e-07
I8241 n1_m1_446400_360000 0 5.788936e-07
I8242 n1_m1_446400_364800 0 2.168643e-07
I8243 n1_m1_446400_369600 0 2.236457e-07
I8244 n1_m1_446400_374400 0 1.859500e-07
I8245 n1_m1_446400_379200 0 8.056429e-07
I8246 n1_m1_446400_384000 0 1.896508e-06
I8247 n1_m1_446400_388800 0 4.552381e-07
I8248 n1_m1_446400_393600 0 2.331522e-06
I8249 n1_m1_446400_398400 0 7.002190e-07
I8250 n1_m1_446400_403200 0 2.064143e-07
I8251 n1_m1_446400_408000 0 4.818167e-07
I8252 n1_m1_446400_412800 0 5.160000e-08
I8253 n1_m1_446400_417600 0 3.438071e-07
I8254 n1_m1_446400_422400 0 7.772714e-07
I8255 n1_m1_446400_427200 0 2.578667e-06
I8256 n1_m1_446400_432000 0 2.162595e-07
I8257 n1_m1_446400_436800 0 2.379048e-08
I8258 n1_m1_446400_441600 0 2.307857e-07
I8259 n1_m1_446400_446400 0 1.430357e-07
I8260 n1_m1_446400_451200 0 5.713333e-07
I8261 n1_m1_446400_456000 0 1.777500e-07
I8262 n1_m1_446400_460800 0 2.656250e-07
I8263 n1_m1_446400_580800 0 2.415000e-07
I8264 n1_m1_446400_585600 0 2.020375e-07
I8265 n1_m1_451200_72000 0 4.314808e-08
I8266 n1_m1_451200_76800 0 6.142871e-08
I8267 n1_m1_451200_81600 0 1.031586e-07
I8268 n1_m1_451200_86400 0 5.842445e-08
I8269 n1_m1_451200_91200 0 3.083686e-08
I8270 n1_m1_451200_96000 0 1.229151e-07
I8271 n1_m1_451200_100800 0 6.741270e-08
I8272 n1_m1_451200_105600 0 2.141667e-07
I8273 n1_m1_451200_110400 0 2.056746e-08
I8274 n1_m1_451200_115200 0 1.134603e-08
I8275 n1_m1_451200_120000 0 9.459000e-08
I8276 n1_m1_451200_124800 0 2.421429e-08
I8277 n1_m1_451200_129600 0 3.990000e-08
I8278 n1_m1_451200_134400 0 2.242119e-07
I8279 n1_m1_451200_139200 0 3.907738e-08
I8280 n1_m1_451200_144000 0 2.285310e-07
I8281 n1_m1_451200_148800 0 7.950357e-08
I8282 n1_m1_451200_153600 0 7.967687e-08
I8283 n1_m1_451200_158400 0 5.628980e-08
I8284 n1_m1_451200_163200 0 1.111633e-08
I8285 n1_m1_451200_168000 0 3.635560e-07
I8286 n1_m1_451200_182400 0 2.816667e-08
I8287 n1_m1_451200_187200 0 3.968571e-08
I8288 n1_m1_451200_192000 0 1.525493e-07
I8289 n1_m1_451200_196800 0 1.044064e-07
I8290 n1_m1_451200_201600 0 3.043018e-07
I8291 n1_m1_451200_206400 0 1.693476e-07
I8292 n1_m1_451200_216000 0 8.881429e-08
I8293 n1_m1_451200_220800 0 7.631905e-08
I8294 n1_m1_451200_225600 0 2.004571e-07
I8295 n1_m1_451200_230400 0 2.554286e-08
I8296 n1_m1_451200_235200 0 1.265208e-07
I8297 n1_m1_451200_240000 0 5.476190e-07
I8298 n1_m1_451200_244800 0 1.679714e-06
I8299 n1_m1_451200_249600 0 1.650500e-06
I8300 n1_m1_451200_254400 0 1.019371e-06
I8301 n1_m1_451200_259200 0 7.008571e-07
I8302 n1_m1_451200_264000 0 1.397143e-06
I8303 n1_m1_451200_268800 0 1.939893e-06
I8304 n1_m1_451200_273600 0 9.488571e-07
I8305 n1_m1_451200_278400 0 6.253030e-07
I8306 n1_m1_451200_283200 0 2.078355e-07
I8307 n1_m1_451200_288000 0 9.215952e-07
I8308 n1_m1_451200_292800 0 2.057473e-06
I8309 n1_m1_451200_297600 0 1.327332e-06
I8310 n1_m1_451200_302400 0 6.069388e-08
I8311 n1_m1_451200_307200 0 1.503061e-07
I8312 n1_m1_451200_312000 0 3.737964e-07
I8313 n1_m1_451200_316800 0 6.224464e-08
I8314 n1_m1_451200_321600 0 1.161167e-07
I8315 n1_m1_451200_326400 0 9.899048e-08
I8316 n1_m1_451200_331200 0 6.367143e-08
I8317 n1_m1_451200_336000 0 1.885286e-07
I8318 n1_m1_451200_340800 0 6.520190e-07
I8319 n1_m1_451200_345600 0 1.204996e-07
I8320 n1_m1_451200_350400 0 3.067792e-07
I8321 n1_m1_451200_355200 0 6.054673e-08
I8322 n1_m1_451200_360000 0 6.939411e-07
I8323 n1_m1_451200_364800 0 1.823500e-07
I8324 n1_m1_451200_369600 0 1.119114e-07
I8325 n1_m1_451200_374400 0 3.004286e-08
I8326 n1_m1_451200_379200 0 1.455000e-07
I8327 n1_m1_451200_384000 0 1.046032e-06
I8328 n1_m1_451200_388800 0 2.845238e-07
I8329 n1_m1_451200_393600 0 1.572222e-06
I8330 n1_m1_451200_398400 0 1.061111e-06
I8331 n1_m1_451200_403200 0 1.583333e-07
I8332 n1_m1_451200_408000 0 1.741667e-07
I8333 n1_m1_451200_412800 0 1.555000e-07
I8334 n1_m1_451200_417600 0 6.084147e-07
I8335 n1_m1_451200_422400 0 2.292714e-07
I8336 n1_m1_451200_427200 0 1.541790e-06
I8337 n1_m1_451200_432000 0 2.880095e-07
I8338 n1_m1_451200_441600 0 4.542857e-08
I8339 n1_m1_451200_446400 0 1.878571e-07
I8340 n1_m1_451200_451200 0 4.172143e-07
I8341 n1_m1_451200_456000 0 2.060000e-07
I8342 n1_m1_451200_460800 0 2.656250e-07
I8343 n1_m1_451200_465600 0 2.756250e-07
I8344 n1_m1_451200_470400 0 4.593750e-08
I8345 n1_m1_456000_4800 0 1.975385e-08
I8346 n1_m1_456000_9600 0 1.646154e-09
I8347 n1_m1_456000_72000 0 9.914000e-08
I8348 n1_m1_456000_76800 0 1.540486e-07
I8349 n1_m1_456000_81600 0 3.043114e-07
I8350 n1_m1_456000_86400 0 4.142615e-08
I8351 n1_m1_456000_91200 0 7.630283e-08
I8352 n1_m1_456000_96000 0 6.068816e-08
I8353 n1_m1_456000_100800 0 6.273968e-08
I8354 n1_m1_456000_105600 0 6.683238e-08
I8355 n1_m1_456000_110400 0 1.904102e-07
I8356 n1_m1_456000_115200 0 9.533265e-08
I8357 n1_m1_456000_120000 0 2.988286e-07
I8358 n1_m1_456000_124800 0 2.022857e-07
I8359 n1_m1_456000_129600 0 2.110571e-07
I8360 n1_m1_456000_134400 0 2.660143e-07
I8361 n1_m1_456000_139200 0 1.375000e-07
I8362 n1_m1_456000_144000 0 1.363143e-07
I8363 n1_m1_456000_148800 0 7.257143e-08
I8364 n1_m1_456000_153600 0 1.197543e-07
I8365 n1_m1_456000_158400 0 8.284000e-07
I8366 n1_m1_456000_163200 0 2.760000e-07
I8367 n1_m1_456000_168000 0 2.030000e-07
I8368 n1_m1_456000_177600 0 1.128611e-06
I8369 n1_m1_456000_182400 0 2.136371e-06
I8370 n1_m1_456000_187200 0 6.484942e-07
I8371 n1_m1_456000_192000 0 5.452941e-07
I8372 n1_m1_456000_196800 0 7.218487e-07
I8373 n1_m1_456000_201600 0 9.779922e-07
I8374 n1_m1_456000_206400 0 7.635126e-08
I8375 n1_m1_456000_211200 0 5.357143e-07
I8376 n1_m1_456000_216000 0 1.032286e-06
I8377 n1_m1_456000_220800 0 1.922222e-06
I8378 n1_m1_456000_225600 0 1.120289e-06
I8379 n1_m1_456000_230400 0 2.563543e-06
I8380 n1_m1_456000_235200 0 8.259196e-07
I8381 n1_m1_456000_240000 0 2.154971e-06
I8382 n1_m1_456000_244800 0 1.775943e-06
I8383 n1_m1_456000_249600 0 3.689314e-06
I8384 n1_m1_456000_254400 0 3.075771e-06
I8385 n1_m1_456000_259200 0 1.012343e-06
I8386 n1_m1_456000_264000 0 2.019971e-06
I8387 n1_m1_456000_268800 0 3.058143e-06
I8388 n1_m1_456000_273600 0 2.324095e-06
I8389 n1_m1_456000_278400 0 1.690204e-06
I8390 n1_m1_456000_283200 0 2.043796e-06
I8391 n1_m1_456000_288000 0 2.776857e-06
I8392 n1_m1_456000_292800 0 1.288571e-06
I8393 n1_m1_456000_297600 0 8.815325e-07
I8394 n1_m1_456000_302400 0 5.641466e-07
I8395 n1_m1_456000_307200 0 1.684683e-06
I8396 n1_m1_456000_312000 0 1.874934e-06
I8397 n1_m1_456000_316800 0 5.871082e-07
I8398 n1_m1_456000_321600 0 9.412468e-07
I8399 n1_m1_456000_326400 0 1.611429e-07
I8400 n1_m1_456000_331200 0 6.711429e-07
I8401 n1_m1_456000_336000 0 1.851771e-07
I8402 n1_m1_456000_340800 0 1.936422e-07
I8403 n1_m1_456000_345600 0 1.634031e-06
I8404 n1_m1_456000_350400 0 3.882381e-06
I8405 n1_m1_456000_355200 0 1.961508e-06
I8406 n1_m1_456000_360000 0 6.376111e-07
I8407 n1_m1_456000_364800 0 8.924370e-07
I8408 n1_m1_456000_369600 0 1.291504e-06
I8409 n1_m1_456000_374400 0 5.023529e-07
I8410 n1_m1_456000_379200 0 1.001728e-06
I8411 n1_m1_456000_384000 0 1.113214e-06
I8412 n1_m1_456000_388800 0 5.604743e-07
I8413 n1_m1_456000_393600 0 3.970167e-06
I8414 n1_m1_456000_398400 0 6.883333e-07
I8415 n1_m1_456000_403200 0 1.567000e-07
I8416 n1_m1_456000_408000 0 6.744000e-07
I8417 n1_m1_456000_412800 0 1.260476e-06
I8418 n1_m1_456000_417600 0 2.222290e-06
I8419 n1_m1_456000_422400 0 2.968908e-07
I8420 n1_m1_456000_427200 0 9.650794e-07
I8421 n1_m1_456000_432000 0 7.238095e-07
I8422 n1_m1_456000_446400 0 1.397727e-07
I8423 n1_m1_456000_451200 0 9.539091e-07
I8424 n1_m1_456000_456000 0 4.295347e-07
I8425 n1_m1_456000_460800 0 5.111671e-07
I8426 n1_m1_456000_465600 0 4.212071e-07
I8427 n1_m1_456000_470400 0 3.281250e-08
I8428 n1_m1_456000_576000 0 8.440000e-07
I8429 n1_m1_456000_580800 0 1.665641e-08
I8430 n1_m1_456000_585600 0 3.181026e-08
I8431 n1_m1_460800_9600 0 5.392500e-07
I8432 n1_m1_460800_14400 0 2.426667e-07
I8433 n1_m1_460800_72000 0 1.234954e-07
I8434 n1_m1_460800_76800 0 9.668502e-08
I8435 n1_m1_460800_81600 0 9.766816e-08
I8436 n1_m1_460800_86400 0 2.088602e-07
I8437 n1_m1_460800_91200 0 7.394223e-08
I8438 n1_m1_460800_96000 0 1.526347e-07
I8439 n1_m1_460800_100800 0 1.828190e-07
I8440 n1_m1_460800_105600 0 3.614567e-07
I8441 n1_m1_460800_110400 0 1.995898e-07
I8442 n1_m1_460800_115200 0 5.714769e-07
I8443 n1_m1_460800_120000 0 1.168894e-06
I8444 n1_m1_460800_124800 0 4.355020e-07
I8445 n1_m1_460800_129600 0 1.783643e-07
I8446 n1_m1_460800_134400 0 5.051714e-07
I8447 n1_m1_460800_139200 0 2.535714e-07
I8448 n1_m1_460800_144000 0 3.020800e-07
I8449 n1_m1_460800_148800 0 1.884800e-07
I8450 n1_m1_460800_153600 0 2.390629e-07
I8451 n1_m1_460800_158400 0 1.481086e-07
I8452 n1_m1_460800_163200 0 1.992714e-07
I8453 n1_m1_460800_168000 0 4.714286e-07
I8454 n1_m1_460800_177600 0 8.235294e-07
I8455 n1_m1_460800_182400 0 1.216968e-06
I8456 n1_m1_460800_187200 0 1.741257e-06
I8457 n1_m1_460800_192000 0 2.523480e-06
I8458 n1_m1_460800_196800 0 1.101294e-06
I8459 n1_m1_460800_201600 0 4.019731e-07
I8460 n1_m1_460800_206400 0 4.590798e-07
I8461 n1_m1_460800_211200 0 4.889286e-07
I8462 n1_m1_460800_216000 0 7.342667e-07
I8463 n1_m1_460800_220800 0 1.547610e-06
I8464 n1_m1_460800_225600 0 7.473119e-07
I8465 n1_m1_460800_230400 0 1.107331e-06
I8466 n1_m1_460800_235200 0 6.921587e-07
I8467 n1_m1_460800_240000 0 1.343171e-06
I8468 n1_m1_460800_244800 0 1.034571e-06
I8469 n1_m1_460800_249600 0 1.847857e-06
I8470 n1_m1_460800_254400 0 1.173686e-06
I8471 n1_m1_460800_259200 0 2.558229e-06
I8472 n1_m1_460800_264000 0 4.375543e-06
I8473 n1_m1_460800_268800 0 2.365857e-06
I8474 n1_m1_460800_273600 0 1.271571e-06
I8475 n1_m1_460800_278400 0 1.033810e-06
I8476 n1_m1_460800_283200 0 1.481845e-06
I8477 n1_m1_460800_288000 0 1.522673e-06
I8478 n1_m1_460800_292800 0 1.165612e-06
I8479 n1_m1_460800_297600 0 3.928571e-07
I8480 n1_m1_460800_302400 0 1.015728e-06
I8481 n1_m1_460800_307200 0 1.504484e-06
I8482 n1_m1_460800_312000 0 1.225912e-06
I8483 n1_m1_460800_316800 0 7.671195e-07
I8484 n1_m1_460800_321600 0 1.361938e-06
I8485 n1_m1_460800_326400 0 4.789730e-07
I8486 n1_m1_460800_331200 0 9.867143e-07
I8487 n1_m1_460800_336000 0 1.201794e-06
I8488 n1_m1_460800_340800 0 7.388027e-07
I8489 n1_m1_460800_345600 0 1.044220e-06
I8490 n1_m1_460800_350400 0 1.269397e-06
I8491 n1_m1_460800_355200 0 2.122259e-06
I8492 n1_m1_460800_360000 0 1.617778e-06
I8493 n1_m1_460800_364800 0 1.084639e-06
I8494 n1_m1_460800_369600 0 1.601311e-06
I8495 n1_m1_460800_374400 0 4.421563e-07
I8496 n1_m1_460800_379200 0 7.443810e-07
I8497 n1_m1_460800_384000 0 7.207021e-07
I8498 n1_m1_460800_388800 0 1.147429e-07
I8499 n1_m1_460800_393600 0 2.103143e-07
I8500 n1_m1_460800_398400 0 2.637429e-07
I8501 n1_m1_460800_403200 0 2.463429e-07
I8502 n1_m1_460800_408000 0 2.882032e-07
I8503 n1_m1_460800_412800 0 1.009571e-06
I8504 n1_m1_460800_417600 0 2.687504e-06
I8505 n1_m1_460800_422400 0 9.802064e-07
I8506 n1_m1_460800_427200 0 6.689884e-07
I8507 n1_m1_460800_432000 0 7.646611e-07
I8508 n1_m1_460800_436800 0 3.045378e-07
I8509 n1_m1_460800_441600 0 4.114286e-09
I8510 n1_m1_460800_446400 0 1.028571e-08
I8511 n1_m1_460800_451200 0 2.303000e-07
I8512 n1_m1_460800_456000 0 4.735918e-08
I8513 n1_m1_460800_460800 0 6.654962e-07
I8514 n1_m1_460800_465600 0 2.188393e-07
I8515 n1_m1_460800_532800 0 4.393846e-06
I8516 n1_m1_460800_576000 0 5.054857e-07
I8517 n1_m1_460800_580800 0 1.491429e-08
I8518 n1_m1_460800_585600 0 2.140000e-08
I8519 n1_m1_465600_4800 0 1.318418e-07
I8520 n1_m1_465600_9600 0 1.669429e-06
I8521 n1_m1_465600_14400 0 3.033333e-08
I8522 n1_m1_465600_72000 0 7.647744e-08
I8523 n1_m1_465600_76800 0 1.655726e-07
I8524 n1_m1_465600_81600 0 1.081078e-06
I8525 n1_m1_465600_86400 0 3.934000e-07
I8526 n1_m1_465600_91200 0 3.243857e-07
I8527 n1_m1_465600_96000 0 3.024714e-07
I8528 n1_m1_465600_100800 0 1.243667e-07
I8529 n1_m1_465600_105600 0 3.388825e-07
I8530 n1_m1_465600_110400 0 4.940812e-07
I8531 n1_m1_465600_115200 0 6.044524e-07
I8532 n1_m1_465600_120000 0 2.673921e-07
I8533 n1_m1_465600_124800 0 4.044980e-07
I8534 n1_m1_465600_129600 0 2.767929e-07
I8535 n1_m1_465600_134400 0 2.671857e-07
I8536 n1_m1_465600_139200 0 7.671429e-08
I8537 n1_m1_465600_144000 0 1.303914e-07
I8538 n1_m1_465600_148800 0 7.647714e-08
I8539 n1_m1_465600_153600 0 1.528829e-07
I8540 n1_m1_465600_158400 0 2.285105e-07
I8541 n1_m1_465600_163200 0 2.603714e-07
I8542 n1_m1_465600_168000 0 1.055017e-06
I8543 n1_m1_465600_172800 0 6.925714e-07
I8544 n1_m1_465600_177600 0 1.992924e-06
I8545 n1_m1_465600_182400 0 2.943746e-06
I8546 n1_m1_465600_187200 0 2.833798e-06
I8547 n1_m1_465600_192000 0 1.602197e-06
I8548 n1_m1_465600_196800 0 1.425286e-06
I8549 n1_m1_465600_201600 0 1.453949e-06
I8550 n1_m1_465600_206400 0 5.625261e-07
I8551 n1_m1_465600_211200 0 9.771429e-08
I8552 n1_m1_465600_216000 0 1.661190e-07
I8553 n1_m1_465600_220800 0 9.666429e-08
I8554 n1_m1_465600_225600 0 1.274271e-06
I8555 n1_m1_465600_230400 0 6.252653e-08
I8556 n1_m1_465600_235200 0 1.146313e-06
I8557 n1_m1_465600_240000 0 3.303000e-07
I8558 n1_m1_465600_244800 0 5.088000e-07
I8559 n1_m1_465600_249600 0 6.206000e-06
I8560 n1_m1_465600_254400 0 3.746657e-06
I8561 n1_m1_465600_259200 0 1.416286e-06
I8562 n1_m1_465600_264000 0 2.656908e-06
I8563 n1_m1_465600_268800 0 1.937933e-06
I8564 n1_m1_465600_273600 0 2.832714e-06
I8565 n1_m1_465600_278400 0 1.665238e-06
I8566 n1_m1_465600_283200 0 2.214060e-06
I8567 n1_m1_465600_288000 0 3.099469e-06
I8568 n1_m1_465600_292800 0 3.028673e-06
I8569 n1_m1_465600_297600 0 4.723095e-06
I8570 n1_m1_465600_302400 0 2.368690e-06
I8571 n1_m1_465600_307200 0 1.636508e-06
I8572 n1_m1_465600_312000 0 4.251101e-06
I8573 n1_m1_465600_316800 0 6.562675e-07
I8574 n1_m1_465600_321600 0 1.760723e-06
I8575 n1_m1_465600_326400 0 1.367475e-06
I8576 n1_m1_465600_331200 0 6.227302e-07
I8577 n1_m1_465600_336000 0 2.922206e-06
I8578 n1_m1_465600_340800 0 1.178816e-06
I8579 n1_m1_465600_345600 0 1.057335e-06
I8580 n1_m1_465600_350400 0 1.444032e-06
I8581 n1_m1_465600_355200 0 9.839796e-07
I8582 n1_m1_465600_360000 0 1.545611e-06
I8583 n1_m1_465600_364800 0 1.271782e-06
I8584 n1_m1_465600_369600 0 1.442395e-06
I8585 n1_m1_465600_374400 0 1.121565e-06
I8586 n1_m1_465600_379200 0 1.015207e-06
I8587 n1_m1_465600_384000 0 5.923540e-07
I8588 n1_m1_465600_388800 0 7.290429e-07
I8589 n1_m1_465600_393600 0 2.219810e-07
I8590 n1_m1_465600_398400 0 1.212857e-07
I8591 n1_m1_465600_403200 0 1.277000e-07
I8592 n1_m1_465600_408000 0 5.415254e-07
I8593 n1_m1_465600_412800 0 6.094095e-07
I8594 n1_m1_465600_417600 0 1.650134e-06
I8595 n1_m1_465600_422400 0 7.190885e-07
I8596 n1_m1_465600_427200 0 6.495513e-07
I8597 n1_m1_465600_432000 0 1.556629e-06
I8598 n1_m1_465600_436800 0 1.951026e-06
I8599 n1_m1_465600_460800 0 1.457143e-07
I8600 n1_m1_465600_465600 0 5.828571e-08
I8601 n1_m1_465600_484800 0 1.553571e-07
I8602 n1_m1_465600_489600 0 3.883929e-07
I8603 n1_m1_465600_532800 0 2.746154e-06
I8604 n1_m1_465600_580800 0 5.207832e-07
I8605 n1_m1_465600_585600 0 3.254895e-07
I8606 n1_m1_470400_4800 0 7.446593e-08
I8607 n1_m1_470400_9600 0 5.523130e-07
I8608 n1_m1_470400_72000 0 8.242344e-08
I8609 n1_m1_470400_76800 0 7.014322e-08
I8610 n1_m1_470400_81600 0 1.659786e-07
I8611 n1_m1_470400_86400 0 4.923407e-08
I8612 n1_m1_470400_91200 0 1.694874e-07
I8613 n1_m1_470400_96000 0 1.945000e-07
I8614 n1_m1_470400_100800 0 2.161890e-07
I8615 n1_m1_470400_105600 0 1.268971e-06
I8616 n1_m1_470400_110400 0 9.029692e-07
I8617 n1_m1_470400_115200 0 3.760753e-07
I8618 n1_m1_470400_120000 0 3.150857e-07
I8619 n1_m1_470400_124800 0 1.342679e-07
I8620 n1_m1_470400_129600 0 1.348214e-07
I8621 n1_m1_470400_134400 0 2.693375e-07
I8622 n1_m1_470400_139200 0 7.410714e-08
I8623 n1_m1_470400_144000 0 2.009381e-07
I8624 n1_m1_470400_148800 0 5.708810e-08
I8625 n1_m1_470400_153600 0 1.024143e-07
I8626 n1_m1_470400_158400 0 9.515238e-08
I8627 n1_m1_470400_163200 0 6.109952e-07
I8628 n1_m1_470400_168000 0 1.498966e-06
I8629 n1_m1_470400_172800 0 1.162538e-06
I8630 n1_m1_470400_177600 0 1.289864e-06
I8631 n1_m1_470400_182400 0 9.311723e-07
I8632 n1_m1_470400_187200 0 1.765279e-06
I8633 n1_m1_470400_192000 0 9.526929e-07
I8634 n1_m1_470400_196800 0 4.825966e-07
I8635 n1_m1_470400_201600 0 2.643249e-07
I8636 n1_m1_470400_206400 0 7.960000e-08
I8637 n1_m1_470400_211200 0 4.593929e-07
I8638 n1_m1_470400_216000 0 1.509714e-07
I8639 n1_m1_470400_220800 0 8.391071e-08
I8640 n1_m1_470400_225600 0 1.527976e-07
I8641 n1_m1_470400_230400 0 1.469714e-07
I8642 n1_m1_470400_235200 0 9.881429e-08
I8643 n1_m1_470400_240000 0 3.192690e-07
I8644 n1_m1_470400_244800 0 8.955429e-07
I8645 n1_m1_470400_249600 0 3.171714e-06
I8646 n1_m1_470400_254400 0 8.328214e-07
I8647 n1_m1_470400_259200 0 1.195786e-06
I8648 n1_m1_470400_264000 0 1.185263e-06
I8649 n1_m1_470400_268800 0 3.071242e-06
I8650 n1_m1_470400_273600 0 2.166667e-06
I8651 n1_m1_470400_278400 0 5.046429e-07
I8652 n1_m1_470400_283200 0 1.098310e-06
I8653 n1_m1_470400_288000 0 8.088571e-07
I8654 n1_m1_470400_292800 0 1.193571e-06
I8655 n1_m1_470400_297600 0 1.775552e-06
I8656 n1_m1_470400_302400 0 1.297374e-06
I8657 n1_m1_470400_307200 0 1.392099e-06
I8658 n1_m1_470400_312000 0 1.820419e-06
I8659 n1_m1_470400_316800 0 6.768529e-07
I8660 n1_m1_470400_321600 0 1.328426e-06
I8661 n1_m1_470400_326400 0 1.802224e-06
I8662 n1_m1_470400_331200 0 1.141382e-06
I8663 n1_m1_470400_336000 0 6.359622e-07
I8664 n1_m1_470400_340800 0 7.199048e-07
I8665 n1_m1_470400_345600 0 9.676527e-07
I8666 n1_m1_470400_350400 0 5.865882e-07
I8667 n1_m1_470400_355200 0 2.722952e-06
I8668 n1_m1_470400_360000 0 1.074714e-06
I8669 n1_m1_470400_364800 0 6.329580e-07
I8670 n1_m1_470400_369600 0 7.940594e-07
I8671 n1_m1_470400_374400 0 4.709496e-07
I8672 n1_m1_470400_379200 0 6.008625e-07
I8673 n1_m1_470400_384000 0 4.505857e-07
I8674 n1_m1_470400_388800 0 2.398429e-07
I8675 n1_m1_470400_393600 0 1.153786e-07
I8676 n1_m1_470400_398400 0 7.341429e-08
I8677 n1_m1_470400_403200 0 5.215714e-08
I8678 n1_m1_470400_408000 0 6.212524e-07
I8679 n1_m1_470400_412800 0 9.562857e-08
I8680 n1_m1_470400_417600 0 2.720643e-07
I8681 n1_m1_470400_422400 0 3.904381e-07
I8682 n1_m1_470400_427200 0 1.831429e-07
I8683 n1_m1_470400_432000 0 1.290336e-06
I8684 n1_m1_470400_436800 0 2.259097e-07
I8685 n1_m1_470400_441600 0 1.690084e-07
I8686 n1_m1_470400_484800 0 2.940714e-07
I8687 n1_m1_470400_489600 0 4.401786e-07
I8688 n1_m1_470400_580800 0 8.253986e-08
I8689 n1_m1_470400_585600 0 1.204207e-07
I8690 n1_m1_475200_4800 0 2.963077e-08
I8691 n1_m1_475200_9600 0 3.726923e-08
I8692 n1_m1_475200_72000 0 1.346374e-08
I8693 n1_m1_475200_76800 0 9.290769e-08
I8694 n1_m1_475200_81600 0 1.669500e-07
I8695 n1_m1_475200_86400 0 2.911978e-08
I8696 n1_m1_475200_91200 0 7.873022e-08
I8697 n1_m1_475200_96000 0 1.941472e-06
I8698 n1_m1_475200_100800 0 4.217237e-07
I8699 n1_m1_475200_105600 0 9.144727e-07
I8700 n1_m1_475200_110400 0 6.625210e-07
I8701 n1_m1_475200_115200 0 1.311544e-06
I8702 n1_m1_475200_120000 0 6.891429e-08
I8703 n1_m1_475200_124800 0 1.250179e-07
I8704 n1_m1_475200_129600 0 1.778214e-07
I8705 n1_m1_475200_134400 0 9.680060e-08
I8706 n1_m1_475200_139200 0 1.284643e-07
I8707 n1_m1_475200_144000 0 4.694762e-07
I8708 n1_m1_475200_148800 0 1.258690e-07
I8709 n1_m1_475200_153600 0 1.722571e-07
I8710 n1_m1_475200_158400 0 3.073143e-07
I8711 n1_m1_475200_163200 0 8.794306e-07
I8712 n1_m1_475200_168000 0 1.089597e-06
I8713 n1_m1_475200_172800 0 9.813277e-07
I8714 n1_m1_475200_177600 0 1.100313e-06
I8715 n1_m1_475200_182400 0 5.175134e-07
I8716 n1_m1_475200_187200 0 3.936941e-07
I8717 n1_m1_475200_192000 0 7.238071e-07
I8718 n1_m1_475200_196800 0 4.938067e-07
I8719 n1_m1_475200_201600 0 6.909513e-07
I8720 n1_m1_475200_206400 0 5.857143e-08
I8721 n1_m1_475200_211200 0 5.007857e-08
I8722 n1_m1_475200_216000 0 9.557143e-08
I8723 n1_m1_475200_220800 0 3.629286e-08
I8724 n1_m1_475200_225600 0 2.961310e-07
I8725 n1_m1_475200_230400 0 4.848571e-08
I8726 n1_m1_475200_235200 0 7.390000e-08
I8727 n1_m1_475200_240000 0 1.490024e-07
I8728 n1_m1_475200_244800 0 3.674857e-07
I8729 n1_m1_475200_249600 0 5.220000e-07
I8730 n1_m1_475200_254400 0 4.817310e-07
I8731 n1_m1_475200_259200 0 2.195357e-06
I8732 n1_m1_475200_264000 0 1.809321e-06
I8733 n1_m1_475200_268800 0 3.878968e-07
I8734 n1_m1_475200_273600 0 1.367538e-06
I8735 n1_m1_475200_278400 0 1.912857e-07
I8736 n1_m1_475200_283200 0 4.287143e-08
I8737 n1_m1_475200_288000 0 3.113429e-07
I8738 n1_m1_475200_292800 0 3.396071e-07
I8739 n1_m1_475200_297600 0 1.656122e-06
I8740 n1_m1_475200_302400 0 1.851247e-06
I8741 n1_m1_475200_307200 0 1.438655e-06
I8742 n1_m1_475200_312000 0 5.531625e-07
I8743 n1_m1_475200_316800 0 6.931908e-07
I8744 n1_m1_475200_321600 0 1.320381e-06
I8745 n1_m1_475200_326400 0 1.525664e-06
I8746 n1_m1_475200_331200 0 5.884678e-07
I8747 n1_m1_475200_336000 0 7.739108e-07
I8748 n1_m1_475200_340800 0 1.015541e-06
I8749 n1_m1_475200_345600 0 1.489022e-06
I8750 n1_m1_475200_350400 0 7.729580e-07
I8751 n1_m1_475200_355200 0 2.897429e-06
I8752 n1_m1_475200_360000 0 6.295429e-07
I8753 n1_m1_475200_364800 0 3.698432e-07
I8754 n1_m1_475200_369600 0 6.152734e-07
I8755 n1_m1_475200_374400 0 1.200571e-07
I8756 n1_m1_475200_379200 0 9.658452e-08
I8757 n1_m1_475200_384000 0 1.435571e-07
I8758 n1_m1_475200_388800 0 2.311000e-07
I8759 n1_m1_475200_393600 0 2.174976e-07
I8760 n1_m1_475200_398400 0 2.431286e-07
I8761 n1_m1_475200_403200 0 4.142571e-07
I8762 n1_m1_475200_408000 0 7.201756e-07
I8763 n1_m1_475200_412800 0 2.559681e-07
I8764 n1_m1_475200_417600 0 9.776071e-07
I8765 n1_m1_475200_422400 0 5.953022e-07
I8766 n1_m1_475200_427200 0 6.980000e-07
I8767 n1_m1_475200_432000 0 4.990067e-07
I8768 n1_m1_475200_436800 0 5.857403e-07
I8769 n1_m1_475200_441600 0 1.113277e-06
I8770 n1_m1_475200_484800 0 3.600000e-08
I8771 n1_m1_475200_489600 0 9.000000e-08
I8772 n1_m1_475200_580800 0 8.861538e-09
I8773 n1_m1_475200_585600 0 1.623846e-08
I8774 n1_m1_480000_4800 0 8.449704e-08
I8775 n1_m1_480000_9600 0 8.088596e-07
I8776 n1_m1_480000_62400 0 2.614286e-07
I8777 n1_m1_480000_67200 0 1.960714e-07
I8778 n1_m1_480000_72000 0 4.888462e-08
I8779 n1_m1_480000_76800 0 1.632868e-07
I8780 n1_m1_480000_81600 0 3.005000e-07
I8781 n1_m1_480000_86400 0 4.983645e-07
I8782 n1_m1_480000_91200 0 2.441736e-07
I8783 n1_m1_480000_96000 0 6.826711e-07
I8784 n1_m1_480000_100800 0 8.380007e-07
I8785 n1_m1_480000_105600 0 9.474000e-07
I8786 n1_m1_480000_110400 0 1.305000e-06
I8787 n1_m1_480000_115200 0 1.532518e-06
I8788 n1_m1_480000_120000 0 2.064857e-07
I8789 n1_m1_480000_124800 0 7.739286e-08
I8790 n1_m1_480000_129600 0 1.138143e-07
I8791 n1_m1_480000_134400 0 4.603048e-07
I8792 n1_m1_480000_139200 0 1.836429e-07
I8793 n1_m1_480000_144000 0 3.679679e-07
I8794 n1_m1_480000_148800 0 7.657143e-08
I8795 n1_m1_480000_153600 0 1.213479e-06
I8796 n1_m1_480000_158400 0 7.352381e-07
I8797 n1_m1_480000_163200 0 1.158121e-06
I8798 n1_m1_480000_168000 0 1.973613e-06
I8799 n1_m1_480000_172800 0 1.289664e-06
I8800 n1_m1_480000_177600 0 2.605370e-06
I8801 n1_m1_480000_182400 0 1.071586e-06
I8802 n1_m1_480000_187200 0 5.621143e-07
I8803 n1_m1_480000_192000 0 4.515000e-07
I8804 n1_m1_480000_196800 0 4.882076e-07
I8805 n1_m1_480000_201600 0 6.245936e-07
I8806 n1_m1_480000_206400 0 2.551714e-07
I8807 n1_m1_480000_211200 0 4.507286e-07
I8808 n1_m1_480000_216000 0 7.168143e-07
I8809 n1_m1_480000_220800 0 3.050143e-07
I8810 n1_m1_480000_225600 0 1.503143e-07
I8811 n1_m1_480000_230400 0 1.418286e-07
I8812 n1_m1_480000_235200 0 1.610571e-07
I8813 n1_m1_480000_240000 0 2.142914e-07
I8814 n1_m1_480000_244800 0 1.700000e-07
I8815 n1_m1_480000_249600 0 2.113393e-07
I8816 n1_m1_480000_254400 0 2.092833e-07
I8817 n1_m1_480000_259200 0 3.512571e-07
I8818 n1_m1_480000_264000 0 1.028055e-06
I8819 n1_m1_480000_268800 0 3.712238e-07
I8820 n1_m1_480000_273600 0 1.105810e-06
I8821 n1_m1_480000_278400 0 1.969524e-07
I8822 n1_m1_480000_283200 0 9.174286e-08
I8823 n1_m1_480000_288000 0 1.739600e-06
I8824 n1_m1_480000_292800 0 1.021786e-07
I8825 n1_m1_480000_297600 0 1.341803e-06
I8826 n1_m1_480000_302400 0 3.007097e-06
I8827 n1_m1_480000_307200 0 1.073908e-06
I8828 n1_m1_480000_312000 0 1.479390e-06
I8829 n1_m1_480000_316800 0 4.211920e-07
I8830 n1_m1_480000_321600 0 8.514048e-07
I8831 n1_m1_480000_326400 0 4.024067e-07
I8832 n1_m1_480000_331200 0 3.735440e-07
I8833 n1_m1_480000_336000 0 1.594341e-06
I8834 n1_m1_480000_340800 0 1.244269e-06
I8835 n1_m1_480000_345600 0 1.442070e-06
I8836 n1_m1_480000_350400 0 9.753025e-07
I8837 n1_m1_480000_355200 0 1.040975e-06
I8838 n1_m1_480000_360000 0 1.551729e-06
I8839 n1_m1_480000_364800 0 1.944702e-07
I8840 n1_m1_480000_369600 0 2.943571e-07
I8841 n1_m1_480000_374400 0 3.225143e-07
I8842 n1_m1_480000_379200 0 1.015893e-07
I8843 n1_m1_480000_384000 0 3.487333e-07
I8844 n1_m1_480000_388800 0 3.880857e-07
I8845 n1_m1_480000_393600 0 3.140286e-07
I8846 n1_m1_480000_398400 0 1.303714e-07
I8847 n1_m1_480000_403200 0 3.367000e-07
I8848 n1_m1_480000_408000 0 5.030898e-07
I8849 n1_m1_480000_412800 0 3.585105e-07
I8850 n1_m1_480000_417600 0 2.342540e-07
I8851 n1_m1_480000_422400 0 2.449739e-07
I8852 n1_m1_480000_427200 0 4.242252e-07
I8853 n1_m1_480000_432000 0 1.161624e-06
I8854 n1_m1_480000_436800 0 1.877835e-06
I8855 n1_m1_480000_441600 0 1.965286e-06
I8856 n1_m1_480000_585600 0 1.426667e-08
I8857 n1_m1_484800_4800 0 9.217988e-08
I8858 n1_m1_484800_9600 0 4.658635e-07
I8859 n1_m1_484800_62400 0 2.962857e-07
I8860 n1_m1_484800_67200 0 2.222143e-07
I8861 n1_m1_484800_72000 0 3.507692e-08
I8862 n1_m1_484800_76800 0 2.809231e-07
I8863 n1_m1_484800_81600 0 1.647714e-07
I8864 n1_m1_484800_86400 0 5.723267e-08
I8865 n1_m1_484800_91200 0 9.285495e-08
I8866 n1_m1_484800_96000 0 8.511429e-08
I8867 n1_m1_484800_100800 0 4.993613e-07
I8868 n1_m1_484800_105600 0 6.450773e-07
I8869 n1_m1_484800_110400 0 4.437857e-07
I8870 n1_m1_484800_115200 0 5.034714e-07
I8871 n1_m1_484800_120000 0 6.312571e-07
I8872 n1_m1_484800_124800 0 3.375000e-08
I8873 n1_m1_484800_129600 0 2.878857e-07
I8874 n1_m1_484800_134400 0 1.289643e-07
I8875 n1_m1_484800_139200 0 1.413214e-07
I8876 n1_m1_484800_144000 0 2.755036e-07
I8877 n1_m1_484800_148800 0 6.737143e-08
I8878 n1_m1_484800_153600 0 3.918071e-07
I8879 n1_m1_484800_158400 0 2.339048e-07
I8880 n1_m1_484800_163200 0 9.349580e-07
I8881 n1_m1_484800_168000 0 1.065970e-06
I8882 n1_m1_484800_172800 0 5.712801e-07
I8883 n1_m1_484800_177600 0 7.950111e-07
I8884 n1_m1_484800_182400 0 3.550000e-07
I8885 n1_m1_484800_187200 0 1.904286e-07
I8886 n1_m1_484800_192000 0 1.956214e-07
I8887 n1_m1_484800_196800 0 1.201891e-07
I8888 n1_m1_484800_201600 0 6.242011e-07
I8889 n1_m1_484800_206400 0 7.135714e-08
I8890 n1_m1_484800_211200 0 2.246857e-07
I8891 n1_m1_484800_216000 0 2.826286e-07
I8892 n1_m1_484800_220800 0 4.498571e-08
I8893 n1_m1_484800_225600 0 2.170571e-07
I8894 n1_m1_484800_230400 0 1.213714e-07
I8895 n1_m1_484800_235200 0 4.997143e-08
I8896 n1_m1_484800_240000 0 9.762286e-08
I8897 n1_m1_484800_244800 0 1.478571e-07
I8898 n1_m1_484800_249600 0 1.076054e-07
I8899 n1_m1_484800_254400 0 1.110536e-07
I8900 n1_m1_484800_259200 0 2.599143e-07
I8901 n1_m1_484800_264000 0 2.467767e-06
I8902 n1_m1_484800_268800 0 3.329476e-07
I8903 n1_m1_484800_273600 0 1.531429e-07
I8904 n1_m1_484800_278400 0 5.535714e-08
I8905 n1_m1_484800_283200 0 7.115714e-08
I8906 n1_m1_484800_288000 0 2.831714e-07
I8907 n1_m1_484800_292800 0 1.862857e-07
I8908 n1_m1_484800_297600 0 4.694857e-07
I8909 n1_m1_484800_302400 0 4.954101e-07
I8910 n1_m1_484800_307200 0 5.087353e-07
I8911 n1_m1_484800_312000 0 6.958387e-07
I8912 n1_m1_484800_316800 0 1.195929e-07
I8913 n1_m1_484800_321600 0 6.613274e-08
I8914 n1_m1_484800_326400 0 2.542143e-08
I8915 n1_m1_484800_331200 0 1.389524e-07
I8916 n1_m1_484800_336000 0 6.376018e-07
I8917 n1_m1_484800_340800 0 5.062857e-07
I8918 n1_m1_484800_345600 0 9.984359e-07
I8919 n1_m1_484800_350400 0 2.341513e-07
I8920 n1_m1_484800_355200 0 4.364538e-07
I8921 n1_m1_484800_360000 0 1.073339e-07
I8922 n1_m1_484800_364800 0 9.102857e-08
I8923 n1_m1_484800_369600 0 2.138714e-07
I8924 n1_m1_484800_374400 0 1.541167e-07
I8925 n1_m1_484800_379200 0 2.111429e-08
I8926 n1_m1_484800_384000 0 2.209810e-07
I8927 n1_m1_484800_388800 0 1.167714e-07
I8928 n1_m1_484800_393600 0 7.917500e-08
I8929 n1_m1_484800_398400 0 1.672500e-07
I8930 n1_m1_484800_403200 0 9.590000e-08
I8931 n1_m1_484800_408000 0 1.909679e-07
I8932 n1_m1_484800_412800 0 1.144357e-07
I8933 n1_m1_484800_417600 0 1.419746e-07
I8934 n1_m1_484800_422400 0 3.416857e-07
I8935 n1_m1_484800_427200 0 1.478319e-07
I8936 n1_m1_484800_432000 0 3.156685e-07
I8937 n1_m1_484800_436800 0 9.577790e-07
I8938 n1_m1_484800_441600 0 1.128000e-07
I8939 n1_m1_484800_580800 0 2.953846e-07
I8940 n1_m1_484800_585600 0 1.846154e-07
I8941 n1_m1_489600_4800 0 6.692308e-08
I8942 n1_m1_489600_9600 0 4.037692e-08
I8943 n1_m1_489600_72000 0 6.226154e-08
I8944 n1_m1_489600_76800 0 3.738670e-07
I8945 n1_m1_489600_81600 0 2.111714e-07
I8946 n1_m1_489600_86400 0 1.099831e-07
I8947 n1_m1_489600_91200 0 1.129484e-07
I8948 n1_m1_489600_96000 0 4.868429e-07
I8949 n1_m1_489600_100800 0 1.489511e-06
I8950 n1_m1_489600_105600 0 1.025549e-06
I8951 n1_m1_489600_110400 0 1.367162e-06
I8952 n1_m1_489600_115200 0 8.308559e-07
I8953 n1_m1_489600_120000 0 9.805314e-07
I8954 n1_m1_489600_124800 0 6.480714e-07
I8955 n1_m1_489600_129600 0 4.000000e-07
I8956 n1_m1_489600_134400 0 5.615000e-08
I8957 n1_m1_489600_139200 0 2.298214e-07
I8958 n1_m1_489600_144000 0 4.688857e-07
I8959 n1_m1_489600_148800 0 5.573381e-07
I8960 n1_m1_489600_153600 0 1.055929e-06
I8961 n1_m1_489600_158400 0 5.000000e-07
I8962 n1_m1_489600_163200 0 3.899950e-07
I8963 n1_m1_489600_168000 0 1.438794e-06
I8964 n1_m1_489600_172800 0 8.502571e-07
I8965 n1_m1_489600_177600 0 3.479603e-07
I8966 n1_m1_489600_182400 0 5.043429e-07
I8967 n1_m1_489600_187200 0 4.120857e-07
I8968 n1_m1_489600_192000 0 1.060221e-06
I8969 n1_m1_489600_196800 0 4.371429e-07
I8970 n1_m1_489600_201600 0 1.924339e-07
I8971 n1_m1_489600_206400 0 1.310857e-07
I8972 n1_m1_489600_211200 0 1.881571e-07
I8973 n1_m1_489600_216000 0 2.022020e-07
I8974 n1_m1_489600_220800 0 1.686294e-07
I8975 n1_m1_489600_225600 0 4.351143e-07
I8976 n1_m1_489600_230400 0 2.404571e-07
I8977 n1_m1_489600_235200 0 7.680000e-08
I8978 n1_m1_489600_240000 0 7.241400e-07
I8979 n1_m1_489600_244800 0 2.310343e-07
I8980 n1_m1_489600_249600 0 2.328239e-07
I8981 n1_m1_489600_254400 0 8.484384e-07
I8982 n1_m1_489600_259200 0 2.591395e-06
I8983 n1_m1_489600_264000 0 2.102143e-06
I8984 n1_m1_489600_268800 0 9.573059e-07
I8985 n1_m1_489600_273600 0 6.341210e-07
I8986 n1_m1_489600_278400 0 1.900714e-07
I8987 n1_m1_489600_283200 0 3.036476e-07
I8988 n1_m1_489600_288000 0 1.191039e-06
I8989 n1_m1_489600_292800 0 2.849082e-07
I8990 n1_m1_489600_297600 0 1.060696e-06
I8991 n1_m1_489600_302400 0 1.666534e-06
I8992 n1_m1_489600_307200 0 2.901810e-07
I8993 n1_m1_489600_312000 0 4.163781e-07
I8994 n1_m1_489600_316800 0 1.199900e-06
I8995 n1_m1_489600_321600 0 3.081425e-07
I8996 n1_m1_489600_326400 0 9.603571e-08
I8997 n1_m1_489600_331200 0 3.326952e-07
I8998 n1_m1_489600_336000 0 6.345268e-07
I8999 n1_m1_489600_340800 0 4.377143e-07
I9000 n1_m1_489600_345600 0 1.001969e-06
I9001 n1_m1_489600_350400 0 6.671429e-08
I9002 n1_m1_489600_355200 0 1.377771e-07
I9003 n1_m1_489600_360000 0 2.550575e-07
I9004 n1_m1_489600_364800 0 1.520914e-07
I9005 n1_m1_489600_369600 0 4.668743e-07
I9006 n1_m1_489600_374400 0 2.079548e-07
I9007 n1_m1_489600_379200 0 1.012143e-07
I9008 n1_m1_489600_384000 0 3.883551e-07
I9009 n1_m1_489600_388800 0 2.782820e-07
I9010 n1_m1_489600_393600 0 4.248985e-07
I9011 n1_m1_489600_398400 0 7.288480e-07
I9012 n1_m1_489600_403200 0 1.805286e-07
I9013 n1_m1_489600_408000 0 2.089429e-07
I9014 n1_m1_489600_412800 0 2.468857e-07
I9015 n1_m1_489600_417600 0 1.065857e-06
I9016 n1_m1_489600_422400 0 8.452571e-07
I9017 n1_m1_489600_427200 0 1.421143e-07
I9018 n1_m1_489600_432000 0 5.392014e-07
I9019 n1_m1_489600_436800 0 3.437686e-07
I9020 n1_m1_489600_441600 0 2.498429e-07
I9021 n1_m1_489600_580800 0 5.669231e-07
I9022 n1_m1_489600_585600 0 5.457269e-07
I9023 n1_m1_494400_72000 0 7.030769e-09
I9024 n1_m1_494400_76800 0 5.703495e-08
I9025 n1_m1_494400_81600 0 7.411429e-08
I9026 n1_m1_494400_86400 0 9.880000e-08
I9027 n1_m1_494400_91200 0 9.391429e-08
I9028 n1_m1_494400_96000 0 1.158000e-07
I9029 n1_m1_494400_100800 0 1.327029e-07
I9030 n1_m1_494400_105600 0 2.411454e-07
I9031 n1_m1_494400_110400 0 3.119808e-07
I9032 n1_m1_494400_115200 0 8.792980e-08
I9033 n1_m1_494400_120000 0 3.483191e-07
I9034 n1_m1_494400_124800 0 7.636060e-07
I9035 n1_m1_494400_129600 0 2.668918e-07
I9036 n1_m1_494400_134400 0 1.092857e-07
I9037 n1_m1_494400_139200 0 1.132143e-07
I9038 n1_m1_494400_144000 0 1.652571e-07
I9039 n1_m1_494400_148800 0 3.015905e-07
I9040 n1_m1_494400_153600 0 1.813857e-07
I9041 n1_m1_494400_158400 0 1.588571e-08
I9042 n1_m1_494400_163200 0 1.710588e-06
I9043 n1_m1_494400_168000 0 1.330114e-07
I9044 n1_m1_494400_172800 0 2.113448e-07
I9045 n1_m1_494400_177600 0 4.511571e-07
I9046 n1_m1_494400_182400 0 1.299857e-07
I9047 n1_m1_494400_187200 0 9.088571e-08
I9048 n1_m1_494400_192000 0 1.285286e-07
I9049 n1_m1_494400_196800 0 4.085000e-07
I9050 n1_m1_494400_201600 0 8.832857e-08
I9051 n1_m1_494400_206400 0 1.180257e-06
I9052 n1_m1_494400_211200 0 1.172000e-07
I9053 n1_m1_494400_216000 0 1.909551e-07
I9054 n1_m1_494400_220800 0 1.845563e-07
I9055 n1_m1_494400_225600 0 6.833730e-07
I9056 n1_m1_494400_230400 0 2.250571e-07
I9057 n1_m1_494400_235200 0 5.122286e-08
I9058 n1_m1_494400_240000 0 1.674457e-07
I9059 n1_m1_494400_244800 0 8.908000e-08
I9060 n1_m1_494400_249600 0 7.624571e-08
I9061 n1_m1_494400_254400 0 3.281437e-07
I9062 n1_m1_494400_259200 0 1.610420e-06
I9063 n1_m1_494400_264000 0 8.465982e-07
I9064 n1_m1_494400_268800 0 2.929941e-07
I9065 n1_m1_494400_273600 0 1.894790e-07
I9066 n1_m1_494400_278400 0 2.639286e-07
I9067 n1_m1_494400_283200 0 9.157095e-07
I9068 n1_m1_494400_288000 0 1.838698e-07
I9069 n1_m1_494400_292800 0 1.126490e-07
I9070 n1_m1_494400_297600 0 2.171327e-07
I9071 n1_m1_494400_302400 0 3.020486e-07
I9072 n1_m1_494400_307200 0 6.212762e-07
I9073 n1_m1_494400_312000 0 2.187648e-07
I9074 n1_m1_494400_316800 0 8.115714e-08
I9075 n1_m1_494400_321600 0 1.315200e-07
I9076 n1_m1_494400_326400 0 1.846286e-07
I9077 n1_m1_494400_331200 0 1.053286e-07
I9078 n1_m1_494400_336000 0 3.839000e-07
I9079 n1_m1_494400_340800 0 1.462857e-07
I9080 n1_m1_494400_345600 0 1.063600e-07
I9081 n1_m1_494400_350400 0 3.098571e-08
I9082 n1_m1_494400_355200 0 6.202286e-08
I9083 n1_m1_494400_360000 0 5.266943e-07
I9084 n1_m1_494400_364800 0 1.635800e-07
I9085 n1_m1_494400_369600 0 1.504314e-07
I9086 n1_m1_494400_374400 0 8.801143e-08
I9087 n1_m1_494400_379200 0 8.581714e-08
I9088 n1_m1_494400_384000 0 1.208963e-07
I9089 n1_m1_494400_388800 0 1.788751e-07
I9090 n1_m1_494400_393600 0 2.137351e-07
I9091 n1_m1_494400_398400 0 1.245706e-07
I9092 n1_m1_494400_403200 0 9.461429e-08
I9093 n1_m1_494400_408000 0 3.569639e-07
I9094 n1_m1_494400_412800 0 5.683265e-07
I9095 n1_m1_494400_417600 0 3.361143e-07
I9096 n1_m1_494400_422400 0 3.914286e-08
I9097 n1_m1_494400_427200 0 3.845714e-08
I9098 n1_m1_494400_432000 0 2.027714e-07
I9099 n1_m1_494400_436800 0 1.078743e-07
I9100 n1_m1_494400_441600 0 6.300000e-08
I9101 n1_m1_494400_580800 0 3.730769e-07
I9102 n1_m1_494400_585600 0 2.331731e-07
I9103 n1_m1_499200_9600 0 7.710303e-07
I9104 n1_m1_499200_72000 0 9.600000e-09
I9105 n1_m1_499200_76800 0 9.066286e-08
I9106 n1_m1_499200_81600 0 9.404143e-08
I9107 n1_m1_499200_86400 0 1.491473e-07
I9108 n1_m1_499200_91200 0 1.435004e-07
I9109 n1_m1_499200_96000 0 1.672429e-07
I9110 n1_m1_499200_100800 0 6.776190e-08
I9111 n1_m1_499200_105600 0 8.260254e-08
I9112 n1_m1_499200_110400 0 1.697982e-07
I9113 n1_m1_499200_115200 0 1.023367e-07
I9114 n1_m1_499200_120000 0 1.301418e-07
I9115 n1_m1_499200_124800 0 3.102036e-07
I9116 n1_m1_499200_129600 0 6.075102e-08
I9117 n1_m1_499200_134400 0 2.422857e-08
I9118 n1_m1_499200_139200 0 3.091429e-07
I9119 n1_m1_499200_144000 0 2.980048e-07
I9120 n1_m1_499200_148800 0 1.584286e-08
I9121 n1_m1_499200_153600 0 7.240000e-08
I9122 n1_m1_499200_163200 0 3.436126e-06
I9123 n1_m1_499200_168000 0 6.543029e-07
I9124 n1_m1_499200_172800 0 1.012171e-07
I9125 n1_m1_499200_177600 0 1.173857e-07
I9126 n1_m1_499200_182400 0 2.954571e-07
I9127 n1_m1_499200_187200 0 2.653750e-07
I9128 n1_m1_499200_192000 0 2.628654e-07
I9129 n1_m1_499200_196800 0 1.306762e-07
I9130 n1_m1_499200_201600 0 2.356114e-07
I9131 n1_m1_499200_206400 0 2.061000e-07
I9132 n1_m1_499200_211200 0 5.219286e-07
I9133 n1_m1_499200_216000 0 5.670400e-07
I9134 n1_m1_499200_220800 0 2.123514e-07
I9135 n1_m1_499200_225600 0 1.006198e-06
I9136 n1_m1_499200_230400 0 2.300000e-07
I9137 n1_m1_499200_235200 0 8.577714e-08
I9138 n1_m1_499200_240000 0 3.058571e-07
I9139 n1_m1_499200_244800 0 1.407429e-07
I9140 n1_m1_499200_249600 0 9.165238e-08
I9141 n1_m1_499200_254400 0 1.097524e-07
I9142 n1_m1_499200_259200 0 1.536756e-06
I9143 n1_m1_499200_264000 0 1.421973e-06
I9144 n1_m1_499200_268800 0 1.059857e-07
I9145 n1_m1_499200_273600 0 1.563857e-07
I9146 n1_m1_499200_278400 0 1.160286e-07
I9147 n1_m1_499200_283200 0 6.998286e-08
I9148 n1_m1_499200_288000 0 1.252914e-07
I9149 n1_m1_499200_292800 0 4.258571e-08
I9150 n1_m1_499200_297600 0 9.760000e-08
I9151 n1_m1_499200_302400 0 7.143743e-07
I9152 n1_m1_499200_307200 0 4.893622e-07
I9153 n1_m1_499200_312000 0 2.685817e-07
I9154 n1_m1_499200_316800 0 6.982262e-08
I9155 n1_m1_499200_321600 0 2.774976e-07
I9156 n1_m1_499200_326400 0 1.314095e-07
I9157 n1_m1_499200_331200 0 3.523333e-08
I9158 n1_m1_499200_336000 0 1.849305e-07
I9159 n1_m1_499200_340800 0 1.626571e-07
I9160 n1_m1_499200_345600 0 1.640429e-07
I9161 n1_m1_499200_350400 0 8.513571e-08
I9162 n1_m1_499200_355200 0 5.338095e-08
I9163 n1_m1_499200_360000 0 3.576571e-07
I9164 n1_m1_499200_364800 0 1.182286e-07
I9165 n1_m1_499200_369600 0 1.521600e-07
I9166 n1_m1_499200_374400 0 2.579314e-07
I9167 n1_m1_499200_379200 0 7.784000e-08
I9168 n1_m1_499200_384000 0 2.066581e-07
I9169 n1_m1_499200_388800 0 8.052857e-08
I9170 n1_m1_499200_393600 0 1.379592e-07
I9171 n1_m1_499200_398400 0 3.943151e-07
I9172 n1_m1_499200_403200 0 2.660000e-07
I9173 n1_m1_499200_408000 0 4.385046e-07
I9174 n1_m1_499200_412800 0 1.369992e-07
I9175 n1_m1_499200_417600 0 8.171429e-08
I9176 n1_m1_499200_422400 0 1.323810e-07
I9177 n1_m1_499200_427200 0 9.057143e-08
I9178 n1_m1_499200_432000 0 1.314200e-07
I9179 n1_m1_499200_436800 0 5.215667e-07
I9180 n1_m1_499200_441600 0 5.664857e-07
I9181 n1_m1_499200_580800 0 1.492308e-07
I9182 n1_m1_499200_585600 0 1.443692e-07
I9183 n1_m1_504000_4800 0 1.975385e-08
I9184 n1_m1_504000_9600 0 7.320159e-07
I9185 n1_m1_504000_81600 0 1.573871e-07
I9186 n1_m1_504000_86400 0 1.362095e-07
I9187 n1_m1_504000_91200 0 1.408524e-07
I9188 n1_m1_504000_96000 0 2.318143e-07
I9189 n1_m1_504000_100800 0 2.525210e-07
I9190 n1_m1_504000_105600 0 1.857832e-07
I9191 n1_m1_504000_110400 0 2.227018e-07
I9192 n1_m1_504000_115200 0 1.218014e-07
I9193 n1_m1_504000_120000 0 2.229076e-07
I9194 n1_m1_504000_124800 0 3.227619e-07
I9195 n1_m1_504000_129600 0 2.227857e-07
I9196 n1_m1_504000_134400 0 1.889571e-07
I9197 n1_m1_504000_139200 0 1.027286e-06
I9198 n1_m1_504000_144000 0 7.159238e-07
I9199 n1_m1_504000_163200 0 4.687429e-07
I9200 n1_m1_504000_168000 0 5.987429e-07
I9201 n1_m1_504000_172800 0 2.741143e-07
I9202 n1_m1_504000_177600 0 3.898255e-07
I9203 n1_m1_504000_182400 0 1.059536e-07
I9204 n1_m1_504000_187200 0 2.079679e-07
I9205 n1_m1_504000_192000 0 2.837727e-07
I9206 n1_m1_504000_196800 0 9.609667e-07
I9207 n1_m1_504000_201600 0 3.241410e-07
I9208 n1_m1_504000_206400 0 1.042857e-07
I9209 n1_m1_504000_211200 0 1.150714e-07
I9210 n1_m1_504000_216000 0 2.573171e-07
I9211 n1_m1_504000_220800 0 2.251914e-07
I9212 n1_m1_504000_225600 0 3.152143e-07
I9213 n1_m1_504000_230400 0 1.768286e-07
I9214 n1_m1_504000_235200 0 1.697821e-07
I9215 n1_m1_504000_240000 0 1.761429e-07
I9216 n1_m1_504000_244800 0 2.298381e-07
I9217 n1_m1_504000_249600 0 1.829476e-07
I9218 n1_m1_504000_254400 0 1.407000e-07
I9219 n1_m1_504000_259200 0 3.215429e-07
I9220 n1_m1_504000_264000 0 3.003714e-06
I9221 n1_m1_504000_268800 0 5.693000e-07
I9222 n1_m1_504000_273600 0 2.005000e-07
I9223 n1_m1_504000_278400 0 1.391857e-07
I9224 n1_m1_504000_283200 0 1.722600e-07
I9225 n1_m1_504000_288000 0 2.421810e-07
I9226 n1_m1_504000_292800 0 1.832857e-07
I9227 n1_m1_504000_297600 0 6.358689e-07
I9228 n1_m1_504000_302400 0 6.204143e-07
I9229 n1_m1_504000_307200 0 1.956092e-07
I9230 n1_m1_504000_312000 0 9.818612e-07
I9231 n1_m1_504000_316800 0 5.195829e-07
I9232 n1_m1_504000_321600 0 6.929595e-07
I9233 n1_m1_504000_326400 0 6.227905e-07
I9234 n1_m1_504000_331200 0 8.077524e-07
I9235 n1_m1_504000_336000 0 5.216505e-07
I9236 n1_m1_504000_340800 0 1.291595e-07
I9237 n1_m1_504000_345600 0 8.913452e-08
I9238 n1_m1_504000_350400 0 8.491190e-08
I9239 n1_m1_504000_355200 0 1.290476e-08
I9240 n1_m1_504000_360000 0 7.983697e-07
I9241 n1_m1_504000_364800 0 1.118857e-07
I9242 n1_m1_504000_369600 0 1.952343e-07
I9243 n1_m1_504000_374400 0 1.389500e-07
I9244 n1_m1_504000_379200 0 1.131257e-06
I9245 n1_m1_504000_384000 0 1.577362e-06
I9246 n1_m1_504000_388800 0 2.502143e-07
I9247 n1_m1_504000_393600 0 2.418180e-07
I9248 n1_m1_504000_398400 0 2.293020e-07
I9249 n1_m1_504000_403200 0 2.166107e-07
I9250 n1_m1_504000_408000 0 4.882029e-07
I9251 n1_m1_504000_412800 0 1.457886e-07
I9252 n1_m1_504000_417600 0 4.419286e-07
I9253 n1_m1_504000_422400 0 3.928619e-07
I9254 n1_m1_504000_427200 0 2.085857e-07
I9255 n1_m1_504000_432000 0 2.450464e-07
I9256 n1_m1_504000_436800 0 1.672190e-07
I9257 n1_m1_504000_441600 0 2.809286e-07
I9258 n1_m1_504000_513600 0 2.175000e-07
I9259 n1_m1_504000_580800 0 2.141538e-08
I9260 n1_m1_504000_585600 0 3.478462e-08
I9261 n1_m1_508800_9600 0 4.497596e-07
I9262 n1_m1_508800_14400 0 2.790000e-07
I9263 n1_m1_508800_115200 0 6.240000e-09
I9264 n1_m1_508800_120000 0 7.200000e-09
I9265 n1_m1_508800_124800 0 6.371429e-08
I9266 n1_m1_508800_129600 0 1.828571e-08
I9267 n1_m1_508800_158400 0 2.657143e-08
I9268 n1_m1_508800_163200 0 1.367590e-07
I9269 n1_m1_508800_168000 0 6.365000e-08
I9270 n1_m1_508800_172800 0 1.614286e-08
I9271 n1_m1_508800_177600 0 4.555294e-07
I9272 n1_m1_508800_182400 0 5.618980e-08
I9273 n1_m1_508800_187200 0 2.101321e-07
I9274 n1_m1_508800_192000 0 6.452650e-08
I9275 n1_m1_508800_196800 0 3.567653e-07
I9276 n1_m1_508800_201600 0 6.321850e-08
I9277 n1_m1_508800_206400 0 1.278190e-08
I9278 n1_m1_508800_211200 0 1.382076e-07
I9279 n1_m1_508800_216000 0 1.670101e-07
I9280 n1_m1_508800_220800 0 1.635000e-08
I9281 n1_m1_508800_225600 0 4.996607e-08
I9282 n1_m1_508800_230400 0 3.984286e-08
I9283 n1_m1_508800_235200 0 8.061607e-08
I9284 n1_m1_508800_240000 0 1.074238e-07
I9285 n1_m1_508800_244800 0 3.994286e-08
I9286 n1_m1_508800_249600 0 4.447857e-08
I9287 n1_m1_508800_254400 0 1.254714e-07
I9288 n1_m1_508800_259200 0 1.057857e-07
I9289 n1_m1_508800_264000 0 3.963988e-07
I9290 n1_m1_508800_268800 0 8.027619e-08
I9291 n1_m1_508800_273600 0 8.698905e-08
I9292 n1_m1_508800_278400 0 8.065714e-08
I9293 n1_m1_508800_283200 0 6.831701e-08
I9294 n1_m1_508800_288000 0 5.895347e-08
I9295 n1_m1_508800_292800 0 1.501250e-08
I9296 n1_m1_508800_297600 0 2.557973e-07
I9297 n1_m1_508800_302400 0 9.439538e-08
I9298 n1_m1_508800_307200 0 3.950000e-08
I9299 n1_m1_508800_312000 0 2.411857e-07
I9300 n1_m1_508800_316800 0 1.310623e-07
I9301 n1_m1_508800_321600 0 1.075381e-07
I9302 n1_m1_508800_326400 0 1.316667e-07
I9303 n1_m1_508800_331200 0 5.289821e-08
I9304 n1_m1_508800_336000 0 6.725714e-08
I9305 n1_m1_508800_340800 0 1.684262e-07
I9306 n1_m1_508800_345600 0 6.345833e-08
I9307 n1_m1_508800_350400 0 3.450857e-08
I9308 n1_m1_508800_355200 0 6.771429e-09
I9309 n1_m1_508800_360000 0 1.247728e-06
I9310 n1_m1_508800_364800 0 3.616667e-09
I9311 n1_m1_508800_369600 0 4.117143e-08
I9312 n1_m1_508800_374400 0 5.632143e-08
I9313 n1_m1_508800_379200 0 6.426667e-08
I9314 n1_m1_508800_384000 0 1.407607e-07
I9315 n1_m1_508800_388800 0 4.671429e-08
I9316 n1_m1_508800_393600 0 9.392381e-08
I9317 n1_m1_508800_398400 0 3.411429e-08
I9318 n1_m1_508800_403200 0 4.015857e-08
I9319 n1_m1_508800_408000 0 1.425964e-07
I9320 n1_m1_508800_412800 0 4.754286e-08
I9321 n1_m1_508800_417600 0 2.629087e-07
I9322 n1_m1_508800_422400 0 3.648655e-07
I9323 n1_m1_508800_427200 0 2.507664e-07
I9324 n1_m1_508800_432000 0 9.030924e-08
I9325 n1_m1_508800_436800 0 2.035941e-08
I9326 n1_m1_508800_441600 0 3.831429e-08
I9327 n1_m1_508800_508800 0 8.925000e-08
I9328 n1_m1_508800_513600 0 3.773750e-07
I9329 n1_m1_513600_4800 0 1.975385e-08
I9330 n1_m1_513600_9600 0 6.443865e-07
I9331 n1_m1_513600_96000 0 5.945455e-07
I9332 n1_m1_513600_120000 0 5.971429e-09
I9333 n1_m1_513600_124800 0 1.492857e-08
I9334 n1_m1_513600_163200 0 1.437381e-07
I9335 n1_m1_513600_168000 0 1.410714e-07
I9336 n1_m1_513600_172800 0 1.704952e-07
I9337 n1_m1_513600_177600 0 5.688933e-07
I9338 n1_m1_513600_182400 0 2.047816e-07
I9339 n1_m1_513600_187200 0 3.928041e-07
I9340 n1_m1_513600_192000 0 7.292048e-07
I9341 n1_m1_513600_196800 0 1.045276e-07
I9342 n1_m1_513600_201600 0 2.600939e-07
I9343 n1_m1_513600_206400 0 1.804429e-07
I9344 n1_m1_513600_211200 0 1.118571e-07
I9345 n1_m1_513600_216000 0 2.798310e-07
I9346 n1_m1_513600_220800 0 1.426286e-07
I9347 n1_m1_513600_225600 0 4.223720e-07
I9348 n1_m1_513600_230400 0 1.827857e-07
I9349 n1_m1_513600_235200 0 2.019839e-07
I9350 n1_m1_513600_240000 0 1.743143e-07
I9351 n1_m1_513600_244800 0 7.226000e-07
I9352 n1_m1_513600_249600 0 4.018643e-07
I9353 n1_m1_513600_254400 0 1.591190e-07
I9354 n1_m1_513600_259200 0 2.935714e-08
I9355 n1_m1_513600_264000 0 6.039750e-07
I9356 n1_m1_513600_268800 0 3.885734e-07
I9357 n1_m1_513600_273600 0 1.187923e-06
I9358 n1_m1_513600_278400 0 2.161286e-07
I9359 n1_m1_513600_283200 0 1.117185e-07
I9360 n1_m1_513600_288000 0 2.159571e-07
I9361 n1_m1_513600_292800 0 1.243750e-07
I9362 n1_m1_513600_297600 0 1.233595e-07
I9363 n1_m1_513600_302400 0 1.550190e-07
I9364 n1_m1_513600_307200 0 1.645000e-07
I9365 n1_m1_513600_312000 0 1.688000e-07
I9366 n1_m1_513600_316800 0 2.775524e-07
I9367 n1_m1_513600_321600 0 3.364940e-07
I9368 n1_m1_513600_326400 0 7.261905e-08
I9369 n1_m1_513600_331200 0 2.242571e-07
I9370 n1_m1_513600_336000 0 2.646595e-07
I9371 n1_m1_513600_340800 0 2.305714e-07
I9372 n1_m1_513600_345600 0 1.733500e-07
I9373 n1_m1_513600_350400 0 9.411429e-08
I9374 n1_m1_513600_355200 0 2.408571e-08
I9375 n1_m1_513600_360000 0 9.447750e-07
I9376 n1_m1_513600_364800 0 2.099833e-07
I9377 n1_m1_513600_369600 0 1.223024e-07
I9378 n1_m1_513600_374400 0 1.274643e-07
I9379 n1_m1_513600_379200 0 1.775000e-07
I9380 n1_m1_513600_384000 0 2.418250e-07
I9381 n1_m1_513600_388800 0 1.740000e-07
I9382 n1_m1_513600_393600 0 2.302286e-07
I9383 n1_m1_513600_398400 0 3.828286e-07
I9384 n1_m1_513600_403200 0 2.049429e-07
I9385 n1_m1_513600_408000 0 3.156143e-07
I9386 n1_m1_513600_412800 0 2.802367e-07
I9387 n1_m1_513600_417600 0 2.098913e-07
I9388 n1_m1_513600_422400 0 1.191095e-07
I9389 n1_m1_513600_427200 0 2.533109e-07
I9390 n1_m1_513600_432000 0 2.041483e-07
I9391 n1_m1_513600_436800 0 2.275041e-07
I9392 n1_m1_513600_441600 0 1.996571e-07
I9393 n1_m1_513600_446400 0 7.414286e-08
I9394 n1_m1_513600_451200 0 2.965714e-08
I9395 n1_m1_513600_465600 0 3.310000e-07
I9396 n1_m1_513600_513600 0 4.809000e-07
I9397 n1_m1_513600_528000 0 1.220048e-06
I9398 n1_m1_513600_580800 0 2.000000e-07
I9399 n1_m1_513600_585600 0 1.642333e-07
I9400 n1_m1_518400_4800 0 4.643077e-08
I9401 n1_m1_518400_9600 0 3.869231e-09
I9402 n1_m1_518400_96000 0 3.864545e-07
I9403 n1_m1_518400_163200 0 1.364667e-07
I9404 n1_m1_518400_168000 0 1.789667e-07
I9405 n1_m1_518400_172800 0 5.593333e-08
I9406 n1_m1_518400_177600 0 2.808667e-07
I9407 n1_m1_518400_182400 0 9.412857e-08
I9408 n1_m1_518400_187200 0 1.135714e-07
I9409 n1_m1_518400_192000 0 7.390000e-08
I9410 n1_m1_518400_196800 0 9.292143e-08
I9411 n1_m1_518400_201600 0 2.857810e-07
I9412 n1_m1_518400_206400 0 2.598810e-07
I9413 n1_m1_518400_211200 0 2.654286e-07
I9414 n1_m1_518400_216000 0 1.299064e-06
I9415 n1_m1_518400_220800 0 1.134714e-08
I9416 n1_m1_518400_225600 0 1.376048e-07
I9417 n1_m1_518400_230400 0 1.378571e-07
I9418 n1_m1_518400_235200 0 1.629714e-07
I9419 n1_m1_518400_240000 0 1.501810e-07
I9420 n1_m1_518400_244800 0 2.071429e-07
I9421 n1_m1_518400_249600 0 1.111714e-07
I9422 n1_m1_518400_254400 0 6.892381e-08
I9423 n1_m1_518400_259200 0 5.617143e-08
I9424 n1_m1_518400_264000 0 1.517000e-07
I9425 n1_m1_518400_268800 0 1.451504e-07
I9426 n1_m1_518400_273600 0 7.397739e-07
I9427 n1_m1_518400_278400 0 1.611429e-07
I9428 n1_m1_518400_283200 0 2.533054e-07
I9429 n1_m1_518400_288000 0 5.828714e-07
I9430 n1_m1_518400_292800 0 9.681250e-08
I9431 n1_m1_518400_297600 0 1.879869e-07
I9432 n1_m1_518400_302400 0 5.372262e-08
I9433 n1_m1_518400_307200 0 2.478095e-07
I9434 n1_m1_518400_312000 0 1.494286e-07
I9435 n1_m1_518400_316800 0 1.110667e-07
I9436 n1_m1_518400_321600 0 1.469179e-07
I9437 n1_m1_518400_326400 0 1.243429e-07
I9438 n1_m1_518400_331200 0 3.620000e-07
I9439 n1_m1_518400_336000 0 1.864976e-07
I9440 n1_m1_518400_340800 0 1.021238e-07
I9441 n1_m1_518400_345600 0 7.049524e-08
I9442 n1_m1_518400_350400 0 8.455714e-08
I9443 n1_m1_518400_355200 0 8.560000e-08
I9444 n1_m1_518400_360000 0 6.810345e-07
I9445 n1_m1_518400_364800 0 7.344286e-08
I9446 n1_m1_518400_369600 0 2.298262e-07
I9447 n1_m1_518400_374400 0 1.610643e-07
I9448 n1_m1_518400_379200 0 3.587143e-08
I9449 n1_m1_518400_384000 0 5.067000e-07
I9450 n1_m1_518400_388800 0 5.570536e-07
I9451 n1_m1_518400_393600 0 5.698190e-07
I9452 n1_m1_518400_398400 0 1.090476e-07
I9453 n1_m1_518400_403200 0 4.876500e-07
I9454 n1_m1_518400_408000 0 4.095524e-07
I9455 n1_m1_518400_412800 0 1.074490e-07
I9456 n1_m1_518400_417600 0 1.186891e-07
I9457 n1_m1_518400_422400 0 1.412917e-07
I9458 n1_m1_518400_427200 0 2.143714e-07
I9459 n1_m1_518400_432000 0 2.567905e-07
I9460 n1_m1_518400_436800 0 9.183333e-08
I9461 n1_m1_518400_441600 0 1.174000e-07
I9462 n1_m1_518400_446400 0 1.730000e-07
I9463 n1_m1_518400_451200 0 6.920000e-08
I9464 n1_m1_518400_528000 0 2.099519e-07
I9465 n1_m1_518400_576000 0 2.428571e-08
I9466 n1_m1_518400_580800 0 6.457143e-07
I9467 n1_m1_518400_585600 0 3.374667e-07
I9468 n1_m1_523200_163200 0 1.042810e-07
I9469 n1_m1_523200_168000 0 1.897857e-07
I9470 n1_m1_523200_172800 0 3.164286e-08
I9471 n1_m1_523200_177600 0 7.155714e-08
I9472 n1_m1_523200_182400 0 1.416000e-07
I9473 n1_m1_523200_187200 0 1.118143e-07
I9474 n1_m1_523200_192000 0 1.870524e-07
I9475 n1_m1_523200_196800 0 2.555429e-07
I9476 n1_m1_523200_201600 0 3.140190e-07
I9477 n1_m1_523200_206400 0 1.090714e-07
I9478 n1_m1_523200_211200 0 4.438714e-07
I9479 n1_m1_523200_216000 0 5.003095e-07
I9480 n1_m1_523200_220800 0 7.849571e-08
I9481 n1_m1_523200_225600 0 1.516196e-07
I9482 n1_m1_523200_230400 0 4.528571e-08
I9483 n1_m1_523200_235200 0 1.118571e-07
I9484 n1_m1_523200_240000 0 6.996190e-08
I9485 n1_m1_523200_244800 0 1.241238e-07
I9486 n1_m1_523200_249600 0 7.550952e-08
I9487 n1_m1_523200_254400 0 4.387143e-08
I9488 n1_m1_523200_259200 0 1.600000e-08
I9489 n1_m1_523200_264000 0 1.107167e-07
I9490 n1_m1_523200_268800 0 7.430773e-07
I9491 n1_m1_523200_273600 0 3.835052e-06
I9492 n1_m1_523200_278400 0 5.785714e-07
I9493 n1_m1_523200_283200 0 7.362857e-08
I9494 n1_m1_523200_288000 0 2.773286e-07
I9495 n1_m1_523200_292800 0 2.148000e-07
I9496 n1_m1_523200_297600 0 9.190571e-08
I9497 n1_m1_523200_302400 0 2.246774e-07
I9498 n1_m1_523200_307200 0 4.434048e-07
I9499 n1_m1_523200_312000 0 1.912619e-07
I9500 n1_m1_523200_316800 0 1.291589e-07
I9501 n1_m1_523200_321600 0 5.642714e-07
I9502 n1_m1_523200_326400 0 4.429714e-07
I9503 n1_m1_523200_331200 0 1.046354e-05
I9504 n1_m1_523200_336000 0 1.822357e-07
I9505 n1_m1_523200_340800 0 5.457143e-08
I9506 n1_m1_523200_345600 0 1.374857e-07
I9507 n1_m1_523200_350400 0 6.946667e-08
I9508 n1_m1_523200_355200 0 9.554286e-08
I9509 n1_m1_523200_360000 0 2.061905e-07
I9510 n1_m1_523200_364800 0 8.430476e-08
I9511 n1_m1_523200_369600 0 7.074286e-08
I9512 n1_m1_523200_374400 0 5.933571e-08
I9513 n1_m1_523200_379200 0 1.317929e-07
I9514 n1_m1_523200_384000 0 1.158524e-07
I9515 n1_m1_523200_388800 0 5.754643e-08
I9516 n1_m1_523200_393600 0 7.349857e-07
I9517 n1_m1_523200_398400 0 8.572381e-08
I9518 n1_m1_523200_403200 0 7.980714e-08
I9519 n1_m1_523200_408000 0 1.319548e-07
I9520 n1_m1_523200_412800 0 9.664762e-08
I9521 n1_m1_523200_417600 0 2.682107e-07
I9522 n1_m1_523200_422400 0 4.096512e-07
I9523 n1_m1_523200_427200 0 1.089929e-07
I9524 n1_m1_523200_432000 0 1.238107e-07
I9525 n1_m1_523200_436800 0 7.268095e-08
I9526 n1_m1_523200_441600 0 7.034286e-08
I9527 n1_m1_523200_460800 0 1.964286e-07
I9528 n1_m1_523200_465600 0 5.860714e-07
I9529 n1_m1_523200_480000 0 7.898571e-07
I9530 n1_m1_523200_484800 0 8.714286e-08
I9531 n1_m1_523200_580800 0 1.000000e-07
I9532 n1_m1_523200_585600 0 6.250000e-08
I9533 n1_m1_528000_9600 0 7.137188e-07
I9534 n1_m1_528000_163200 0 6.030038e-07
I9535 n1_m1_528000_168000 0 4.374333e-07
I9536 n1_m1_528000_172800 0 2.204429e-07
I9537 n1_m1_528000_177600 0 1.563333e-07
I9538 n1_m1_528000_182400 0 1.450029e-07
I9539 n1_m1_528000_187200 0 3.219000e-07
I9540 n1_m1_528000_192000 0 2.252105e-07
I9541 n1_m1_528000_196800 0 2.081286e-07
I9542 n1_m1_528000_201600 0 3.137367e-07
I9543 n1_m1_528000_206400 0 2.303290e-07
I9544 n1_m1_528000_211200 0 2.286286e-07
I9545 n1_m1_528000_216000 0 8.504667e-08
I9546 n1_m1_528000_220800 0 1.874214e-07
I9547 n1_m1_528000_225600 0 2.615089e-07
I9548 n1_m1_528000_230400 0 1.118000e-07
I9549 n1_m1_528000_235200 0 6.330000e-08
I9550 n1_m1_528000_240000 0 1.947943e-07
I9551 n1_m1_528000_244800 0 1.958990e-07
I9552 n1_m1_528000_249600 0 2.173619e-07
I9553 n1_m1_528000_254400 0 1.358714e-07
I9554 n1_m1_528000_259200 0 4.948000e-07
I9555 n1_m1_528000_264000 0 1.467926e-06
I9556 n1_m1_528000_268800 0 1.306575e-06
I9557 n1_m1_528000_273600 0 1.229176e-06
I9558 n1_m1_528000_278400 0 1.137143e-07
I9559 n1_m1_528000_283200 0 9.398776e-08
I9560 n1_m1_528000_288000 0 2.209122e-07
I9561 n1_m1_528000_292800 0 3.331286e-07
I9562 n1_m1_528000_297600 0 2.722943e-07
I9563 n1_m1_528000_302400 0 1.194452e-07
I9564 n1_m1_528000_307200 0 1.513714e-07
I9565 n1_m1_528000_312000 0 2.652610e-07
I9566 n1_m1_528000_316800 0 1.055868e-07
I9567 n1_m1_528000_321600 0 6.675048e-07
I9568 n1_m1_528000_326400 0 1.858514e-07
I9569 n1_m1_528000_331200 0 1.087229e-07
I9570 n1_m1_528000_336000 0 3.415300e-07
I9571 n1_m1_528000_340800 0 1.957429e-07
I9572 n1_m1_528000_345600 0 1.902429e-07
I9573 n1_m1_528000_350400 0 1.823019e-07
I9574 n1_m1_528000_355200 0 4.577143e-08
I9575 n1_m1_528000_360000 0 5.047059e-07
I9576 n1_m1_528000_364800 0 2.448810e-07
I9577 n1_m1_528000_369600 0 2.330571e-07
I9578 n1_m1_528000_374400 0 9.766857e-08
I9579 n1_m1_528000_379200 0 1.663500e-07
I9580 n1_m1_528000_384000 0 1.217762e-07
I9581 n1_m1_528000_388800 0 1.549571e-07
I9582 n1_m1_528000_393600 0 2.142286e-07
I9583 n1_m1_528000_398400 0 9.605714e-08
I9584 n1_m1_528000_403200 0 9.136429e-08
I9585 n1_m1_528000_408000 0 2.753214e-07
I9586 n1_m1_528000_412800 0 1.542667e-07
I9587 n1_m1_528000_417600 0 2.532607e-07
I9588 n1_m1_528000_422400 0 6.243929e-08
I9589 n1_m1_528000_427200 0 2.616357e-07
I9590 n1_m1_528000_432000 0 3.408321e-07
I9591 n1_m1_528000_436800 0 3.101143e-07
I9592 n1_m1_528000_441600 0 5.434286e-08
I9593 n1_m1_528000_465600 0 8.986429e-07
I9594 n1_m1_528000_470400 0 1.685714e-08
I9595 n1_m1_528000_480000 0 6.938571e-07
I9596 n1_m1_528000_484800 0 8.714286e-08
I9597 n1_m1_528000_576000 0 9.828571e-09
I9598 n1_m1_528000_580800 0 4.016511e-07
I9599 n1_m1_528000_585600 0 2.355748e-07
I9600 n1_m1_532800_4800 0 4.495385e-08
I9601 n1_m1_532800_9600 0 5.520899e-07
I9602 n1_m1_532800_153600 0 3.310312e-07
I9603 n1_m1_532800_163200 0 2.475429e-08
I9604 n1_m1_532800_168000 0 2.154857e-07
I9605 n1_m1_532800_172800 0 1.723714e-07
I9606 n1_m1_532800_177600 0 1.385886e-07
I9607 n1_m1_532800_182400 0 6.676286e-08
I9608 n1_m1_532800_187200 0 1.098000e-07
I9609 n1_m1_532800_192000 0 1.471371e-07
I9610 n1_m1_532800_196800 0 2.114204e-07
I9611 n1_m1_532800_201600 0 1.753000e-07
I9612 n1_m1_532800_206400 0 6.652181e-08
I9613 n1_m1_532800_211200 0 9.520000e-08
I9614 n1_m1_532800_216000 0 7.962000e-08
I9615 n1_m1_532800_220800 0 7.020000e-08
I9616 n1_m1_532800_225600 0 3.009857e-07
I9617 n1_m1_532800_230400 0 6.914286e-08
I9618 n1_m1_532800_235200 0 1.105571e-07
I9619 n1_m1_532800_240000 0 1.448629e-07
I9620 n1_m1_532800_244800 0 1.537714e-08
I9621 n1_m1_532800_249600 0 9.034286e-08
I9622 n1_m1_532800_254400 0 5.785714e-08
I9623 n1_m1_532800_259200 0 5.968000e-08
I9624 n1_m1_532800_264000 0 3.857457e-07
I9625 n1_m1_532800_268800 0 1.878048e-07
I9626 n1_m1_532800_273600 0 3.362371e-07
I9627 n1_m1_532800_278400 0 1.504571e-07
I9628 n1_m1_532800_283200 0 1.993122e-07
I9629 n1_m1_532800_288000 0 1.526449e-07
I9630 n1_m1_532800_292800 0 1.540000e-07
I9631 n1_m1_532800_297600 0 2.216629e-07
I9632 n1_m1_532800_302400 0 3.667143e-08
I9633 n1_m1_532800_307200 0 6.841429e-08
I9634 n1_m1_532800_312000 0 1.111086e-07
I9635 n1_m1_532800_316800 0 1.923694e-07
I9636 n1_m1_532800_321600 0 2.175544e-07
I9637 n1_m1_532800_326400 0 5.236762e-08
I9638 n1_m1_532800_331200 0 5.525651e-08
I9639 n1_m1_532800_336000 0 7.584857e-08
I9640 n1_m1_532800_340800 0 6.701714e-08
I9641 n1_m1_532800_345600 0 5.104857e-08
I9642 n1_m1_532800_350400 0 1.613514e-07
I9643 n1_m1_532800_355200 0 6.062857e-08
I9644 n1_m1_532800_360000 0 3.959961e-06
I9645 n1_m1_532800_364800 0 3.342857e-08
I9646 n1_m1_532800_369600 0 1.525857e-07
I9647 n1_m1_532800_374400 0 7.654571e-08
I9648 n1_m1_532800_379200 0 5.467143e-08
I9649 n1_m1_532800_384000 0 4.709429e-07
I9650 n1_m1_532800_388800 0 5.168571e-08
I9651 n1_m1_532800_393600 0 1.439860e-07
I9652 n1_m1_532800_398400 0 1.167257e-07
I9653 n1_m1_532800_403200 0 1.203971e-07
I9654 n1_m1_532800_408000 0 1.698429e-07
I9655 n1_m1_532800_412800 0 1.159429e-07
I9656 n1_m1_532800_417600 0 2.158571e-07
I9657 n1_m1_532800_422400 0 2.281143e-07
I9658 n1_m1_532800_427200 0 1.696000e-07
I9659 n1_m1_532800_432000 0 1.198143e-07
I9660 n1_m1_532800_436800 0 4.108143e-07
I9661 n1_m1_532800_441600 0 7.011429e-07
I9662 n1_m1_532800_576000 0 1.474286e-08
I9663 n1_m1_532800_580800 0 3.651005e-07
I9664 n1_m1_532800_585600 0 2.045221e-07
I9665 n1_m1_537600_4800 0 1.492426e-07
I9666 n1_m1_537600_9600 0 5.889994e-07
I9667 n1_m1_537600_153600 0 3.310313e-07
I9668 n1_m1_537600_163200 0 1.362857e-08
I9669 n1_m1_537600_168000 0 1.916500e-07
I9670 n1_m1_537600_172800 0 7.477143e-08
I9671 n1_m1_537600_177600 0 1.282000e-07
I9672 n1_m1_537600_182400 0 8.624286e-08
I9673 n1_m1_537600_187200 0 1.860000e-07
I9674 n1_m1_537600_192000 0 2.053571e-07
I9675 n1_m1_537600_196800 0 1.241429e-07
I9676 n1_m1_537600_201600 0 4.457143e-07
I9677 n1_m1_537600_206400 0 1.155762e-07
I9678 n1_m1_537600_211200 0 8.598929e-08
I9679 n1_m1_537600_216000 0 2.639143e-07
I9680 n1_m1_537600_220800 0 1.235089e-07
I9681 n1_m1_537600_225600 0 4.301429e-08
I9682 n1_m1_537600_230400 0 9.680000e-08
I9683 n1_m1_537600_235200 0 1.718857e-07
I9684 n1_m1_537600_240000 0 1.439286e-07
I9685 n1_m1_537600_244800 0 5.519048e-08
I9686 n1_m1_537600_249600 0 1.558810e-07
I9687 n1_m1_537600_254400 0 2.995238e-07
I9688 n1_m1_537600_259200 0 6.565714e-07
I9689 n1_m1_537600_264000 0 6.394286e-07
I9690 n1_m1_537600_268800 0 9.175952e-08
I9691 n1_m1_537600_273600 0 1.357500e-07
I9692 n1_m1_537600_278400 0 2.226012e-07
I9693 n1_m1_537600_283200 0 8.149048e-08
I9694 n1_m1_537600_288000 0 1.865970e-07
I9695 n1_m1_537600_292800 0 7.428571e-08
I9696 n1_m1_537600_297600 0 4.417190e-07
I9697 n1_m1_537600_302400 0 1.029310e-07
I9698 n1_m1_537600_307200 0 2.735119e-07
I9699 n1_m1_537600_312000 0 2.852429e-07
I9700 n1_m1_537600_316800 0 3.027143e-07
I9701 n1_m1_537600_321600 0 3.104286e-07
I9702 n1_m1_537600_326400 0 7.581429e-08
I9703 n1_m1_537600_331200 0 1.124357e-07
I9704 n1_m1_537600_336000 0 1.609714e-07
I9705 n1_m1_537600_340800 0 9.442857e-08
I9706 n1_m1_537600_345600 0 2.075071e-07
I9707 n1_m1_537600_350400 0 9.261190e-08
I9708 n1_m1_537600_355200 0 4.597143e-08
I9709 n1_m1_537600_364800 0 4.251429e-08
I9710 n1_m1_537600_369600 0 7.180000e-08
I9711 n1_m1_537600_374400 0 7.390238e-08
I9712 n1_m1_537600_379200 0 7.315714e-08
I9713 n1_m1_537600_384000 0 1.363143e-07
I9714 n1_m1_537600_388800 0 7.678571e-09
I9715 n1_m1_537600_393600 0 1.892738e-07
I9716 n1_m1_537600_398400 0 1.339714e-07
I9717 n1_m1_537600_403200 0 1.072714e-07
I9718 n1_m1_537600_408000 0 1.442857e-07
I9719 n1_m1_537600_412800 0 1.243714e-07
I9720 n1_m1_537600_417600 0 1.618333e-07
I9721 n1_m1_537600_422400 0 1.191476e-07
I9722 n1_m1_537600_427200 0 8.220952e-08
I9723 n1_m1_537600_432000 0 2.037012e-07
I9724 n1_m1_537600_436800 0 1.520762e-07
I9725 n1_m1_542400_4800 0 3.292308e-09
I9726 n1_m1_542400_9600 0 2.743590e-10
I9727 n1_m1_542400_28800 0 3.420000e-06
I9728 n1_m1_542400_33600 0 4.560000e-06
I9729 n1_m1_542400_168000 0 2.029071e-07
I9730 n1_m1_542400_172800 0 1.052667e-07
I9731 n1_m1_542400_177600 0 6.790952e-08
I9732 n1_m1_542400_182400 0 2.060000e-08
I9733 n1_m1_542400_187200 0 6.805714e-08
I9734 n1_m1_542400_192000 0 1.096429e-07
I9735 n1_m1_542400_196800 0 2.343810e-08
I9736 n1_m1_542400_201600 0 2.988048e-07
I9737 n1_m1_542400_206400 0 1.615238e-07
I9738 n1_m1_542400_211200 0 3.266000e-07
I9739 n1_m1_542400_216000 0 1.663619e-07
I9740 n1_m1_542400_220800 0 6.065893e-08
I9741 n1_m1_542400_225600 0 1.687714e-07
I9742 n1_m1_542400_230400 0 1.126667e-07
I9743 n1_m1_542400_235200 0 2.342857e-08
I9744 n1_m1_542400_240000 0 3.165857e-07
I9745 n1_m1_542400_244800 0 5.449524e-08
I9746 n1_m1_542400_249600 0 1.062571e-07
I9747 n1_m1_542400_254400 0 1.304286e-07
I9748 n1_m1_542400_264000 0 1.608810e-07
I9749 n1_m1_542400_268800 0 2.332004e-07
I9750 n1_m1_542400_273600 0 1.202324e-06
I9751 n1_m1_542400_278400 0 2.156607e-07
I9752 n1_m1_542400_283200 0 1.527000e-07
I9753 n1_m1_542400_288000 0 1.219839e-07
I9754 n1_m1_542400_292800 0 1.078571e-07
I9755 n1_m1_542400_297600 0 6.727143e-08
I9756 n1_m1_542400_302400 0 1.652952e-07
I9757 n1_m1_542400_307200 0 7.184524e-08
I9758 n1_m1_542400_312000 0 3.749857e-07
I9759 n1_m1_542400_316800 0 1.524429e-07
I9760 n1_m1_542400_321600 0 1.266429e-07
I9761 n1_m1_542400_326400 0 6.818571e-08
I9762 n1_m1_542400_331200 0 8.574048e-08
I9763 n1_m1_542400_336000 0 5.729048e-08
I9764 n1_m1_542400_340800 0 4.002857e-08
I9765 n1_m1_542400_345600 0 2.194881e-07
I9766 n1_m1_542400_350400 0 1.381357e-07
I9767 n1_m1_542400_355200 0 7.951429e-08
I9768 n1_m1_542400_364800 0 2.888571e-08
I9769 n1_m1_542400_369600 0 1.763286e-07
I9770 n1_m1_542400_374400 0 1.417690e-07
I9771 n1_m1_542400_379200 0 1.809714e-07
I9772 n1_m1_542400_384000 0 1.670905e-07
I9773 n1_m1_542400_388800 0 1.043798e-07
I9774 n1_m1_542400_393600 0 1.465929e-07
I9775 n1_m1_542400_398400 0 2.421429e-07
I9776 n1_m1_542400_403200 0 2.478143e-07
I9777 n1_m1_542400_408000 0 1.167190e-07
I9778 n1_m1_542400_412800 0 1.093714e-07
I9779 n1_m1_542400_417600 0 1.276286e-07
I9780 n1_m1_542400_422400 0 1.073857e-07
I9781 n1_m1_542400_427200 0 2.183048e-07
I9782 n1_m1_542400_432000 0 8.607143e-09
I9783 n1_m1_547200_168000 0 2.397143e-08
I9784 n1_m1_547200_172800 0 9.607619e-08
I9785 n1_m1_547200_177600 0 1.214190e-07
I9786 n1_m1_547200_182400 0 2.925000e-08
I9787 n1_m1_547200_187200 0 9.977143e-08
I9788 n1_m1_547200_192000 0 1.587119e-07
I9789 n1_m1_547200_196800 0 1.176524e-07
I9790 n1_m1_547200_201600 0 1.057048e-07
I9791 n1_m1_547200_206400 0 8.509286e-08
I9792 n1_m1_547200_211200 0 8.893571e-08
I9793 n1_m1_547200_216000 0 1.032119e-07
I9794 n1_m1_547200_220800 0 1.268571e-08
I9795 n1_m1_547200_225600 0 9.707143e-08
I9796 n1_m1_547200_230400 0 8.961905e-08
I9797 n1_m1_547200_235200 0 7.284286e-08
I9798 n1_m1_547200_240000 0 9.440238e-08
I9799 n1_m1_547200_244800 0 1.045286e-07
I9800 n1_m1_547200_249600 0 9.221905e-08
I9801 n1_m1_547200_254400 0 1.513333e-08
I9802 n1_m1_547200_264000 0 2.042286e-07
I9803 n1_m1_547200_268800 0 1.368186e-07
I9804 n1_m1_547200_273600 0 4.243546e-07
I9805 n1_m1_547200_278400 0 3.385714e-08
I9806 n1_m1_547200_283200 0 6.556429e-08
I9807 n1_m1_547200_288000 0 6.633929e-08
I9808 n1_m1_547200_292800 0 1.098304e-07
I9809 n1_m1_547200_297600 0 1.183786e-07
I9810 n1_m1_547200_302400 0 6.911786e-08
I9811 n1_m1_547200_307200 0 6.361607e-08
I9812 n1_m1_547200_312000 0 2.534571e-07
I9813 n1_m1_547200_316800 0 1.308238e-07
I9814 n1_m1_547200_321600 0 1.764095e-07
I9815 n1_m1_547200_326400 0 6.007143e-08
I9816 n1_m1_547200_331200 0 1.474810e-07
I9817 n1_m1_547200_336000 0 1.013452e-07
I9818 n1_m1_547200_340800 0 4.020000e-08
I9819 n1_m1_547200_345600 0 3.228952e-07
I9820 n1_m1_547200_350400 0 6.170000e-08
I9821 n1_m1_547200_369600 0 1.634286e-08
I9822 n1_m1_547200_374400 0 1.225714e-08
I9823 n1_m1_547200_379200 0 8.960000e-08
I9824 n1_m1_547200_384000 0 3.542714e-07
I9825 n1_m1_547200_388800 0 1.172202e-07
I9826 n1_m1_547200_393600 0 5.176667e-08
I9827 n1_m1_547200_398400 0 1.315619e-07
I9828 n1_m1_547200_403200 0 2.311714e-07
I9829 n1_m1_547200_408000 0 2.129667e-07
I9830 n1_m1_547200_412800 0 8.820000e-08
I9831 n1_m1_547200_422400 0 6.028571e-09
I9832 n1_m1_547200_427200 0 3.617143e-08
I9833 n1_m1_552000_4800 0 1.440000e-07
I9834 n1_m1_552000_9600 0 1.160108e-06
I9835 n1_m1_552000_124800 0 4.028571e-06
I9836 n1_m1_552000_129600 0 1.611429e-06
I9837 n1_m1_552000_177600 0 6.230000e-08
I9838 n1_m1_552000_182400 0 1.339286e-08
I9839 n1_m1_552000_187200 0 1.514000e-07
I9840 n1_m1_552000_192000 0 1.536738e-07
I9841 n1_m1_552000_196800 0 8.945238e-08
I9842 n1_m1_552000_201600 0 1.649762e-07
I9843 n1_m1_552000_206400 0 1.037214e-07
I9844 n1_m1_552000_211200 0 1.303714e-07
I9845 n1_m1_552000_216000 0 2.955405e-07
I9846 n1_m1_552000_220800 0 1.310881e-07
I9847 n1_m1_552000_225600 0 2.921000e-07
I9848 n1_m1_552000_230400 0 1.564000e-07
I9849 n1_m1_552000_235200 0 9.970000e-08
I9850 n1_m1_552000_240000 0 4.378762e-07
I9851 n1_m1_552000_244800 0 1.620714e-07
I9852 n1_m1_552000_249600 0 2.382286e-07
I9853 n1_m1_552000_254400 0 3.857143e-09
I9854 n1_m1_552000_264000 0 7.976190e-08
I9855 n1_m1_552000_268800 0 1.230929e-07
I9856 n1_m1_552000_273600 0 1.533024e-07
I9857 n1_m1_552000_278400 0 7.264286e-08
I9858 n1_m1_552000_283200 0 1.142000e-07
I9859 n1_m1_552000_288000 0 1.975750e-07
I9860 n1_m1_552000_292800 0 1.498125e-07
I9861 n1_m1_552000_297600 0 4.314786e-07
I9862 n1_m1_552000_302400 0 2.042012e-07
I9863 n1_m1_552000_307200 0 9.152679e-08
I9864 n1_m1_552000_312000 0 1.420405e-07
I9865 n1_m1_552000_316800 0 2.184762e-07
I9866 n1_m1_552000_321600 0 1.945976e-07
I9867 n1_m1_552000_326400 0 1.133810e-07
I9868 n1_m1_552000_331200 0 6.710714e-08
I9869 n1_m1_552000_336000 0 9.796429e-08
I9870 n1_m1_552000_340800 0 1.169333e-07
I9871 n1_m1_552000_345600 0 1.724143e-07
I9872 n1_m1_552000_350400 0 5.000000e-08
I9873 n1_m1_552000_384000 0 6.371429e-09
I9874 n1_m1_552000_388800 0 4.778571e-09
I9875 n1_m1_552000_398400 0 4.003810e-08
I9876 n1_m1_552000_403200 0 3.002857e-08
I9877 n1_m1_556800_4800 0 3.175385e-08
I9878 n1_m1_556800_9600 0 6.245380e-07
I9879 n1_m1_556800_124800 0 3.357143e-07
I9880 n1_m1_556800_129600 0 1.342857e-07
I9881 n1_m1_556800_211200 0 1.067857e-08
I9882 n1_m1_556800_216000 0 6.445714e-08
I9883 n1_m1_556800_220800 0 1.509762e-08
I9884 n1_m1_556800_240000 0 2.395000e-08
I9885 n1_m1_556800_264000 0 3.579286e-07
I9886 n1_m1_556800_268800 0 1.667762e-07
I9887 n1_m1_556800_273600 0 1.563214e-07
I9888 n1_m1_556800_278400 0 8.742857e-08
I9889 n1_m1_556800_283200 0 9.285000e-08
I9890 n1_m1_556800_288000 0 1.524000e-07
I9891 n1_m1_556800_292800 0 1.103393e-07
I9892 n1_m1_556800_297600 0 1.171571e-07
I9893 n1_m1_556800_302400 0 1.404762e-08
I9894 n1_m1_556800_307200 0 5.416667e-08
I9895 n1_m1_556800_312000 0 1.565738e-07
I9896 n1_m1_556800_316800 0 4.798571e-08
I9897 n1_m1_556800_321600 0 1.948500e-07
I9898 n1_m1_556800_326400 0 9.903333e-08
I9899 n1_m1_556800_331200 0 7.923571e-08
I9900 n1_m1_556800_336000 0 1.526476e-07
I9901 n1_m1_556800_340800 0 1.070095e-07
I9902 n1_m1_556800_345600 0 4.245714e-08
I9903 n1_m1_556800_408000 0 4.876923e-07
I9904 n1_m1_556800_412800 0 2.926154e-06
I9905 n1_m1_556800_580800 0 8.861538e-09
I9906 n1_m1_556800_585600 0 5.538462e-09
I9907 n1_m1_561600_240000 0 1.054545e-07
I9908 n1_m1_561600_264000 0 5.305714e-07
I9909 n1_m1_561600_268800 0 7.570952e-08
I9910 n1_m1_561600_273600 0 6.460476e-07
I9911 n1_m1_561600_278400 0 1.030714e-06
I9912 n1_m1_561600_283200 0 1.449286e-07
I9913 n1_m1_561600_288000 0 1.008714e-07
I9914 n1_m1_561600_292800 0 1.146250e-07
I9915 n1_m1_561600_297600 0 2.494143e-07
I9916 n1_m1_561600_302400 0 1.879905e-07
I9917 n1_m1_561600_307200 0 5.486905e-08
I9918 n1_m1_561600_312000 0 1.372500e-07
I9919 n1_m1_561600_316800 0 2.445738e-07
I9920 n1_m1_561600_321600 0 5.326857e-07
I9921 n1_m1_561600_326400 0 3.620000e-08
I9922 n1_m1_561600_331200 0 3.704286e-08
I9923 n1_m1_561600_336000 0 1.503524e-07
I9924 n1_m1_561600_340800 0 2.022857e-08
I9925 n1_m1_561600_350400 0 1.242857e-09
I9926 n1_m1_561600_355200 0 1.657143e-09
I9927 n1_m1_561600_408000 0 4.180220e-07
I9928 n1_m1_561600_412800 0 2.508132e-06
I9929 n1_m1_561600_508800 0 5.391429e-06
I9930 n1_m1_561600_513600 0 8.985714e-07
I9931 n1_m1_566400_9600 0 6.068750e-07
I9932 n1_m1_566400_206400 0 3.484615e-07
I9933 n1_m1_566400_211200 0 7.625000e-07
I9934 n1_m1_566400_235200 0 1.329200e-07
I9935 n1_m1_566400_240000 0 7.030303e-07
I9936 n1_m1_566400_244800 0 2.341818e-07
I9937 n1_m1_566400_249600 0 1.756364e-07
I9938 n1_m1_566400_264000 0 4.320000e-07
I9939 n1_m1_566400_268800 0 1.728000e-07
I9940 n1_m1_566400_273600 0 4.377143e-08
I9941 n1_m1_566400_278400 0 1.094286e-07
I9942 n1_m1_566400_297600 0 4.208571e-08
I9943 n1_m1_566400_302400 0 7.014286e-09
I9944 n1_m1_566400_312000 0 1.590857e-07
I9945 n1_m1_566400_316800 0 2.651429e-08
I9946 n1_m1_566400_336000 0 6.214286e-08
I9947 n1_m1_566400_340800 0 8.285714e-08
I9948 n1_m1_566400_350400 0 6.274286e-08
I9949 n1_m1_566400_355200 0 8.365714e-08
I9950 n1_m1_566400_384000 0 5.848438e-07
I9951 n1_m1_566400_393600 0 2.196429e-08
I9952 n1_m1_566400_398400 0 1.317857e-07
I9953 n1_m1_571200_4800 0 4.633846e-08
I9954 n1_m1_571200_9600 0 9.489279e-08
I9955 n1_m1_571200_28800 0 3.656250e-08
I9956 n1_m1_571200_72000 0 3.376068e-08
I9957 n1_m1_571200_76800 0 1.856838e-07
I9958 n1_m1_571200_129600 0 4.558442e-07
I9959 n1_m1_571200_134400 0 1.571169e-07
I9960 n1_m1_571200_139200 0 2.028571e-07
I9961 n1_m1_571200_158400 0 1.011429e-07
I9962 n1_m1_571200_163200 0 7.418571e-07
I9963 n1_m1_571200_187200 0 2.528571e-07
I9964 n1_m1_571200_192000 0 5.739610e-07
I9965 n1_m1_571200_206400 0 9.153846e-08
I9966 n1_m1_571200_211200 0 4.193750e-07
I9967 n1_m1_571200_235200 0 3.480000e-09
I9968 n1_m1_571200_240000 0 2.220000e-07
I9969 n1_m1_571200_244800 0 3.178182e-07
I9970 n1_m1_571200_249600 0 2.383636e-07
I9971 n1_m1_571200_254400 0 7.138528e-08
I9972 n1_m1_571200_259200 0 4.283117e-07
I9973 n1_m1_571200_264000 0 4.680000e-07
I9974 n1_m1_571200_268800 0 1.872000e-07
I9975 n1_m1_571200_302400 0 3.920313e-07
I9976 n1_m1_571200_336000 0 4.297143e-07
I9977 n1_m1_571200_340800 0 4.142857e-07
I9978 n1_m1_571200_350400 0 1.568571e-08
I9979 n1_m1_571200_355200 0 2.091429e-08
I9980 n1_m1_571200_360000 0 3.843750e-08
I9981 n1_m1_571200_384000 0 4.001563e-07
I9982 n1_m1_571200_393600 0 4.558214e-07
I9983 n1_m1_571200_398400 0 7.411264e-07
I9984 n1_m1_571200_403200 0 6.164835e-08
I9985 n1_m1_571200_408000 0 3.262500e-07
I9986 n1_m1_571200_480000 0 7.526853e-07
I9987 n1_m1_571200_484800 0 8.757576e-08
I9988 n1_m1_576000_4800 0 1.975385e-08
I9989 n1_m1_576000_9600 0 1.224462e-07
I9990 n1_m1_576000_24000 0 1.190000e-07
I9991 n1_m1_576000_28800 0 1.285875e-06
I9992 n1_m1_576000_33600 0 2.520000e-07
I9993 n1_m1_576000_57600 0 5.878022e-07
I9994 n1_m1_576000_62400 0 4.114286e-07
I9995 n1_m1_576000_72000 0 3.725641e-07
I9996 n1_m1_576000_76800 0 1.114103e-06
I9997 n1_m1_576000_91200 0 9.942857e-09
I9998 n1_m1_576000_96000 0 7.457143e-09
I9999 n1_m1_576000_124800 0 1.242857e-08
I10000 n1_m1_576000_129600 0 8.263416e-07
I10001 n1_m1_576000_134400 0 2.620617e-07
I10002 n1_m1_576000_153600 0 7.435612e-07
I10003 n1_m1_576000_158400 0 6.208163e-08
I10004 n1_m1_576000_163200 0 6.980000e-07
I10005 n1_m1_576000_192000 0 7.745818e-07
I10006 n1_m1_576000_196800 0 1.450000e-07
I10007 n1_m1_576000_220800 0 8.030000e-06
I10008 n1_m1_576000_240000 0 5.490000e-07
I10009 n1_m1_576000_249600 0 1.783333e-08
I10010 n1_m1_576000_254400 0 7.127900e-08
I10011 n1_m1_576000_259200 0 4.276740e-07
I10012 n1_m1_576000_297600 0 9.315275e-07
I10013 n1_m1_576000_302400 0 8.318259e-07
I10014 n1_m1_576000_312000 0 2.742857e-07
I10015 n1_m1_576000_316800 0 1.360000e-07
I10016 n1_m1_576000_321600 0 2.257143e-07
I10017 n1_m1_576000_331200 0 3.311948e-07
I10018 n1_m1_576000_336000 0 3.696857e-07
I10019 n1_m1_576000_340800 0 3.699341e-07
I10020 n1_m1_576000_345600 0 9.993873e-07
I10021 n1_m1_576000_355200 0 1.457143e-07
I10022 n1_m1_576000_360000 0 1.454411e-06
I10023 n1_m1_576000_393600 0 5.826190e-08
I10024 n1_m1_576000_398400 0 3.645165e-07
I10025 n1_m1_576000_403200 0 1.120879e-08
I10026 n1_m1_576000_408000 0 1.168236e-06
I10027 n1_m1_576000_412800 0 1.491429e-08
I10028 n1_m1_576000_432000 0 3.130000e-07
I10029 n1_m1_576000_441600 0 1.259780e-07
I10030 n1_m1_576000_446400 0 1.001525e-06
I10031 n1_m1_576000_451200 0 2.746320e-07
I10032 n1_m1_576000_460800 0 1.957143e-07
I10033 n1_m1_576000_465600 0 7.828571e-08
I10034 n1_m1_576000_480000 0 6.253147e-07
I10035 n1_m1_576000_484800 0 8.242424e-08
I10036 n1_m1_576000_499200 0 3.163636e-07
I10037 n1_m1_576000_518400 0 8.365385e-08
I10038 n1_m1_576000_523200 0 9.759615e-08
I10039 n1_m1_580800_9600 0 8.600000e-08
I10040 n1_m1_580800_24000 0 4.046250e-07
I10041 n1_m1_580800_28800 0 5.396250e-08
I10042 n1_m1_580800_38400 0 3.541818e-07
I10043 n1_m1_580800_43200 0 3.672727e-07
I10044 n1_m1_580800_52800 0 3.483636e-07
I10045 n1_m1_580800_57600 0 9.350549e-07
I10046 n1_m1_580800_62400 0 2.571429e-08
I10047 n1_m1_580800_72000 0 3.569340e-07
I10048 n1_m1_580800_76800 0 3.713675e-08
I10049 n1_m1_580800_81600 0 1.546667e-08
I10050 n1_m1_580800_86400 0 3.578182e-07
I10051 n1_m1_580800_105600 0 4.617188e-07
I10052 n1_m1_580800_110400 0 2.803125e-07
I10053 n1_m1_580800_115200 0 1.625146e-07
I10054 n1_m1_580800_120000 0 3.023377e-07
I10055 n1_m1_580800_129600 0 7.404286e-07
I10056 n1_m1_580800_134400 0 1.035714e-07
I10057 n1_m1_580800_139200 0 2.566234e-07
I10058 n1_m1_580800_144000 0 1.026494e-07
I10059 n1_m1_580800_153600 0 9.252959e-07
I10060 n1_m1_580800_158400 0 2.397885e-07
I10061 n1_m1_580800_168000 0 1.547532e-07
I10062 n1_m1_580800_172800 0 2.063377e-07
I10063 n1_m1_580800_182400 0 1.721920e-07
I10064 n1_m1_580800_187200 0 2.295893e-07
I10065 n1_m1_580800_196800 0 7.733333e-09
I10066 n1_m1_580800_240000 0 4.344000e-07
I10067 n1_m1_580800_244800 0 8.001143e-08
I10068 n1_m1_580800_249600 0 6.723254e-07
I10069 n1_m1_580800_254400 0 4.689308e-07
I10070 n1_m1_580800_259200 0 4.157845e-07
I10071 n1_m1_580800_264000 0 3.487143e-08
I10072 n1_m1_580800_268800 0 7.472527e-09
I10073 n1_m1_580800_273600 0 6.495227e-07
I10074 n1_m1_580800_278400 0 4.142857e-09
I10075 n1_m1_580800_283200 0 3.554753e-07
I10076 n1_m1_580800_288000 0 1.317857e-07
I10077 n1_m1_580800_292800 0 3.397500e-07
I10078 n1_m1_580800_297600 0 6.358725e-07
I10079 n1_m1_580800_302400 0 4.549048e-07
I10080 n1_m1_580800_307200 0 2.990476e-07
I10081 n1_m1_580800_312000 0 1.077714e-07
I10082 n1_m1_580800_316800 0 4.610030e-07
I10083 n1_m1_580800_321600 0 4.817262e-07
I10084 n1_m1_580800_326400 0 1.457143e-07
I10085 n1_m1_580800_331200 0 8.709351e-07
I10086 n1_m1_580800_336000 0 4.823090e-07
I10087 n1_m1_580800_340800 0 2.678159e-07
I10088 n1_m1_580800_345600 0 2.648984e-07
I10089 n1_m1_580800_360000 0 4.563750e-08
I10090 n1_m1_580800_364800 0 1.496104e-07
I10091 n1_m1_580800_369600 0 4.035325e-07
I10092 n1_m1_580800_374400 0 1.530390e-07
I10093 n1_m1_580800_384000 0 3.578182e-07
I10094 n1_m1_580800_388800 0 3.509091e-07
I10095 n1_m1_580800_393600 0 1.023810e-08
I10096 n1_m1_580800_398400 0 6.142857e-08
I10097 n1_m1_580800_408000 0 7.822727e-07
I10098 n1_m1_580800_417600 0 2.571429e-07
I10099 n1_m1_580800_422400 0 1.028571e-07
I10100 n1_m1_580800_427200 0 2.057143e-07
I10101 n1_m1_580800_432000 0 1.542857e-07
I10102 n1_m1_580800_441600 0 3.736264e-09
I10103 n1_m1_580800_446400 0 1.941891e-07
I10104 n1_m1_580800_451200 0 7.496797e-08
I10105 n1_m1_580800_456000 0 6.171429e-09
I10106 n1_m1_580800_470400 0 1.869048e-07
I10107 n1_m1_580800_475200 0 4.672619e-07
I10108 n1_m1_580800_494400 0 1.020000e-07
I10109 n1_m1_580800_499200 0 7.200303e-07
I10110 n1_m1_580800_513600 0 3.498182e-07
I10111 n1_m1_580800_518400 0 4.536154e-07
I10112 n1_m1_580800_523200 0 3.903846e-07
I10113 n1_m1_580800_537600 0 6.910947e-07
I10114 n1_m1_580800_542400 0 1.005917e-08
I10115 n1_m1_585600_19200 0 4.380000e-08
I10116 n1_m1_585600_24000 0 5.986750e-07
I10117 n1_m1_585600_28800 0 2.140000e-08
I10118 n1_m1_585600_33600 0 3.206154e-08
I10119 n1_m1_585600_38400 0 6.398566e-07
I10120 n1_m1_585600_43200 0 6.686196e-07
I10121 n1_m1_585600_48000 0 3.020769e-08
I10122 n1_m1_585600_52800 0 6.096364e-07
I10123 n1_m1_585600_57600 0 7.230000e-08
I10124 n1_m1_585600_67200 0 5.100000e-08
I10125 n1_m1_585600_72000 0 6.161105e-07
I10126 n1_m1_585600_76800 0 1.810769e-08
I10127 n1_m1_585600_81600 0 7.709048e-08
I10128 n1_m1_585600_86400 0 6.407247e-07
I10129 n1_m1_585600_91200 0 1.222857e-08
I10130 n1_m1_585600_96000 0 9.171429e-09
I10131 n1_m1_585600_100800 0 5.114286e-09
I10132 n1_m1_585600_105600 0 5.700241e-07
I10133 n1_m1_585600_110400 0 4.498304e-07
I10134 n1_m1_585600_115200 0 3.028568e-07
I10135 n1_m1_585600_120000 0 5.799909e-07
I10136 n1_m1_585600_124800 0 1.528571e-08
I10137 n1_m1_585600_129600 0 4.389857e-07
I10138 n1_m1_585600_134400 0 8.025000e-08
I10139 n1_m1_585600_139200 0 4.855195e-07
I10140 n1_m1_585600_144000 0 1.796364e-07
I10141 n1_m1_585600_148800 0 3.134286e-08
I10142 n1_m1_585600_153600 0 3.902571e-07
I10143 n1_m1_585600_158400 0 4.515013e-07
I10144 n1_m1_585600_163200 0 3.677143e-08
I10145 n1_m1_585600_168000 0 2.852182e-07
I10146 n1_m1_585600_172800 0 4.234909e-07
I10147 n1_m1_585600_177600 0 1.040000e-08
I10148 n1_m1_585600_182400 0 2.516652e-07
I10149 n1_m1_585600_187200 0 3.832107e-07
I10150 n1_m1_585600_192000 0 6.414286e-08
I10151 n1_m1_585600_196800 0 5.763810e-08
I10152 n1_m1_585600_201600 0 1.222857e-08
I10153 n1_m1_585600_211200 0 2.140000e-08
I10154 n1_m1_585600_235200 0 3.880000e-08
I10155 n1_m1_585600_240000 0 9.877143e-08
I10156 n1_m1_585600_244800 0 1.123886e-07
I10157 n1_m1_585600_249600 0 8.465841e-07
I10158 n1_m1_585600_254400 0 6.972764e-07
I10159 n1_m1_585600_259200 0 5.532298e-07
I10160 n1_m1_585600_264000 0 7.184286e-08
I10161 n1_m1_585600_268800 0 1.987033e-08
I10162 n1_m1_585600_273600 0 8.106488e-07
I10163 n1_m1_585600_278400 0 4.914286e-08
I10164 n1_m1_585600_283200 0 6.388390e-07
I10165 n1_m1_585600_288000 0 2.906429e-07
I10166 n1_m1_585600_292800 0 4.135357e-07
I10167 n1_m1_585600_297600 0 1.210857e-07
I10168 n1_m1_585600_302400 0 6.336381e-07
I10169 n1_m1_585600_307200 0 4.756667e-07
I10170 n1_m1_585600_312000 0 3.003000e-07
I10171 n1_m1_585600_316800 0 5.347542e-07
I10172 n1_m1_585600_321600 0 5.803595e-07
I10173 n1_m1_585600_326400 0 7.065714e-08
I10174 n1_m1_585600_331200 0 4.290273e-07
I10175 n1_m1_585600_336000 0 7.015767e-07
I10176 n1_m1_585600_340800 0 3.533929e-07
I10177 n1_m1_585600_345600 0 4.922857e-08
I10178 n1_m1_585600_350400 0 2.357143e-08
I10179 n1_m1_585600_355200 0 3.057143e-08
I10180 n1_m1_585600_360000 0 8.885714e-08
I10181 n1_m1_585600_364800 0 3.097182e-07
I10182 n1_m1_585600_369600 0 7.570818e-07
I10183 n1_m1_585600_374400 0 2.678182e-07
I10184 n1_m1_585600_379200 0 6.682857e-08
I10185 n1_m1_585600_384000 0 7.052675e-07
I10186 n1_m1_585600_388800 0 6.567766e-07
I10187 n1_m1_585600_393600 0 3.785714e-08
I10188 n1_m1_585600_398400 0 3.057143e-08
I10189 n1_m1_585600_403200 0 6.077143e-08
I10190 n1_m1_585600_408000 0 1.254684e-06
I10191 n1_m1_585600_412800 0 5.974286e-08
I10192 n1_m1_585600_417600 0 4.500000e-07
I10193 n1_m1_585600_422400 0 2.389286e-07
I10194 n1_m1_585600_427200 0 4.081714e-07
I10195 n1_m1_585600_432000 0 3.536857e-07
I10196 n1_m1_585600_436800 0 1.165714e-08
I10197 n1_m1_585600_441600 0 3.325714e-08
I10198 n1_m1_585600_446400 0 3.057143e-08
I10199 n1_m1_585600_451200 0 3.962857e-08
I10200 n1_m1_585600_456000 0 5.740000e-08
I10201 n1_m1_585600_460800 0 1.528571e-08
I10202 n1_m1_585600_465600 0 7.792857e-08
I10203 n1_m1_585600_470400 0 4.388524e-07
I10204 n1_m1_585600_475200 0 6.694524e-07
I10205 n1_m1_585600_480000 0 4.280000e-08
I10206 n1_m1_585600_484800 0 6.114286e-09
I10207 n1_m1_585600_489600 0 3.631429e-08
I10208 n1_m1_585600_494400 0 4.971429e-08
I10209 n1_m1_585600_499200 0 3.339489e-07
I10210 n1_m1_585600_504000 0 3.382857e-08
I10211 n1_m1_585600_513600 0 6.850818e-07
I10212 n1_m1_585600_518400 0 2.400692e-07
I10213 n1_m1_585600_523200 0 2.727379e-07
I10214 n1_m1_585600_528000 0 5.542857e-09
I10215 n1_m1_585600_537600 0 1.046690e-06
I10216 n1_m1_585600_542400 0 6.355621e-08
I10217 n1_m1_585600_561600 0 5.620000e-08
I10218 n1_m1_585600_580800 0 2.141538e-08
I10219 n1_m1_585600_585600 0 5.618462e-08
I10220 n1_m1_32000_9600 0 2.870000e-08
I10221 n1_m1_32000_144000 0 4.047692e-06
I10222 n1_m1_32000_148800 0 6.746154e-07
I10223 n1_m1_32000_249600 0 1.455157e-07
I10224 n1_m1_32000_254400 0 5.614429e-08
I10225 n1_m1_32000_259200 0 1.221371e-07
I10226 n1_m1_32000_264000 0 1.156714e-07
I10227 n1_m1_32000_268800 0 4.662714e-08
I10228 n1_m1_32000_273600 0 7.219762e-08
I10229 n1_m1_32000_278400 0 8.178571e-08
I10230 n1_m1_32000_283200 0 3.123143e-08
I10231 n1_m1_32000_288000 0 4.131429e-08
I10232 n1_m1_32000_292800 0 1.728036e-07
I10233 n1_m1_32000_297600 0 1.322417e-07
I10234 n1_m1_32000_302400 0 8.186964e-08
I10235 n1_m1_32000_307200 0 6.482143e-08
I10236 n1_m1_32000_312000 0 6.075714e-08
I10237 n1_m1_32000_316800 0 2.380952e-08
I10238 n1_m1_32000_321600 0 7.138095e-08
I10239 n1_m1_32000_326400 0 3.689048e-08
I10240 n1_m1_32000_331200 0 6.645476e-08
I10241 n1_m1_32000_336000 0 1.290286e-07
I10242 n1_m1_32000_518400 0 3.625000e-07
I10243 n1_m1_60000_4800 0 3.292308e-09
I10244 n1_m1_60000_9600 0 2.743590e-10
I10245 n1_m1_60000_48000 0 1.044000e-08
I10246 n1_m1_60000_163200 0 1.884286e-08
I10247 n1_m1_60000_168000 0 4.710714e-08
I10248 n1_m1_60000_177600 0 4.625000e-08
I10249 n1_m1_60000_182400 0 6.787857e-08
I10250 n1_m1_60000_187200 0 9.391429e-08
I10251 n1_m1_60000_192000 0 1.085738e-07
I10252 n1_m1_60000_196800 0 6.282857e-08
I10253 n1_m1_60000_201600 0 2.150857e-07
I10254 n1_m1_60000_206400 0 9.728571e-08
I10255 n1_m1_60000_211200 0 8.046667e-08
I10256 n1_m1_60000_216000 0 2.495714e-07
I10257 n1_m1_60000_220800 0 6.664524e-08
I10258 n1_m1_60000_225600 0 4.290714e-08
I10259 n1_m1_60000_230400 0 2.534286e-08
I10260 n1_m1_60000_240000 0 3.038095e-09
I10261 n1_m1_60000_244800 0 4.353571e-08
I10262 n1_m1_60000_249600 0 6.432321e-08
I10263 n1_m1_60000_254400 0 5.910952e-08
I10264 n1_m1_60000_259200 0 9.285714e-08
I10265 n1_m1_60000_264000 0 7.604286e-08
I10266 n1_m1_60000_268800 0 1.071837e-08
I10267 n1_m1_60000_273600 0 1.013245e-07
I10268 n1_m1_60000_278400 0 1.501190e-07
I10269 n1_m1_60000_283200 0 1.757823e-07
I10270 n1_m1_60000_288000 0 6.083673e-08
I10271 n1_m1_60000_292800 0 7.327381e-08
I10272 n1_m1_60000_297600 0 9.185476e-08
I10273 n1_m1_60000_302400 0 7.103274e-08
I10274 n1_m1_60000_307200 0 1.027143e-07
I10275 n1_m1_60000_312000 0 2.202667e-07
I10276 n1_m1_60000_316800 0 2.544444e-08
I10277 n1_m1_60000_321600 0 4.936667e-08
I10278 n1_m1_60000_326400 0 6.282857e-08
I10279 n1_m1_60000_331200 0 1.254000e-07
I10280 n1_m1_60000_336000 0 1.284714e-07
I10281 n1_m1_60000_350400 0 1.080000e-08
I10282 n1_m1_60000_355200 0 4.285714e-08
I10283 n1_m1_60000_360000 0 2.307619e-08
I10284 n1_m1_60000_364800 0 1.088571e-08
I10285 n1_m1_60000_369600 0 8.019167e-08
I10286 n1_m1_60000_374400 0 4.951429e-08
I10287 n1_m1_60000_379200 0 5.569048e-08
I10288 n1_m1_60000_384000 0 7.160476e-08
I10289 n1_m1_60000_388800 0 7.208810e-08
I10290 n1_m1_60000_393600 0 3.587143e-08
I10291 n1_m1_60000_398400 0 3.520952e-08
I10292 n1_m1_60000_403200 0 1.188571e-08
I10293 n1_m1_60000_408000 0 3.075238e-08
I10294 n1_m1_60000_412800 0 4.518571e-08
I10295 n1_m1_60000_417600 0 6.930833e-08
I10296 n1_m1_60000_422400 0 8.542891e-08
I10297 n1_m1_60000_427200 0 1.153639e-07
I10298 n1_m1_60000_432000 0 4.344571e-07
I10299 n1_m1_60000_436800 0 9.996429e-08
I10300 n1_m1_88000_9600 0 2.350385e-07
I10301 n1_m1_88000_139200 0 8.571429e-08
I10302 n1_m1_88000_144000 0 5.060000e-08
I10303 n1_m1_88000_148800 0 3.973619e-08
I10304 n1_m1_88000_153600 0 9.014286e-08
I10305 n1_m1_88000_158400 0 1.557551e-08
I10306 n1_m1_88000_163200 0 1.180435e-07
I10307 n1_m1_88000_168000 0 5.447619e-08
I10308 n1_m1_88000_172800 0 1.158185e-07
I10309 n1_m1_88000_177600 0 9.112605e-09
I10310 n1_m1_88000_182400 0 7.086429e-08
I10311 n1_m1_88000_187200 0 5.688571e-08
I10312 n1_m1_88000_192000 0 4.372000e-07
I10313 n1_m1_88000_196800 0 1.080000e-08
I10314 n1_m1_88000_201600 0 2.900571e-08
I10315 n1_m1_88000_206400 0 3.099543e-07
I10316 n1_m1_88000_211200 0 5.054286e-08
I10317 n1_m1_88000_216000 0 5.558095e-08
I10318 n1_m1_88000_220800 0 3.959048e-08
I10319 n1_m1_88000_225600 0 4.473333e-08
I10320 n1_m1_88000_230400 0 2.495238e-08
I10321 n1_m1_88000_235200 0 8.141429e-08
I10322 n1_m1_88000_240000 0 6.630000e-08
I10323 n1_m1_88000_244800 0 1.188571e-08
I10324 n1_m1_88000_249600 0 3.851429e-08
I10325 n1_m1_88000_254400 0 3.318571e-08
I10326 n1_m1_88000_259200 0 5.320816e-08
I10327 n1_m1_88000_264000 0 6.552517e-08
I10328 n1_m1_88000_268800 0 1.291429e-08
I10329 n1_m1_88000_273600 0 2.931429e-08
I10330 n1_m1_88000_278400 0 1.014286e-08
I10331 n1_m1_88000_283200 0 3.546214e-08
I10332 n1_m1_88000_288000 0 5.476571e-08
I10333 n1_m1_88000_292800 0 5.087755e-08
I10334 n1_m1_88000_297600 0 5.812041e-08
I10335 n1_m1_88000_302400 0 1.363806e-07
I10336 n1_m1_88000_307200 0 5.396429e-08
I10337 n1_m1_88000_312000 0 6.056429e-08
I10338 n1_m1_88000_316800 0 3.763714e-08
I10339 n1_m1_88000_321600 0 7.622857e-08
I10340 n1_m1_88000_326400 0 9.580000e-08
I10341 n1_m1_88000_331200 0 4.299943e-07
I10342 n1_m1_88000_336000 0 4.806723e-07
I10343 n1_m1_88000_340800 0 8.771429e-08
I10344 n1_m1_88000_345600 0 5.441905e-08
I10345 n1_m1_88000_350400 0 4.775714e-08
I10346 n1_m1_88000_355200 0 8.076190e-09
I10347 n1_m1_88000_364800 0 2.186667e-08
I10348 n1_m1_88000_369600 0 1.338776e-08
I10349 n1_m1_88000_374400 0 6.014082e-08
I10350 n1_m1_88000_379200 0 2.238367e-07
I10351 n1_m1_88000_384000 0 3.487537e-07
I10352 n1_m1_88000_388800 0 5.838095e-08
I10353 n1_m1_88000_393600 0 1.301164e-07
I10354 n1_m1_88000_398400 0 3.578399e-08
I10355 n1_m1_88000_403200 0 1.341429e-08
I10356 n1_m1_88000_408000 0 9.430929e-08
I10357 n1_m1_88000_412800 0 2.828571e-08
I10358 n1_m1_88000_417600 0 6.650286e-08
I10359 n1_m1_88000_422400 0 1.418571e-08
I10360 n1_m1_88000_427200 0 5.128571e-08
I10361 n1_m1_88000_432000 0 1.255810e-07
I10362 n1_m1_88000_436800 0 8.926667e-08
I10363 n1_m1_88000_441600 0 6.887143e-08
I10364 n1_m1_116000_4800 0 6.584615e-09
I10365 n1_m1_116000_9600 0 5.487179e-10
I10366 n1_m1_116000_24000 0 8.660000e-08
I10367 n1_m1_116000_67200 0 5.195625e-07
I10368 n1_m1_116000_144000 0 9.710815e-07
I10369 n1_m1_116000_148800 0 4.881613e-07
I10370 n1_m1_116000_153600 0 8.762661e-07
I10371 n1_m1_116000_158400 0 7.886429e-08
I10372 n1_m1_116000_163200 0 1.989738e-07
I10373 n1_m1_116000_168000 0 1.706167e-07
I10374 n1_m1_116000_172800 0 5.573250e-07
I10375 n1_m1_116000_177600 0 3.816446e-07
I10376 n1_m1_116000_182400 0 1.434014e-06
I10377 n1_m1_116000_187200 0 2.426000e-06
I10378 n1_m1_116000_192000 0 3.452107e-07
I10379 n1_m1_116000_196800 0 1.003714e-07
I10380 n1_m1_116000_201600 0 3.012143e-07
I10381 n1_m1_116000_206400 0 6.761429e-08
I10382 n1_m1_116000_211200 0 1.447619e-07
I10383 n1_m1_116000_216000 0 2.221310e-07
I10384 n1_m1_116000_220800 0 7.292798e-08
I10385 n1_m1_116000_225600 0 4.303571e-07
I10386 n1_m1_116000_230400 0 1.511429e-07
I10387 n1_m1_116000_235200 0 9.353750e-08
I10388 n1_m1_116000_240000 0 4.096500e-07
I10389 n1_m1_116000_244800 0 3.200000e-07
I10390 n1_m1_116000_249600 0 5.277000e-06
I10391 n1_m1_116000_254400 0 2.497845e-06
I10392 n1_m1_116000_259200 0 1.377619e-06
I10393 n1_m1_116000_264000 0 2.101286e-06
I10394 n1_m1_116000_268800 0 1.129353e-06
I10395 n1_m1_116000_273600 0 2.268216e-06
I10396 n1_m1_116000_278400 0 1.858036e-06
I10397 n1_m1_116000_283200 0 1.109259e-06
I10398 n1_m1_116000_288000 0 2.449952e-06
I10399 n1_m1_116000_292800 0 9.321429e-07
I10400 n1_m1_116000_297600 0 2.130357e-06
I10401 n1_m1_116000_302400 0 6.808810e-07
I10402 n1_m1_116000_307200 0 2.163333e-06
I10403 n1_m1_116000_312000 0 3.001048e-06
I10404 n1_m1_116000_316800 0 7.394319e-07
I10405 n1_m1_116000_321600 0 1.361086e-06
I10406 n1_m1_116000_326400 0 2.913257e-06
I10407 n1_m1_116000_331200 0 2.156840e-06
I10408 n1_m1_116000_336000 0 4.114101e-06
I10409 n1_m1_116000_340800 0 1.143286e-06
I10410 n1_m1_116000_345600 0 2.250798e-07
I10411 n1_m1_116000_350400 0 1.032714e-07
I10412 n1_m1_116000_355200 0 1.902857e-08
I10413 n1_m1_116000_360000 0 1.280000e-07
I10414 n1_m1_116000_364800 0 2.264286e-07
I10415 n1_m1_116000_369600 0 1.395048e-07
I10416 n1_m1_116000_374400 0 3.741250e-07
I10417 n1_m1_116000_379200 0 1.296851e-07
I10418 n1_m1_116000_384000 0 1.979030e-07
I10419 n1_m1_116000_388800 0 1.250952e-07
I10420 n1_m1_116000_393600 0 2.423911e-07
I10421 n1_m1_116000_398400 0 1.425607e-07
I10422 n1_m1_116000_403200 0 2.488857e-07
I10423 n1_m1_116000_408000 0 1.831607e-07
I10424 n1_m1_116000_412800 0 1.699643e-07
I10425 n1_m1_116000_417600 0 3.007513e-07
I10426 n1_m1_116000_422400 0 1.430444e-07
I10427 n1_m1_116000_427200 0 2.158952e-07
I10428 n1_m1_116000_432000 0 3.424607e-07
I10429 n1_m1_116000_436800 0 1.259786e-07
I10430 n1_m1_116000_441600 0 8.272563e-07
I10431 n1_m1_116000_465600 0 8.357143e-08
I10432 n1_m1_116000_470400 0 1.392857e-08
I10433 n1_m1_116000_576000 0 7.384615e-09
I10434 n1_m1_116000_580800 0 9.729915e-08
I10435 n1_m1_116000_585600 0 3.311966e-08
I10436 n1_m1_172000_4800 0 1.316923e-08
I10437 n1_m1_172000_9600 0 4.455419e-07
I10438 n1_m1_172000_14400 0 6.214286e-08
I10439 n1_m1_172000_19200 0 8.285714e-08
I10440 n1_m1_172000_28800 0 3.625000e-07
I10441 n1_m1_172000_91200 0 3.188571e-08
I10442 n1_m1_172000_96000 0 5.115238e-08
I10443 n1_m1_172000_100800 0 5.275048e-08
I10444 n1_m1_172000_105600 0 7.255714e-08
I10445 n1_m1_172000_110400 0 9.696429e-08
I10446 n1_m1_172000_115200 0 1.500000e-08
I10447 n1_m1_172000_120000 0 1.458952e-07
I10448 n1_m1_172000_124800 0 2.807143e-08
I10449 n1_m1_172000_129600 0 2.305714e-08
I10450 n1_m1_172000_134400 0 2.078429e-07
I10451 n1_m1_172000_139200 0 3.585714e-08
I10452 n1_m1_172000_144000 0 6.951429e-08
I10453 n1_m1_172000_148800 0 1.148000e-07
I10454 n1_m1_172000_153600 0 3.242857e-08
I10455 n1_m1_172000_158400 0 3.180000e-08
I10456 n1_m1_172000_163200 0 8.182857e-08
I10457 n1_m1_172000_168000 0 1.955573e-07
I10458 n1_m1_172000_172800 0 9.178510e-08
I10459 n1_m1_172000_177600 0 5.208627e-07
I10460 n1_m1_172000_182400 0 8.166667e-07
I10461 n1_m1_172000_187200 0 7.314286e-08
I10462 n1_m1_172000_192000 0 9.851048e-08
I10463 n1_m1_172000_196800 0 6.618857e-08
I10464 n1_m1_172000_201600 0 1.771067e-07
I10465 n1_m1_172000_206400 0 3.147143e-08
I10466 n1_m1_172000_211200 0 1.620000e-08
I10467 n1_m1_172000_216000 0 5.242857e-08
I10468 n1_m1_172000_220800 0 5.187143e-08
I10469 n1_m1_172000_225600 0 3.128138e-06
I10470 n1_m1_172000_230400 0 1.840000e-08
I10471 n1_m1_172000_235200 0 1.380000e-08
I10472 n1_m1_172000_240000 0 7.435000e-08
I10473 n1_m1_172000_244800 0 8.419048e-09
I10474 n1_m1_172000_249600 0 1.293143e-07
I10475 n1_m1_172000_254400 0 2.220952e-07
I10476 n1_m1_172000_259200 0 2.005333e-08
I10477 n1_m1_172000_264000 0 8.671143e-08
I10478 n1_m1_172000_268800 0 4.112857e-08
I10479 n1_m1_172000_273600 0 6.317857e-07
I10480 n1_m1_172000_278400 0 7.357143e-07
I10481 n1_m1_172000_288000 0 3.521032e-07
I10482 n1_m1_172000_292800 0 2.265079e-07
I10483 n1_m1_172000_297600 0 4.687066e-07
I10484 n1_m1_172000_302400 0 8.347490e-08
I10485 n1_m1_172000_307200 0 4.817460e-07
I10486 n1_m1_172000_312000 0 8.551270e-07
I10487 n1_m1_172000_316800 0 2.361429e-07
I10488 n1_m1_172000_321600 0 6.908571e-07
I10489 n1_m1_172000_326400 0 6.171429e-08
I10490 n1_m1_172000_331200 0 5.100317e-07
I10491 n1_m1_172000_336000 0 6.562143e-07
I10492 n1_m1_172000_340800 0 6.114286e-08
I10493 n1_m1_172000_345600 0 8.230707e-07
I10494 n1_m1_172000_350400 0 3.873571e-07
I10495 n1_m1_172000_355200 0 1.800000e-07
I10496 n1_m1_172000_360000 0 1.222372e-06
I10497 n1_m1_172000_364800 0 3.521076e-07
I10498 n1_m1_172000_369600 0 1.021802e-06
I10499 n1_m1_172000_374400 0 5.533613e-07
I10500 n1_m1_172000_379200 0 3.567059e-07
I10501 n1_m1_172000_384000 0 3.465882e-07
I10502 n1_m1_172000_388800 0 1.580000e-07
I10503 n1_m1_172000_393600 0 2.380714e-07
I10504 n1_m1_172000_398400 0 4.302857e-08
I10505 n1_m1_172000_403200 0 3.740000e-08
I10506 n1_m1_172000_408000 0 8.064381e-08
I10507 n1_m1_172000_412800 0 3.026286e-08
I10508 n1_m1_172000_417600 0 7.028571e-08
I10509 n1_m1_172000_422400 0 3.761429e-08
I10510 n1_m1_172000_427200 0 5.700000e-08
I10511 n1_m1_172000_432000 0 2.361905e-08
I10512 n1_m1_172000_436800 0 4.504762e-08
I10513 n1_m1_172000_441600 0 7.257143e-09
I10514 n1_m1_172000_446400 0 1.814286e-08
I10515 n1_m1_172000_451200 0 3.420000e-08
I10516 n1_m1_172000_456000 0 9.451429e-08
I10517 n1_m1_172000_460800 0 9.926190e-08
I10518 n1_m1_172000_465600 0 8.657143e-09
I10519 n1_m1_172000_480000 0 1.249714e-07
I10520 n1_m1_172000_484800 0 2.082857e-08
I10521 n1_m1_172000_585600 0 7.133333e-09
I10522 n1_m1_200000_86400 0 1.708744e-07
I10523 n1_m1_200000_91200 0 1.275352e-07
I10524 n1_m1_200000_96000 0 7.306190e-08
I10525 n1_m1_200000_100800 0 3.321190e-08
I10526 n1_m1_200000_105600 0 3.763810e-08
I10527 n1_m1_200000_110400 0 6.658095e-08
I10528 n1_m1_200000_115200 0 1.014086e-07
I10529 n1_m1_200000_120000 0 2.590500e-07
I10530 n1_m1_200000_124800 0 3.682232e-07
I10531 n1_m1_200000_129600 0 1.492821e-07
I10532 n1_m1_200000_134400 0 4.009643e-08
I10533 n1_m1_200000_139200 0 2.257143e-08
I10534 n1_m1_200000_144000 0 1.529600e-07
I10535 n1_m1_200000_148800 0 1.606408e-08
I10536 n1_m1_200000_153600 0 7.987270e-08
I10537 n1_m1_200000_158400 0 1.611429e-08
I10538 n1_m1_200000_163200 0 7.693036e-08
I10539 n1_m1_200000_168000 0 1.337125e-07
I10540 n1_m1_200000_172800 0 9.714286e-08
I10541 n1_m1_200000_177600 0 1.462167e-07
I10542 n1_m1_200000_182400 0 1.097200e-07
I10543 n1_m1_200000_187200 0 2.742857e-08
I10544 n1_m1_200000_192000 0 7.207143e-08
I10545 n1_m1_200000_196800 0 8.632647e-07
I10546 n1_m1_200000_201600 0 1.507000e-07
I10547 n1_m1_200000_206400 0 7.991667e-08
I10548 n1_m1_200000_211200 0 5.410714e-08
I10549 n1_m1_200000_216000 0 3.338589e-07
I10550 n1_m1_200000_220800 0 1.443571e-07
I10551 n1_m1_200000_225600 0 2.971429e-09
I10552 n1_m1_200000_230400 0 5.497143e-08
I10553 n1_m1_200000_235200 0 5.306571e-07
I10554 n1_m1_200000_240000 0 1.400000e-08
I10555 n1_m1_200000_244800 0 2.655714e-08
I10556 n1_m1_200000_249600 0 1.466810e-07
I10557 n1_m1_200000_254400 0 1.383810e-08
I10558 n1_m1_200000_259200 0 7.867619e-07
I10559 n1_m1_200000_264000 0 6.376071e-07
I10560 n1_m1_200000_268800 0 6.202500e-08
I10561 n1_m1_200000_273600 0 9.286718e-07
I10562 n1_m1_200000_278400 0 8.827510e-07
I10563 n1_m1_200000_283200 0 6.140000e-08
I10564 n1_m1_200000_288000 0 2.583673e-07
I10565 n1_m1_200000_292800 0 2.544303e-07
I10566 n1_m1_200000_297600 0 2.222143e-07
I10567 n1_m1_200000_302400 0 1.185357e-07
I10568 n1_m1_200000_307200 0 7.863095e-08
I10569 n1_m1_200000_312000 0 6.498095e-08
I10570 n1_m1_200000_316800 0 5.600000e-08
I10571 n1_m1_200000_321600 0 1.124000e-07
I10572 n1_m1_200000_326400 0 4.828571e-08
I10573 n1_m1_200000_331200 0 7.534643e-08
I10574 n1_m1_200000_336000 0 7.216190e-08
I10575 n1_m1_200000_340800 0 5.738095e-08
I10576 n1_m1_200000_345600 0 7.764286e-08
I10577 n1_m1_200000_350400 0 1.170000e-07
I10578 n1_m1_200000_355200 0 4.200000e-08
I10579 n1_m1_200000_360000 0 3.820000e-07
I10580 n1_m1_200000_364800 0 2.058810e-07
I10581 n1_m1_200000_369600 0 6.654762e-07
I10582 n1_m1_200000_374400 0 5.714286e-08
I10583 n1_m1_200000_379200 0 4.323333e-07
I10584 n1_m1_200000_384000 0 1.213386e-06
I10585 n1_m1_200000_388800 0 3.905294e-07
I10586 n1_m1_200000_393600 0 2.083097e-07
I10587 n1_m1_200000_398400 0 3.012076e-07
I10588 n1_m1_200000_403200 0 2.851071e-08
I10589 n1_m1_200000_408000 0 3.405866e-07
I10590 n1_m1_200000_412800 0 1.925714e-07
I10591 n1_m1_200000_417600 0 1.003310e-07
I10592 n1_m1_200000_422400 0 4.643929e-08
I10593 n1_m1_200000_427200 0 4.435714e-09
I10594 n1_m1_200000_432000 0 6.075000e-08
I10595 n1_m1_200000_436800 0 6.955357e-08
I10596 n1_m1_200000_441600 0 8.197619e-08
I10597 n1_m1_200000_446400 0 9.461190e-08
I10598 n1_m1_200000_451200 0 9.102571e-08
I10599 n1_m1_200000_456000 0 7.922143e-09
I10600 n1_m1_200000_460800 0 5.937679e-08
I10601 n1_m1_200000_465600 0 1.026286e-07
I10602 n1_m1_200000_484800 0 7.834524e-08
I10603 n1_m1_200000_489600 0 7.426667e-08
I10604 n1_m1_200000_494400 0 3.440000e-08
I10605 n1_m1_200000_499200 0 1.059190e-07
I10606 n1_m1_200000_504000 0 6.058333e-08
I10607 n1_m1_200000_508800 0 6.082857e-08
I10608 n1_m1_200000_513600 0 3.062381e-08
I10609 n1_m1_200000_518400 0 5.556538e-08
I10610 n1_m1_200000_523200 0 8.553462e-08
I10611 n1_m1_200000_528000 0 1.455000e-07
I10612 n1_m1_200000_532800 0 3.704308e-08
I10613 n1_m1_200000_537600 0 8.951436e-08
I10614 n1_m1_200000_542400 0 1.277692e-07
I10615 n1_m1_200000_547200 0 3.020308e-08
I10616 n1_m1_200000_552000 0 7.879923e-08
I10617 n1_m1_200000_556800 0 3.719103e-08
I10618 n1_m1_200000_561600 0 3.870000e-08
I10619 n1_m1_228000_9600 0 1.009375e-07
I10620 n1_m1_228000_28800 0 3.098571e-08
I10621 n1_m1_228000_33600 0 1.402694e-07
I10622 n1_m1_228000_38400 0 4.976154e-08
I10623 n1_m1_228000_43200 0 6.130000e-08
I10624 n1_m1_228000_48000 0 9.480000e-08
I10625 n1_m1_228000_52800 0 4.065000e-08
I10626 n1_m1_228000_57600 0 9.825667e-08
I10627 n1_m1_228000_62400 0 1.917524e-07
I10628 n1_m1_228000_67200 0 1.122643e-07
I10629 n1_m1_228000_72000 0 8.999391e-08
I10630 n1_m1_228000_76800 0 3.177007e-07
I10631 n1_m1_228000_81600 0 2.894250e-07
I10632 n1_m1_228000_86400 0 1.080440e-08
I10633 n1_m1_228000_91200 0 5.329560e-08
I10634 n1_m1_228000_96000 0 7.042143e-08
I10635 n1_m1_228000_100800 0 1.991633e-08
I10636 n1_m1_228000_105600 0 1.073551e-07
I10637 n1_m1_228000_110400 0 7.471429e-08
I10638 n1_m1_228000_115200 0 7.648250e-08
I10639 n1_m1_228000_120000 0 9.492929e-08
I10640 n1_m1_228000_124800 0 7.365714e-08
I10641 n1_m1_228000_129600 0 9.504735e-08
I10642 n1_m1_228000_134400 0 8.603265e-08
I10643 n1_m1_228000_139200 0 7.392857e-08
I10644 n1_m1_228000_144000 0 1.662857e-08
I10645 n1_m1_228000_148800 0 6.285714e-09
I10646 n1_m1_228000_153600 0 4.957796e-08
I10647 n1_m1_228000_158400 0 4.156156e-08
I10648 n1_m1_228000_163200 0 1.318237e-07
I10649 n1_m1_228000_168000 0 2.367647e-07
I10650 n1_m1_228000_172800 0 4.139496e-08
I10651 n1_m1_228000_177600 0 1.394286e-07
I10652 n1_m1_228000_182400 0 5.553501e-07
I10653 n1_m1_228000_187200 0 5.315593e-07
I10654 n1_m1_228000_192000 0 1.675350e-07
I10655 n1_m1_228000_196800 0 1.637143e-07
I10656 n1_m1_228000_201600 0 5.393429e-07
I10657 n1_m1_228000_206400 0 4.787487e-07
I10658 n1_m1_228000_211200 0 2.391429e-08
I10659 n1_m1_228000_216000 0 1.610643e-07
I10660 n1_m1_228000_220800 0 2.207143e-08
I10661 n1_m1_228000_225600 0 9.170857e-08
I10662 n1_m1_228000_230400 0 2.715143e-08
I10663 n1_m1_228000_235200 0 1.627500e-08
I10664 n1_m1_228000_240000 0 7.806500e-08
I10665 n1_m1_228000_244800 0 5.614405e-08
I10666 n1_m1_228000_249600 0 1.445295e-07
I10667 n1_m1_228000_254400 0 3.160524e-08
I10668 n1_m1_228000_259200 0 9.540000e-08
I10669 n1_m1_228000_264000 0 6.330238e-08
I10670 n1_m1_228000_268800 0 2.664929e-07
I10671 n1_m1_228000_273600 0 4.315714e-07
I10672 n1_m1_228000_278400 0 3.047143e-07
I10673 n1_m1_228000_283200 0 1.577000e-07
I10674 n1_m1_228000_288000 0 9.632286e-07
I10675 n1_m1_228000_292800 0 1.029286e-07
I10676 n1_m1_228000_297600 0 4.510343e-07
I10677 n1_m1_228000_302400 0 2.055333e-08
I10678 n1_m1_228000_307200 0 5.678571e-08
I10679 n1_m1_228000_312000 0 5.559643e-08
I10680 n1_m1_228000_316800 0 2.072302e-08
I10681 n1_m1_228000_321600 0 2.183838e-07
I10682 n1_m1_228000_326400 0 8.800000e-08
I10683 n1_m1_228000_331200 0 7.132321e-08
I10684 n1_m1_228000_336000 0 5.914286e-08
I10685 n1_m1_228000_340800 0 2.381008e-07
I10686 n1_m1_228000_345600 0 1.596739e-07
I10687 n1_m1_228000_350400 0 1.542964e-07
I10688 n1_m1_228000_355200 0 1.234300e-06
I10689 n1_m1_228000_360000 0 7.438619e-07
I10690 n1_m1_228000_364800 0 3.163420e-07
I10691 n1_m1_228000_369600 0 4.090056e-07
I10692 n1_m1_228000_374400 0 3.933036e-08
I10693 n1_m1_228000_379200 0 3.327000e-08
I10694 n1_m1_228000_384000 0 2.270476e-08
I10695 n1_m1_228000_388800 0 4.321607e-08
I10696 n1_m1_228000_393600 0 5.688750e-08
I10697 n1_m1_228000_398400 0 3.385459e-08
I10698 n1_m1_228000_403200 0 1.273469e-08
I10699 n1_m1_228000_408000 0 5.200000e-08
I10700 n1_m1_228000_412800 0 1.291429e-07
I10701 n1_m1_228000_417600 0 3.718571e-07
I10702 n1_m1_228000_422400 0 3.914286e-07
I10703 n1_m1_228000_427200 0 1.405714e-07
I10704 n1_m1_228000_432000 0 6.800000e-09
I10705 n1_m1_228000_436800 0 3.386286e-08
I10706 n1_m1_228000_441600 0 3.109071e-07
I10707 n1_m1_228000_446400 0 3.169643e-09
I10708 n1_m1_228000_451200 0 4.879786e-08
I10709 n1_m1_228000_456000 0 3.280000e-08
I10710 n1_m1_228000_460800 0 3.122619e-08
I10711 n1_m1_228000_465600 0 3.465714e-07
I10712 n1_m1_228000_470400 0 5.178571e-08
I10713 n1_m1_228000_475200 0 2.415476e-08
I10714 n1_m1_228000_480000 0 1.096969e-07
I10715 n1_m1_228000_484800 0 5.905000e-08
I10716 n1_m1_228000_489600 0 1.402071e-07
I10717 n1_m1_228000_494400 0 9.271429e-08
I10718 n1_m1_228000_499200 0 1.607619e-07
I10719 n1_m1_228000_504000 0 3.997581e-07
I10720 n1_m1_228000_508800 0 1.052600e-07
I10721 n1_m1_228000_513600 0 1.966786e-07
I10722 n1_m1_228000_518400 0 6.076667e-08
I10723 n1_m1_228000_523200 0 4.534286e-08
I10724 n1_m1_228000_528000 0 2.121857e-07
I10725 n1_m1_228000_532800 0 2.427523e-07
I10726 n1_m1_228000_537600 0 1.243744e-07
I10727 n1_m1_228000_542400 0 5.764744e-08
I10728 n1_m1_228000_547200 0 2.860385e-08
I10729 n1_m1_228000_552000 0 3.742308e-08
I10730 n1_m1_228000_556800 0 7.582308e-08
I10731 n1_m1_228000_561600 0 5.848762e-08
I10732 n1_m1_228000_566400 0 3.377802e-08
I10733 n1_m1_228000_571200 0 3.849103e-08
I10734 n1_m1_228000_576000 0 3.000000e-07
I10735 n1_m1_256000_4800 0 1.316923e-08
I10736 n1_m1_256000_9600 0 1.097436e-09
I10737 n1_m1_256000_14400 0 3.968750e-07
I10738 n1_m1_256000_19200 0 8.914286e-08
I10739 n1_m1_256000_24000 0 1.439571e-07
I10740 n1_m1_256000_28800 0 2.112857e-08
I10741 n1_m1_256000_33600 0 2.817143e-08
I10742 n1_m1_256000_38400 0 2.200000e-08
I10743 n1_m1_256000_43200 0 3.940000e-08
I10744 n1_m1_256000_48000 0 1.362571e-07
I10745 n1_m1_256000_52800 0 1.396714e-07
I10746 n1_m1_256000_57600 0 6.397952e-08
I10747 n1_m1_256000_62400 0 2.635714e-08
I10748 n1_m1_256000_67200 0 1.090000e-07
I10749 n1_m1_256000_72000 0 1.405179e-07
I10750 n1_m1_256000_76800 0 1.394440e-07
I10751 n1_m1_256000_81600 0 1.428571e-07
I10752 n1_m1_256000_86400 0 7.203297e-08
I10753 n1_m1_256000_91200 0 3.192527e-07
I10754 n1_m1_256000_96000 0 4.873333e-07
I10755 n1_m1_256000_100800 0 3.636303e-07
I10756 n1_m1_256000_105600 0 3.075630e-07
I10757 n1_m1_256000_110400 0 1.946218e-07
I10758 n1_m1_256000_115200 0 4.976403e-07
I10759 n1_m1_256000_120000 0 6.050420e-07
I10760 n1_m1_256000_124800 0 3.252101e-07
I10761 n1_m1_256000_129600 0 7.824650e-07
I10762 n1_m1_256000_134400 0 1.066508e-06
I10763 n1_m1_256000_139200 0 1.954286e-06
I10764 n1_m1_256000_144000 0 2.937143e-06
I10765 n1_m1_256000_148800 0 4.712381e-07
I10766 n1_m1_256000_153600 0 1.199683e-06
I10767 n1_m1_256000_158400 0 9.721905e-07
I10768 n1_m1_256000_163200 0 7.003571e-07
I10769 n1_m1_256000_168000 0 7.992976e-07
I10770 n1_m1_256000_172800 0 5.880952e-07
I10771 n1_m1_256000_177600 0 1.299743e-06
I10772 n1_m1_256000_182400 0 1.632294e-07
I10773 n1_m1_256000_187200 0 1.496234e-07
I10774 n1_m1_256000_192000 0 1.592835e-07
I10775 n1_m1_256000_196800 0 4.378571e-07
I10776 n1_m1_256000_201600 0 4.760000e-07
I10777 n1_m1_256000_206400 0 1.161365e-06
I10778 n1_m1_256000_211200 0 7.361111e-07
I10779 n1_m1_256000_216000 0 1.107247e-06
I10780 n1_m1_256000_220800 0 2.075188e-07
I10781 n1_m1_256000_225600 0 2.790476e-07
I10782 n1_m1_256000_230400 0 5.412698e-07
I10783 n1_m1_256000_235200 0 4.059524e-07
I10784 n1_m1_256000_240000 0 7.780159e-07
I10785 n1_m1_256000_244800 0 2.731746e-07
I10786 n1_m1_256000_249600 0 8.314454e-07
I10787 n1_m1_256000_254400 0 2.282353e-07
I10788 n1_m1_256000_259200 0 5.989916e-07
I10789 n1_m1_256000_264000 0 1.082951e-06
I10790 n1_m1_256000_268800 0 2.560317e-07
I10791 n1_m1_256000_273600 0 7.954160e-07
I10792 n1_m1_256000_278400 0 6.690476e-07
I10793 n1_m1_256000_283200 0 7.870857e-07
I10794 n1_m1_256000_288000 0 7.555798e-07
I10795 n1_m1_256000_292800 0 4.816807e-07
I10796 n1_m1_256000_297600 0 1.496786e-07
I10797 n1_m1_256000_302400 0 1.608162e-07
I10798 n1_m1_256000_307200 0 1.293393e-07
I10799 n1_m1_256000_312000 0 1.480095e-07
I10800 n1_m1_256000_316800 0 3.704286e-08
I10801 n1_m1_256000_321600 0 3.150000e-08
I10802 n1_m1_256000_326400 0 2.074286e-08
I10803 n1_m1_256000_331200 0 6.322714e-08
I10804 n1_m1_256000_336000 0 7.304694e-08
I10805 n1_m1_256000_340800 0 3.676735e-08
I10806 n1_m1_256000_345600 0 2.000000e-08
I10807 n1_m1_256000_350400 0 2.386143e-07
I10808 n1_m1_256000_355200 0 2.685857e-07
I10809 n1_m1_256000_360000 0 2.635833e-07
I10810 n1_m1_256000_364800 0 1.092444e-07
I10811 n1_m1_256000_369600 0 8.615714e-07
I10812 n1_m1_256000_374400 0 5.290000e-07
I10813 n1_m1_256000_379200 0 3.814204e-07
I10814 n1_m1_256000_384000 0 2.451161e-07
I10815 n1_m1_256000_388800 0 5.060606e-07
I10816 n1_m1_256000_393600 0 6.713143e-07
I10817 n1_m1_256000_398400 0 5.326476e-07
I10818 n1_m1_256000_403200 0 2.405714e-07
I10819 n1_m1_256000_408000 0 1.631898e-06
I10820 n1_m1_256000_412800 0 4.463878e-07
I10821 n1_m1_256000_417600 0 8.110000e-07
I10822 n1_m1_256000_422400 0 1.038095e-07
I10823 n1_m1_256000_427200 0 6.228571e-07
I10824 n1_m1_256000_432000 0 3.557143e-07
I10825 n1_m1_256000_436800 0 1.984286e-07
I10826 n1_m1_256000_441600 0 1.748905e-06
I10827 n1_m1_256000_446400 0 1.320952e-06
I10828 n1_m1_256000_451200 0 8.895048e-07
I10829 n1_m1_256000_456000 0 8.227429e-07
I10830 n1_m1_256000_460800 0 5.142857e-07
I10831 n1_m1_256000_465600 0 6.305556e-07
I10832 n1_m1_256000_470400 0 2.552381e-08
I10833 n1_m1_256000_475200 0 1.673016e-07
I10834 n1_m1_256000_480000 0 7.919010e-07
I10835 n1_m1_256000_484800 0 1.684930e-07
I10836 n1_m1_256000_489600 0 6.399953e-07
I10837 n1_m1_256000_494400 0 1.567513e-07
I10838 n1_m1_256000_499200 0 6.377143e-08
I10839 n1_m1_256000_504000 0 7.524286e-07
I10840 n1_m1_256000_508800 0 2.413714e-08
I10841 n1_m1_256000_513600 0 9.279619e-08
I10842 n1_m1_256000_518400 0 4.338462e-09
I10843 n1_m1_256000_523200 0 5.061538e-09
I10844 n1_m1_256000_528000 0 8.911000e-08
I10845 n1_m1_256000_532800 0 8.523077e-08
I10846 n1_m1_256000_537600 0 1.581359e-07
I10847 n1_m1_256000_542400 0 2.100000e-07
I10848 n1_m1_256000_547200 0 1.430000e-07
I10849 n1_m1_256000_552000 0 5.900000e-08
I10850 n1_m1_256000_561600 0 1.971429e-08
I10851 n1_m1_256000_566400 0 1.182857e-07
I10852 n1_m1_256000_571200 0 4.940000e-08
I10853 n1_m1_256000_576000 0 1.490000e-08
I10854 n1_m1_284000_4800 0 3.621538e-08
I10855 n1_m1_284000_9600 0 1.741795e-08
I10856 n1_m1_284000_19200 0 8.800000e-08
I10857 n1_m1_284000_24000 0 1.566667e-07
I10858 n1_m1_284000_28800 0 6.027619e-08
I10859 n1_m1_284000_33600 0 7.432381e-08
I10860 n1_m1_284000_43200 0 8.850769e-08
I10861 n1_m1_284000_48000 0 1.045328e-07
I10862 n1_m1_284000_52800 0 2.164997e-07
I10863 n1_m1_284000_57600 0 5.548265e-07
I10864 n1_m1_284000_62400 0 3.485714e-08
I10865 n1_m1_284000_67200 0 8.359286e-08
I10866 n1_m1_284000_72000 0 5.336154e-08
I10867 n1_m1_284000_76800 0 1.273670e-07
I10868 n1_m1_284000_81600 0 3.199714e-07
I10869 n1_m1_284000_86400 0 1.849253e-07
I10870 n1_m1_284000_91200 0 1.324747e-07
I10871 n1_m1_284000_96000 0 2.550071e-07
I10872 n1_m1_284000_100800 0 2.856000e-06
I10873 n1_m1_284000_105600 0 1.438786e-06
I10874 n1_m1_284000_110400 0 3.007381e-07
I10875 n1_m1_284000_115200 0 3.542143e-08
I10876 n1_m1_284000_120000 0 1.516429e-06
I10877 n1_m1_284000_124800 0 6.627976e-07
I10878 n1_m1_284000_129600 0 1.474452e-06
I10879 n1_m1_284000_134400 0 2.624774e-06
I10880 n1_m1_284000_139200 0 1.815714e-06
I10881 n1_m1_284000_144000 0 4.540659e-06
I10882 n1_m1_284000_148800 0 1.515538e-06
I10883 n1_m1_284000_153600 0 1.826429e-06
I10884 n1_m1_284000_158400 0 2.525571e-06
I10885 n1_m1_284000_163200 0 1.770643e-06
I10886 n1_m1_284000_168000 0 2.905357e-06
I10887 n1_m1_284000_172800 0 2.164095e-06
I10888 n1_m1_284000_177600 0 8.582143e-07
I10889 n1_m1_284000_182400 0 1.144286e-06
I10890 n1_m1_284000_187200 0 8.139127e-07
I10891 n1_m1_284000_192000 0 1.284107e-06
I10892 n1_m1_284000_196800 0 1.372524e-06
I10893 n1_m1_284000_201600 0 5.224762e-07
I10894 n1_m1_284000_206400 0 3.386000e-07
I10895 n1_m1_284000_211200 0 3.412738e-07
I10896 n1_m1_284000_216000 0 3.939952e-07
I10897 n1_m1_284000_220800 0 3.331143e-07
I10898 n1_m1_284000_225600 0 2.801905e-07
I10899 n1_m1_284000_230400 0 1.080286e-07
I10900 n1_m1_284000_235200 0 1.006143e-07
I10901 n1_m1_284000_240000 0 1.429690e-06
I10902 n1_m1_284000_244800 0 1.360667e-07
I10903 n1_m1_284000_249600 0 6.988714e-07
I10904 n1_m1_284000_254400 0 2.091744e-07
I10905 n1_m1_284000_259200 0 1.479714e-07
I10906 n1_m1_284000_264000 0 1.744071e-07
I10907 n1_m1_284000_268800 0 2.108540e-07
I10908 n1_m1_284000_273600 0 8.859122e-07
I10909 n1_m1_284000_278400 0 3.096429e-06
I10910 n1_m1_284000_283200 0 1.113479e-06
I10911 n1_m1_284000_288000 0 8.987365e-07
I10912 n1_m1_284000_292800 0 4.738095e-07
I10913 n1_m1_284000_297600 0 1.364095e-06
I10914 n1_m1_284000_302400 0 3.536650e-07
I10915 n1_m1_284000_307200 0 7.370612e-07
I10916 n1_m1_284000_312000 0 7.171303e-07
I10917 n1_m1_284000_316800 0 2.107338e-07
I10918 n1_m1_284000_321600 0 4.508214e-07
I10919 n1_m1_284000_326400 0 6.634524e-07
I10920 n1_m1_284000_331200 0 2.266976e-07
I10921 n1_m1_284000_336000 0 2.324381e-07
I10922 n1_m1_284000_340800 0 9.020816e-08
I10923 n1_m1_284000_345600 0 1.646633e-07
I10924 n1_m1_284000_350400 0 6.892143e-08
I10925 n1_m1_284000_355200 0 5.801429e-08
I10926 n1_m1_284000_360000 0 3.545268e-07
I10927 n1_m1_284000_364800 0 9.232500e-08
I10928 n1_m1_284000_369600 0 1.323643e-07
I10929 n1_m1_284000_374400 0 7.588571e-08
I10930 n1_m1_284000_379200 0 3.274766e-07
I10931 n1_m1_284000_384000 0 2.092113e-07
I10932 n1_m1_284000_388800 0 2.183571e-07
I10933 n1_m1_284000_393600 0 1.669328e-07
I10934 n1_m1_284000_398400 0 1.810231e-07
I10935 n1_m1_284000_403200 0 9.941905e-07
I10936 n1_m1_284000_408000 0 3.858738e-06
I10937 n1_m1_284000_412800 0 8.914286e-07
I10938 n1_m1_284000_417600 0 1.322749e-06
I10939 n1_m1_284000_422400 0 1.050276e-06
I10940 n1_m1_284000_427200 0 2.155347e-06
I10941 n1_m1_284000_432000 0 3.044839e-06
I10942 n1_m1_284000_436800 0 1.056357e-06
I10943 n1_m1_284000_441600 0 2.483857e-06
I10944 n1_m1_284000_446400 0 4.689286e-07
I10945 n1_m1_284000_451200 0 7.560952e-07
I10946 n1_m1_284000_456000 0 1.783750e-06
I10947 n1_m1_284000_460800 0 2.311161e-06
I10948 n1_m1_284000_465600 0 1.716667e-06
I10949 n1_m1_284000_470400 0 1.198742e-06
I10950 n1_m1_284000_475200 0 1.064286e-07
I10951 n1_m1_284000_480000 0 1.848095e-06
I10952 n1_m1_284000_484800 0 2.589524e-07
I10953 n1_m1_284000_489600 0 3.842857e-07
I10954 n1_m1_284000_513600 0 1.147875e-06
I10955 n1_m1_284000_518400 0 4.459154e-06
I10956 n1_m1_284000_523200 0 1.012179e-06
I10957 n1_m1_284000_528000 0 4.306667e-07
I10958 n1_m1_284000_532800 0 9.613782e-07
I10959 n1_m1_284000_537600 0 7.023590e-07
I10960 n1_m1_284000_542400 0 1.664462e-07
I10961 n1_m1_284000_547200 0 2.978673e-07
I10962 n1_m1_284000_552000 0 9.647436e-08
I10963 n1_m1_284000_561600 0 2.598214e-08
I10964 n1_m1_284000_566400 0 1.558929e-07
I10965 n1_m1_284000_576000 0 2.815263e-07
I10966 n1_m1_284000_580800 0 7.924806e-07
I10967 n1_m1_284000_585600 0 1.498718e-07
I10968 n1_m1_340000_4800 0 2.730070e-07
I10969 n1_m1_340000_9600 0 2.083756e-07
I10970 n1_m1_340000_57600 0 7.510000e-08
I10971 n1_m1_340000_62400 0 1.368381e-08
I10972 n1_m1_340000_67200 0 1.026286e-08
I10973 n1_m1_340000_72000 0 5.358997e-07
I10974 n1_m1_340000_76800 0 1.158538e-07
I10975 n1_m1_340000_81600 0 7.017143e-08
I10976 n1_m1_340000_86400 0 5.766703e-08
I10977 n1_m1_340000_91200 0 9.894725e-08
I10978 n1_m1_340000_96000 0 1.035410e-07
I10979 n1_m1_340000_100800 0 8.422381e-08
I10980 n1_m1_340000_105600 0 1.420200e-07
I10981 n1_m1_340000_110400 0 6.362381e-08
I10982 n1_m1_340000_115200 0 5.902095e-08
I10983 n1_m1_340000_120000 0 1.337143e-07
I10984 n1_m1_340000_124800 0 1.296939e-07
I10985 n1_m1_340000_129600 0 1.279214e-07
I10986 n1_m1_340000_134400 0 2.462017e-07
I10987 n1_m1_340000_139200 0 4.566387e-07
I10988 n1_m1_340000_144000 0 1.419583e-06
I10989 n1_m1_340000_148800 0 1.458833e-06
I10990 n1_m1_340000_153600 0 8.542143e-07
I10991 n1_m1_340000_158400 0 1.975385e-06
I10992 n1_m1_340000_163200 0 1.379745e-06
I10993 n1_m1_340000_168000 0 1.678357e-06
I10994 n1_m1_340000_172800 0 1.948571e-06
I10995 n1_m1_340000_177600 0 1.458857e-06
I10996 n1_m1_340000_182400 0 1.114286e-07
I10997 n1_m1_340000_187200 0 2.737143e-07
I10998 n1_m1_340000_192000 0 1.259667e-06
I10999 n1_m1_340000_196800 0 9.497143e-08
I11000 n1_m1_340000_201600 0 2.102143e-07
I11001 n1_m1_340000_206400 0 3.531429e-08
I11002 n1_m1_340000_211200 0 6.720000e-08
I11003 n1_m1_340000_216000 0 3.454857e-07
I11004 n1_m1_340000_220800 0 1.139143e-07
I11005 n1_m1_340000_225600 0 1.034089e-07
I11006 n1_m1_340000_230400 0 1.049714e-07
I11007 n1_m1_340000_235200 0 4.112190e-08
I11008 n1_m1_340000_240000 0 4.262622e-07
I11009 n1_m1_340000_244800 0 7.974286e-08
I11010 n1_m1_340000_249600 0 3.496000e-07
I11011 n1_m1_340000_254400 0 2.309272e-07
I11012 n1_m1_340000_259200 0 8.999184e-08
I11013 n1_m1_340000_264000 0 9.367143e-08
I11014 n1_m1_340000_268800 0 4.175013e-07
I11015 n1_m1_340000_273600 0 5.156857e-07
I11016 n1_m1_340000_283200 0 3.346869e-07
I11017 n1_m1_340000_288000 0 7.361247e-08
I11018 n1_m1_340000_292800 0 3.985333e-07
I11019 n1_m1_340000_297600 0 1.735914e-06
I11020 n1_m1_340000_302400 0 8.101704e-07
I11021 n1_m1_340000_307200 0 5.385714e-07
I11022 n1_m1_340000_312000 0 3.508571e-07
I11023 n1_m1_340000_316800 0 4.826826e-07
I11024 n1_m1_340000_321600 0 5.338929e-07
I11025 n1_m1_340000_326400 0 3.451619e-07
I11026 n1_m1_340000_331200 0 4.749104e-07
I11027 n1_m1_340000_336000 0 1.013156e-06
I11028 n1_m1_340000_340800 0 2.084034e-07
I11029 n1_m1_340000_345600 0 2.479168e-07
I11030 n1_m1_340000_350400 0 2.460000e-08
I11031 n1_m1_340000_355200 0 9.658857e-08
I11032 n1_m1_340000_360000 0 1.206314e-07
I11033 n1_m1_340000_364800 0 2.665905e-07
I11034 n1_m1_340000_369600 0 1.676698e-07
I11035 n1_m1_340000_374400 0 8.180558e-07
I11036 n1_m1_340000_379200 0 5.439184e-08
I11037 n1_m1_340000_384000 0 1.908417e-06
I11038 n1_m1_340000_388800 0 1.425549e-06
I11039 n1_m1_340000_393600 0 7.096667e-08
I11040 n1_m1_340000_408000 0 7.540000e-08
I11041 n1_m1_340000_412800 0 3.051429e-08
I11042 n1_m1_340000_417600 0 8.029534e-07
I11043 n1_m1_340000_422400 0 2.731842e-07
I11044 n1_m1_340000_427200 0 4.129286e-07
I11045 n1_m1_340000_432000 0 6.714709e-07
I11046 n1_m1_340000_436800 0 3.066143e-06
I11047 n1_m1_340000_441600 0 1.188857e-06
I11048 n1_m1_340000_446400 0 5.158730e-07
I11049 n1_m1_340000_451200 0 9.545294e-07
I11050 n1_m1_340000_456000 0 7.676022e-07
I11051 n1_m1_340000_460800 0 4.829972e-07
I11052 n1_m1_340000_465600 0 7.706387e-07
I11053 n1_m1_340000_470400 0 4.745042e-07
I11054 n1_m1_340000_475200 0 2.469422e-07
I11055 n1_m1_340000_480000 0 1.120563e-07
I11056 n1_m1_340000_484800 0 7.085714e-08
I11057 n1_m1_340000_489600 0 3.681219e-07
I11058 n1_m1_340000_494400 0 1.684152e-07
I11059 n1_m1_340000_499200 0 5.376310e-08
I11060 n1_m1_340000_504000 0 1.068152e-07
I11061 n1_m1_340000_508800 0 1.170457e-07
I11062 n1_m1_340000_513600 0 7.500000e-08
I11063 n1_m1_340000_518400 0 6.166923e-08
I11064 n1_m1_340000_523200 0 8.857363e-08
I11065 n1_m1_340000_528000 0 9.474945e-08
I11066 n1_m1_340000_532800 0 8.172308e-08
I11067 n1_m1_340000_537600 0 6.978974e-08
I11068 n1_m1_340000_542400 0 1.665385e-08
I11069 n1_m1_340000_547200 0 6.100000e-08
I11070 n1_m1_340000_552000 0 5.858571e-08
I11071 n1_m1_340000_556800 0 2.930000e-08
I11072 n1_m1_340000_561600 0 4.005000e-08
I11073 n1_m1_340000_576000 0 3.096875e-07
I11074 n1_m1_340000_580800 0 1.114615e-07
I11075 n1_m1_340000_585600 0 6.966346e-08
I11076 n1_m1_368000_9600 0 2.690625e-07
I11077 n1_m1_368000_14400 0 4.828571e-08
I11078 n1_m1_368000_48000 0 1.714639e-07
I11079 n1_m1_368000_52800 0 5.459796e-08
I11080 n1_m1_368000_57600 0 3.637429e-08
I11081 n1_m1_368000_62400 0 9.081714e-08
I11082 n1_m1_368000_67200 0 4.301190e-08
I11083 n1_m1_368000_72000 0 2.677147e-07
I11084 n1_m1_368000_76800 0 2.075566e-07
I11085 n1_m1_368000_81600 0 1.910571e-07
I11086 n1_m1_368000_86400 0 7.802286e-08
I11087 n1_m1_368000_91200 0 2.474286e-08
I11088 n1_m1_368000_96000 0 9.375714e-08
I11089 n1_m1_368000_100800 0 5.228612e-08
I11090 n1_m1_368000_105600 0 5.843102e-08
I11091 n1_m1_368000_110400 0 1.040857e-07
I11092 n1_m1_368000_115200 0 6.831429e-08
I11093 n1_m1_368000_120000 0 8.211905e-08
I11094 n1_m1_368000_124800 0 6.915476e-08
I11095 n1_m1_368000_129600 0 7.282857e-08
I11096 n1_m1_368000_134400 0 1.728571e-07
I11097 n1_m1_368000_139200 0 3.764286e-08
I11098 n1_m1_368000_144000 0 8.417500e-08
I11099 n1_m1_368000_148800 0 4.772095e-07
I11100 n1_m1_368000_153600 0 1.724034e-06
I11101 n1_m1_368000_163200 0 4.716000e-08
I11102 n1_m1_368000_168000 0 3.293333e-08
I11103 n1_m1_368000_172800 0 2.562286e-08
I11104 n1_m1_368000_177600 0 1.659048e-08
I11105 n1_m1_368000_182400 0 3.847500e-08
I11106 n1_m1_368000_192000 0 5.275000e-08
I11107 n1_m1_368000_196800 0 3.411429e-08
I11108 n1_m1_368000_201600 0 1.489143e-07
I11109 n1_m1_368000_206400 0 1.261314e-07
I11110 n1_m1_368000_211200 0 2.186667e-08
I11111 n1_m1_368000_216000 0 8.980952e-09
I11112 n1_m1_368000_220800 0 3.038571e-08
I11113 n1_m1_368000_225600 0 4.462185e-08
I11114 n1_m1_368000_230400 0 4.718655e-07
I11115 n1_m1_368000_235200 0 4.365714e-07
I11116 n1_m1_368000_240000 0 5.245882e-07
I11117 n1_m1_368000_244800 0 4.277647e-07
I11118 n1_m1_368000_249600 0 8.139160e-07
I11119 n1_m1_368000_254400 0 7.763856e-07
I11120 n1_m1_368000_259200 0 1.032540e-06
I11121 n1_m1_368000_264000 0 7.514683e-07
I11122 n1_m1_368000_268800 0 3.186929e-07
I11123 n1_m1_368000_273600 0 3.843554e-07
I11124 n1_m1_368000_278400 0 1.892381e-07
I11125 n1_m1_368000_283200 0 7.534512e-07
I11126 n1_m1_368000_288000 0 2.768980e-07
I11127 n1_m1_368000_292800 0 3.781955e-07
I11128 n1_m1_368000_297600 0 1.467290e-06
I11129 n1_m1_368000_302400 0 6.262652e-07
I11130 n1_m1_368000_307200 0 1.171506e-06
I11131 n1_m1_368000_312000 0 7.288880e-07
I11132 n1_m1_368000_316800 0 2.382143e-07
I11133 n1_m1_368000_321600 0 9.259055e-07
I11134 n1_m1_368000_326400 0 2.568010e-07
I11135 n1_m1_368000_331200 0 6.816071e-08
I11136 n1_m1_368000_336000 0 1.490385e-06
I11137 n1_m1_368000_340800 0 2.161905e-07
I11138 n1_m1_368000_345600 0 8.806563e-07
I11139 n1_m1_368000_350400 0 1.028571e-07
I11140 n1_m1_368000_355200 0 5.687104e-07
I11141 n1_m1_368000_360000 0 8.997232e-07
I11142 n1_m1_368000_364800 0 5.994135e-07
I11143 n1_m1_368000_369600 0 9.249165e-07
I11144 n1_m1_368000_374400 0 6.695238e-07
I11145 n1_m1_368000_379200 0 3.468571e-07
I11146 n1_m1_368000_384000 0 3.090357e-07
I11147 n1_m1_368000_388800 0 4.498824e-07
I11148 n1_m1_368000_393600 0 5.595562e-07
I11149 n1_m1_368000_398400 0 4.261609e-07
I11150 n1_m1_368000_403200 0 6.139412e-07
I11151 n1_m1_368000_408000 0 2.194000e-07
I11152 n1_m1_368000_412800 0 1.302857e-08
I11153 n1_m1_368000_417600 0 3.564381e-07
I11154 n1_m1_368000_422400 0 1.675857e-07
I11155 n1_m1_368000_427200 0 1.562438e-07
I11156 n1_m1_368000_432000 0 1.467168e-07
I11157 n1_m1_368000_436800 0 3.297500e-08
I11158 n1_m1_368000_441600 0 1.148076e-07
I11159 n1_m1_368000_446400 0 8.707857e-08
I11160 n1_m1_368000_451200 0 4.716082e-07
I11161 n1_m1_368000_456000 0 1.134905e-07
I11162 n1_m1_368000_460800 0 6.583333e-09
I11163 n1_m1_368000_465600 0 1.005821e-07
I11164 n1_m1_368000_470400 0 4.473619e-08
I11165 n1_m1_368000_475200 0 3.105714e-08
I11166 n1_m1_368000_480000 0 2.048099e-07
I11167 n1_m1_368000_484800 0 3.103166e-07
I11168 n1_m1_368000_489600 0 2.920898e-07
I11169 n1_m1_368000_494400 0 1.010857e-07
I11170 n1_m1_368000_499200 0 6.622857e-08
I11171 n1_m1_368000_504000 0 3.337977e-07
I11172 n1_m1_368000_508800 0 1.224082e-07
I11173 n1_m1_368000_513600 0 1.386143e-07
I11174 n1_m1_368000_518400 0 5.689712e-08
I11175 n1_m1_368000_523200 0 1.514872e-08
I11176 n1_m1_368000_528000 0 8.055000e-08
I11177 n1_m1_368000_532800 0 4.910000e-08
I11178 n1_m1_368000_537600 0 9.399231e-08
I11179 n1_m1_368000_542400 0 5.640769e-08
I11180 n1_m1_368000_547200 0 3.820923e-08
I11181 n1_m1_368000_552000 0 7.475172e-08
I11182 n1_m1_368000_576000 0 4.168831e-09
I11183 n1_m1_368000_580800 0 1.765514e-07
I11184 n1_m1_368000_585600 0 1.458115e-07
I11185 n1_m1_396000_4800 0 9.876923e-09
I11186 n1_m1_396000_9600 0 4.303077e-09
I11187 n1_m1_396000_48000 0 4.160952e-08
I11188 n1_m1_396000_52800 0 5.640714e-08
I11189 n1_m1_396000_57600 0 2.590333e-08
I11190 n1_m1_396000_67200 0 2.271000e-08
I11191 n1_m1_396000_72000 0 3.746026e-08
I11192 n1_m1_396000_76800 0 3.232308e-08
I11193 n1_m1_396000_81600 0 1.298571e-08
I11194 n1_m1_396000_86400 0 1.692308e-08
I11195 n1_m1_396000_91200 0 1.000769e-07
I11196 n1_m1_396000_96000 0 4.015000e-08
I11197 n1_m1_396000_100800 0 4.082143e-08
I11198 n1_m1_396000_105600 0 7.785119e-08
I11199 n1_m1_396000_110400 0 1.487321e-07
I11200 n1_m1_396000_115200 0 8.372143e-08
I11201 n1_m1_396000_120000 0 7.947321e-07
I11202 n1_m1_396000_124800 0 1.665000e-06
I11203 n1_m1_396000_129600 0 1.217738e-07
I11204 n1_m1_396000_134400 0 7.026561e-08
I11205 n1_m1_396000_139200 0 1.251837e-07
I11206 n1_m1_396000_144000 0 4.123857e-07
I11207 n1_m1_396000_148800 0 5.025556e-07
I11208 n1_m1_396000_153600 0 1.203889e-06
I11209 n1_m1_396000_158400 0 1.962857e-08
I11210 n1_m1_396000_163200 0 3.500714e-08
I11211 n1_m1_396000_168000 0 3.869429e-08
I11212 n1_m1_396000_172800 0 5.303592e-08
I11213 n1_m1_396000_177600 0 4.143265e-08
I11214 n1_m1_396000_182400 0 1.705714e-08
I11215 n1_m1_396000_187200 0 2.274286e-08
I11216 n1_m1_396000_192000 0 4.879000e-08
I11217 n1_m1_396000_196800 0 4.524524e-08
I11218 n1_m1_396000_201600 0 1.136429e-07
I11219 n1_m1_396000_206400 0 2.909286e-07
I11220 n1_m1_396000_211200 0 5.873229e-07
I11221 n1_m1_396000_216000 0 1.657143e-07
I11222 n1_m1_396000_220800 0 6.514286e-08
I11223 n1_m1_396000_225600 0 1.820755e-07
I11224 n1_m1_396000_230400 0 1.393163e-08
I11225 n1_m1_396000_235200 0 2.675089e-07
I11226 n1_m1_396000_240000 0 1.224436e-06
I11227 n1_m1_396000_244800 0 6.733500e-08
I11228 n1_m1_396000_249600 0 2.578982e-07
I11229 n1_m1_396000_254400 0 4.624690e-07
I11230 n1_m1_396000_259200 0 7.672782e-07
I11231 n1_m1_396000_264000 0 1.909143e-06
I11232 n1_m1_396000_268800 0 1.339429e-06
I11233 n1_m1_396000_273600 0 9.282857e-07
I11234 n1_m1_396000_278400 0 5.911905e-07
I11235 n1_m1_396000_283200 0 7.015655e-07
I11236 n1_m1_396000_288000 0 1.778893e-06
I11237 n1_m1_396000_292800 0 1.089524e-06
I11238 n1_m1_396000_297600 0 1.105122e-06
I11239 n1_m1_396000_302400 0 8.015045e-07
I11240 n1_m1_396000_307200 0 6.008403e-07
I11241 n1_m1_396000_312000 0 3.452802e-07
I11242 n1_m1_396000_316800 0 4.734405e-08
I11243 n1_m1_396000_321600 0 5.413929e-08
I11244 n1_m1_396000_326400 0 1.125857e-07
I11245 n1_m1_396000_331200 0 3.883786e-07
I11246 n1_m1_396000_336000 0 3.519500e-07
I11247 n1_m1_396000_340800 0 2.810000e-08
I11248 n1_m1_396000_345600 0 1.550000e-08
I11249 n1_m1_396000_350400 0 2.548512e-08
I11250 n1_m1_396000_355200 0 3.398016e-08
I11251 n1_m1_396000_360000 0 7.727500e-07
I11252 n1_m1_396000_364800 0 6.680000e-09
I11253 n1_m1_396000_369600 0 2.438571e-08
I11254 n1_m1_396000_374400 0 3.420000e-08
I11255 n1_m1_396000_379200 0 6.008393e-08
I11256 n1_m1_396000_384000 0 5.517024e-08
I11257 n1_m1_396000_388800 0 5.366667e-08
I11258 n1_m1_396000_393600 0 1.314881e-07
I11259 n1_m1_396000_398400 0 7.547143e-08
I11260 n1_m1_396000_403200 0 9.605714e-08
I11261 n1_m1_396000_408000 0 8.954167e-08
I11262 n1_m1_396000_412800 0 8.657143e-08
I11263 n1_m1_396000_417600 0 3.435119e-07
I11264 n1_m1_396000_422400 0 6.726607e-08
I11265 n1_m1_396000_432000 0 3.230587e-08
I11266 n1_m1_396000_436800 0 5.038520e-08
I11267 n1_m1_396000_441600 0 5.297143e-08
I11268 n1_m1_396000_446400 0 4.496429e-08
I11269 n1_m1_396000_451200 0 8.662143e-08
I11270 n1_m1_396000_456000 0 3.697143e-09
I11271 n1_m1_396000_460800 0 2.739762e-08
I11272 n1_m1_396000_465600 0 7.226190e-08
I11273 n1_m1_396000_470400 0 3.166667e-08
I11274 n1_m1_396000_475200 0 2.000000e-08
I11275 n1_m1_396000_480000 0 8.000000e-09
I11276 n1_m1_396000_484800 0 2.755556e-08
I11277 n1_m1_396000_576000 0 1.879121e-09
I11278 n1_m1_396000_580800 0 2.574286e-07
I11279 n1_m1_396000_585600 0 1.538462e-07
I11280 n1_m1_424000_4800 0 7.492308e-09
I11281 n1_m1_424000_9600 0 2.813119e-07
I11282 n1_m1_424000_76800 0 1.485714e-08
I11283 n1_m1_424000_81600 0 6.139429e-08
I11284 n1_m1_424000_86400 0 2.918242e-08
I11285 n1_m1_424000_91200 0 1.235738e-07
I11286 n1_m1_424000_96000 0 9.445333e-08
I11287 n1_m1_424000_100800 0 6.186190e-08
I11288 n1_m1_424000_105600 0 3.816381e-08
I11289 n1_m1_424000_110400 0 5.585238e-08
I11290 n1_m1_424000_115200 0 3.903619e-08
I11291 n1_m1_424000_120000 0 3.472313e-08
I11292 n1_m1_424000_124800 0 5.438322e-08
I11293 n1_m1_424000_129600 0 6.512063e-08
I11294 n1_m1_424000_134400 0 3.166429e-08
I11295 n1_m1_424000_139200 0 1.278571e-08
I11296 n1_m1_424000_144000 0 2.203378e-07
I11297 n1_m1_424000_148800 0 5.571545e-07
I11298 n1_m1_424000_153600 0 1.164193e-06
I11299 n1_m1_424000_158400 0 7.165714e-07
I11300 n1_m1_424000_163200 0 1.292563e-07
I11301 n1_m1_424000_168000 0 6.082857e-08
I11302 n1_m1_424000_172800 0 6.135238e-08
I11303 n1_m1_424000_177600 0 5.327429e-08
I11304 n1_m1_424000_182400 0 1.821605e-07
I11305 n1_m1_424000_187200 0 7.516952e-08
I11306 n1_m1_424000_192000 0 6.228095e-08
I11307 n1_m1_424000_196800 0 1.156714e-07
I11308 n1_m1_424000_201600 0 1.218857e-07
I11309 n1_m1_424000_206400 0 1.475429e-07
I11310 n1_m1_424000_211200 0 4.714286e-09
I11311 n1_m1_424000_216000 0 1.361777e-07
I11312 n1_m1_424000_220800 0 5.241429e-08
I11313 n1_m1_424000_225600 0 4.071429e-07
I11314 n1_m1_424000_230400 0 7.741562e-07
I11315 n1_m1_424000_235200 0 1.030743e-07
I11316 n1_m1_424000_240000 0 3.006367e-07
I11317 n1_m1_424000_244800 0 6.003361e-07
I11318 n1_m1_424000_249600 0 1.147532e-06
I11319 n1_m1_424000_254400 0 5.932381e-07
I11320 n1_m1_424000_259200 0 4.771429e-07
I11321 n1_m1_424000_264000 0 1.730873e-06
I11322 n1_m1_424000_268800 0 4.491312e-07
I11323 n1_m1_424000_273600 0 5.834000e-07
I11324 n1_m1_424000_278400 0 3.721224e-07
I11325 n1_m1_424000_283200 0 5.481871e-07
I11326 n1_m1_424000_288000 0 1.328714e-06
I11327 n1_m1_424000_292800 0 4.586466e-07
I11328 n1_m1_424000_297600 0 1.137840e-06
I11329 n1_m1_424000_302400 0 8.724664e-07
I11330 n1_m1_424000_307200 0 6.998449e-07
I11331 n1_m1_424000_312000 0 5.550918e-07
I11332 n1_m1_424000_316800 0 6.714286e-08
I11333 n1_m1_424000_321600 0 4.720000e-08
I11334 n1_m1_424000_326400 0 2.142667e-07
I11335 n1_m1_424000_331200 0 1.045111e-07
I11336 n1_m1_424000_336000 0 4.007571e-07
I11337 n1_m1_424000_340800 0 4.419048e-07
I11338 n1_m1_424000_345600 0 2.246667e-07
I11339 n1_m1_424000_350400 0 7.251429e-08
I11340 n1_m1_424000_355200 0 5.512000e-08
I11341 n1_m1_424000_360000 0 1.891057e-07
I11342 n1_m1_424000_364800 0 4.882857e-08
I11343 n1_m1_424000_369600 0 5.657143e-08
I11344 n1_m1_424000_374400 0 5.380357e-08
I11345 n1_m1_424000_379200 0 4.780000e-08
I11346 n1_m1_424000_384000 0 6.373333e-08
I11347 n1_m1_424000_388800 0 5.211765e-08
I11348 n1_m1_424000_393600 0 2.020000e-07
I11349 n1_m1_424000_398400 0 4.885721e-07
I11350 n1_m1_424000_403200 0 3.337557e-07
I11351 n1_m1_424000_408000 0 1.262173e-07
I11352 n1_m1_424000_412800 0 7.425483e-08
I11353 n1_m1_424000_417600 0 8.893345e-08
I11354 n1_m1_424000_422400 0 5.668472e-08
I11355 n1_m1_424000_427200 0 6.030476e-07
I11356 n1_m1_424000_432000 0 2.440857e-07
I11357 n1_m1_424000_436800 0 1.480000e-09
I11358 n1_m1_424000_441600 0 3.168000e-08
I11359 n1_m1_424000_451200 0 7.172143e-08
I11360 n1_m1_424000_456000 0 6.612857e-08
I11361 n1_m1_424000_460800 0 1.044000e-07
I11362 n1_m1_424000_465600 0 1.077714e-07
I11363 n1_m1_424000_470400 0 6.049238e-08
I11364 n1_m1_424000_475200 0 7.709184e-08
I11365 n1_m1_424000_480000 0 1.915102e-08
I11366 n1_m1_452000_9600 0 1.740000e-08
I11367 n1_m1_452000_72000 0 6.421346e-08
I11368 n1_m1_452000_76800 0 9.192404e-08
I11369 n1_m1_452000_81600 0 1.175914e-07
I11370 n1_m1_452000_86400 0 6.901473e-08
I11371 n1_m1_452000_91200 0 1.533872e-07
I11372 n1_m1_452000_96000 0 3.527192e-07
I11373 n1_m1_452000_100800 0 1.757143e-07
I11374 n1_m1_452000_105600 0 7.860181e-07
I11375 n1_m1_452000_110400 0 1.647540e-07
I11376 n1_m1_452000_115200 0 9.374444e-08
I11377 n1_m1_452000_120000 0 3.485600e-07
I11378 n1_m1_452000_124800 0 1.750000e-07
I11379 n1_m1_452000_129600 0 2.187143e-07
I11380 n1_m1_452000_134400 0 1.380429e-07
I11381 n1_m1_452000_139200 0 1.327024e-07
I11382 n1_m1_452000_144000 0 1.067569e-06
I11383 n1_m1_452000_148800 0 1.598857e-07
I11384 n1_m1_452000_153600 0 1.611517e-07
I11385 n1_m1_452000_158400 0 4.385306e-08
I11386 n1_m1_452000_163200 0 2.889796e-08
I11387 n1_m1_452000_168000 0 7.049722e-07
I11388 n1_m1_452000_177600 0 1.261389e-06
I11389 n1_m1_452000_182400 0 1.285772e-06
I11390 n1_m1_452000_187200 0 6.143629e-07
I11391 n1_m1_452000_192000 0 1.818150e-07
I11392 n1_m1_452000_196800 0 5.421293e-07
I11393 n1_m1_452000_201600 0 1.001910e-06
I11394 n1_m1_452000_206400 0 5.911429e-07
I11395 n1_m1_452000_211200 0 5.018857e-06
I11396 n1_m1_452000_216000 0 1.048571e-06
I11397 n1_m1_452000_220800 0 6.374381e-07
I11398 n1_m1_452000_225600 0 7.328000e-07
I11399 n1_m1_452000_230400 0 6.742857e-08
I11400 n1_m1_452000_235200 0 7.818214e-07
I11401 n1_m1_452000_240000 0 9.743333e-07
I11402 n1_m1_452000_244800 0 1.046057e-06
I11403 n1_m1_452000_249600 0 2.880400e-06
I11404 n1_m1_452000_254400 0 1.111200e-06
I11405 n1_m1_452000_259200 0 1.181143e-06
I11406 n1_m1_452000_264000 0 3.856000e-07
I11407 n1_m1_452000_268800 0 1.436857e-06
I11408 n1_m1_452000_273600 0 2.583333e-06
I11409 n1_m1_452000_278400 0 1.504731e-06
I11410 n1_m1_452000_283200 0 1.169035e-06
I11411 n1_m1_452000_288000 0 1.296405e-06
I11412 n1_m1_452000_292800 0 3.473901e-06
I11413 n1_m1_452000_297600 0 2.935971e-06
I11414 n1_m1_452000_302400 0 5.556698e-07
I11415 n1_m1_452000_307200 0 5.889796e-07
I11416 n1_m1_452000_312000 0 2.621429e-06
I11417 n1_m1_452000_316800 0 2.545190e-07
I11418 n1_m1_452000_321600 0 1.389571e-07
I11419 n1_m1_452000_326400 0 1.352381e-08
I11420 n1_m1_452000_331200 0 1.138857e-07
I11421 n1_m1_452000_336000 0 2.175657e-07
I11422 n1_m1_452000_340800 0 2.009864e-07
I11423 n1_m1_452000_345600 0 2.255073e-07
I11424 n1_m1_452000_350400 0 2.969048e-07
I11425 n1_m1_452000_355200 0 1.910363e-07
I11426 n1_m1_452000_360000 0 2.645994e-06
I11427 n1_m1_452000_364800 0 2.817714e-07
I11428 n1_m1_452000_369600 0 3.547000e-07
I11429 n1_m1_452000_374400 0 2.636908e-07
I11430 n1_m1_452000_379200 0 1.001605e-06
I11431 n1_m1_452000_384000 0 1.339262e-06
I11432 n1_m1_452000_388800 0 4.701352e-07
I11433 n1_m1_452000_393600 0 2.878889e-06
I11434 n1_m1_452000_398400 0 2.122222e-06
I11435 n1_m1_452000_403200 0 3.166667e-07
I11436 n1_m1_452000_408000 0 4.604167e-07
I11437 n1_m1_452000_412800 0 2.221429e-08
I11438 n1_m1_452000_417600 0 1.355550e-06
I11439 n1_m1_452000_427200 0 6.547810e-07
I11440 n1_m1_452000_432000 0 4.910857e-07
I11441 n1_m1_452000_446400 0 7.908442e-08
I11442 n1_m1_452000_451200 0 7.044766e-07
I11443 n1_m1_452000_456000 0 5.901133e-07
I11444 n1_m1_452000_460800 0 4.405153e-07
I11445 n1_m1_452000_465600 0 8.109000e-07
I11446 n1_m1_452000_470400 0 1.312500e-07
I11447 n1_m1_452000_576000 0 1.450000e-07
I11448 n1_m1_452000_580800 0 4.758974e-09
I11449 n1_m1_452000_585600 0 2.974359e-09
I11450 n1_m1_508000_9600 0 3.075000e-07
I11451 n1_m1_508000_14400 0 3.100000e-08
I11452 n1_m1_508000_86400 0 1.063333e-08
I11453 n1_m1_508000_105600 0 1.080000e-08
I11454 n1_m1_508000_110400 0 2.700000e-08
I11455 n1_m1_508000_115200 0 3.700762e-08
I11456 n1_m1_508000_120000 0 5.294286e-08
I11457 n1_m1_508000_124800 0 5.292857e-08
I11458 n1_m1_508000_129600 0 1.471429e-08
I11459 n1_m1_508000_158400 0 1.062857e-07
I11460 n1_m1_508000_163200 0 1.344743e-07
I11461 n1_m1_508000_168000 0 6.952143e-08
I11462 n1_m1_508000_172800 0 6.285714e-08
I11463 n1_m1_508000_177600 0 5.939518e-07
I11464 n1_m1_508000_182400 0 4.597500e-08
I11465 n1_m1_508000_187200 0 1.790924e-07
I11466 n1_m1_508000_192000 0 1.013021e-07
I11467 n1_m1_508000_196800 0 1.728571e-08
I11468 n1_m1_508000_201600 0 8.070667e-08
I11469 n1_m1_508000_206400 0 4.949429e-08
I11470 n1_m1_508000_211200 0 1.637067e-07
I11471 n1_m1_508000_216000 0 1.507328e-07
I11472 n1_m1_508000_220800 0 1.624286e-08
I11473 n1_m1_508000_225600 0 3.044286e-08
I11474 n1_m1_508000_230400 0 4.485714e-08
I11475 n1_m1_508000_235200 0 3.997500e-08
I11476 n1_m1_508000_240000 0 1.337333e-07
I11477 n1_m1_508000_244800 0 1.493333e-08
I11478 n1_m1_508000_249600 0 4.371429e-08
I11479 n1_m1_508000_254400 0 5.293333e-08
I11480 n1_m1_508000_259200 0 1.350857e-07
I11481 n1_m1_508000_264000 0 5.776548e-07
I11482 n1_m1_508000_268800 0 9.982857e-08
I11483 n1_m1_508000_273600 0 1.694429e-07
I11484 n1_m1_508000_278400 0 6.278571e-08
I11485 n1_m1_508000_283200 0 6.173061e-08
I11486 n1_m1_508000_288000 0 7.032272e-08
I11487 n1_m1_508000_292800 0 5.172857e-08
I11488 n1_m1_508000_297600 0 6.496588e-07
I11489 n1_m1_508000_302400 0 2.050975e-07
I11490 n1_m1_508000_307200 0 6.728571e-08
I11491 n1_m1_508000_312000 0 1.088571e-08
I11492 n1_m1_508000_316800 0 8.358703e-07
I11493 n1_m1_508000_321600 0 8.346429e-08
I11494 n1_m1_508000_326400 0 1.585714e-07
I11495 n1_m1_508000_331200 0 4.311607e-08
I11496 n1_m1_508000_336000 0 6.743333e-08
I11497 n1_m1_508000_340800 0 1.316619e-07
I11498 n1_m1_508000_345600 0 8.240476e-08
I11499 n1_m1_508000_350400 0 4.810095e-08
I11500 n1_m1_508000_355200 0 1.668571e-08
I11501 n1_m1_508000_360000 0 2.256831e-06
I11502 n1_m1_508000_364800 0 1.705714e-08
I11503 n1_m1_508000_369600 0 1.277143e-07
I11504 n1_m1_508000_374400 0 6.423571e-08
I11505 n1_m1_508000_379200 0 6.053333e-08
I11506 n1_m1_508000_384000 0 2.036286e-07
I11507 n1_m1_508000_388800 0 1.997143e-08
I11508 n1_m1_508000_393600 0 5.998571e-08
I11509 n1_m1_508000_398400 0 4.491429e-08
I11510 n1_m1_508000_403200 0 5.449500e-08
I11511 n1_m1_508000_408000 0 8.902750e-07
I11512 n1_m1_508000_412800 0 3.720000e-08
I11513 n1_m1_508000_417600 0 1.758538e-07
I11514 n1_m1_508000_422400 0 2.851429e-07
I11515 n1_m1_508000_427200 0 1.597084e-07
I11516 n1_m1_508000_432000 0 1.393627e-07
I11517 n1_m1_508000_436800 0 3.193651e-08
I11518 n1_m1_508000_441600 0 8.230000e-08
I11519 n1_m1_508000_508800 0 1.275000e-08
I11520 n1_m1_508000_513600 0 3.646250e-07
I11521 n1_m1_536000_4800 0 2.414201e-08
I11522 n1_m1_536000_9600 0 3.863868e-07
I11523 n1_m1_536000_14400 0 2.880000e-07
I11524 n1_m1_536000_153600 0 3.009375e-07
I11525 n1_m1_536000_163200 0 9.165714e-09
I11526 n1_m1_536000_168000 0 3.577143e-08
I11527 n1_m1_536000_172800 0 1.714286e-08
I11528 n1_m1_536000_177600 0 1.724000e-08
I11529 n1_m1_536000_182400 0 5.959143e-08
I11530 n1_m1_536000_187200 0 7.085714e-08
I11531 n1_m1_536000_192000 0 6.287143e-08
I11532 n1_m1_536000_196800 0 1.075102e-08
I11533 n1_m1_536000_201600 0 1.433469e-08
I11534 n1_m1_536000_206400 0 8.977778e-08
I11535 n1_m1_536000_211200 0 3.618214e-08
I11536 n1_m1_536000_216000 0 8.330000e-08
I11537 n1_m1_536000_220800 0 5.411786e-08
I11538 n1_m1_536000_225600 0 6.848571e-08
I11539 n1_m1_536000_230400 0 2.377143e-08
I11540 n1_m1_536000_235200 0 9.385714e-09
I11541 n1_m1_536000_240000 0 6.171429e-08
I11542 n1_m1_536000_244800 0 2.048571e-08
I11543 n1_m1_536000_249600 0 1.157143e-08
I11544 n1_m1_536000_254400 0 3.027143e-08
I11545 n1_m1_536000_259200 0 1.360629e-07
I11546 n1_m1_536000_264000 0 4.276400e-07
I11547 n1_m1_536000_268800 0 1.099429e-07
I11548 n1_m1_536000_273600 0 2.359486e-07
I11549 n1_m1_536000_278400 0 1.470667e-07
I11550 n1_m1_536000_283200 0 1.359524e-07
I11551 n1_m1_536000_288000 0 1.169905e-07
I11552 n1_m1_536000_292800 0 3.164286e-08
I11553 n1_m1_536000_297600 0 2.250324e-07
I11554 n1_m1_536000_302400 0 5.944524e-08
I11555 n1_m1_536000_307200 0 6.345000e-07
I11556 n1_m1_536000_312000 0 3.218257e-07
I11557 n1_m1_536000_316800 0 1.553992e-07
I11558 n1_m1_536000_321600 0 3.814082e-08
I11559 n1_m1_536000_326400 0 5.575238e-08
I11560 n1_m1_536000_331200 0 1.734921e-08
I11561 n1_m1_536000_336000 0 9.675714e-08
I11562 n1_m1_536000_340800 0 1.174400e-07
I11563 n1_m1_536000_345600 0 6.128952e-08
I11564 n1_m1_536000_350400 0 4.518952e-08
I11565 n1_m1_536000_355200 0 2.605714e-08
I11566 n1_m1_536000_360000 0 3.493333e-07
I11567 n1_m1_536000_364800 0 1.080000e-08
I11568 n1_m1_536000_369600 0 5.511429e-08
I11569 n1_m1_536000_374400 0 4.778571e-08
I11570 n1_m1_536000_379200 0 2.840000e-08
I11571 n1_m1_536000_384000 0 1.387238e-07
I11572 n1_m1_536000_388800 0 1.354286e-08
I11573 n1_m1_536000_393600 0 7.300921e-08
I11574 n1_m1_536000_398400 0 3.084571e-08
I11575 n1_m1_536000_403200 0 4.670286e-08
I11576 n1_m1_536000_412800 0 1.708571e-08
I11577 n1_m1_536000_417600 0 2.368095e-08
I11578 n1_m1_536000_422400 0 4.800952e-08
I11579 n1_m1_536000_427200 0 5.445714e-08
I11580 n1_m1_536000_432000 0 9.684881e-08
I11581 n1_m1_536000_436800 0 8.800952e-08
I11582 n1_m1_536000_585600 0 2.108000e-08
I11583 n1_m1_564000_9600 0 2.730938e-07
I11584 n1_m1_564000_211200 0 3.812500e-08
I11585 n1_m1_564000_240000 0 3.515152e-07
I11586 n1_m1_564000_273600 0 2.343714e-07
I11587 n1_m1_564000_278400 0 5.359286e-07
I11588 n1_m1_564000_283200 0 9.000000e-09
I11589 n1_m1_564000_288000 0 6.157143e-09
I11590 n1_m1_564000_292800 0 1.539286e-08
I11591 n1_m1_564000_297600 0 7.302857e-08
I11592 n1_m1_564000_302400 0 7.375714e-08
I11593 n1_m1_564000_307200 0 1.646429e-08
I11594 n1_m1_564000_312000 0 8.450714e-08
I11595 n1_m1_564000_316800 0 8.971190e-08
I11596 n1_m1_564000_321600 0 1.932143e-07
I11597 n1_m1_564000_350400 0 6.214286e-09
I11598 n1_m1_564000_355200 0 8.285714e-09
.op
.end
