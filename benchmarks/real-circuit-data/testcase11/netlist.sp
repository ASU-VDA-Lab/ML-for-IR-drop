R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R98 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R99 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R100 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R101 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R102 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R103 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R104 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R105 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R106 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R107 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R108 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R109 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R110 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R111 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R112 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R113 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R114 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R115 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R116 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R117 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R118 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R119 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R120 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R121 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R122 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R123 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R124 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R125 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R126 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R127 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R128 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R129 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R130 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R131 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R132 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R133 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R134 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R135 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R136 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R137 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R138 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R139 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R140 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R141 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R142 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R143 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R144 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R145 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R146 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R147 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R148 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R149 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R150 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R151 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R152 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R153 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R154 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R155 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R156 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R157 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R158 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R159 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R160 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R161 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R162 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R163 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R164 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R165 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R166 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R167 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R168 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R169 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R170 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R171 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R172 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R173 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R174 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R175 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R176 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R177 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R178 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R179 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R180 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R181 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R182 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R183 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R184 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R185 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R186 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R187 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R188 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R189 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R190 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R191 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R192 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R193 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R194 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R195 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R196 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R197 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R198 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R199 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R200 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R201 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R202 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R203 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R204 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R205 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R206 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R207 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R208 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R209 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R210 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R211 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R212 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R213 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R214 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R215 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R216 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R217 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R218 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R219 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R220 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R221 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R222 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R223 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R224 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R225 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R226 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R227 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R228 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R229 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R230 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R231 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R232 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R233 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R234 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R235 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R236 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R237 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R238 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R239 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R240 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R241 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R242 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R243 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R244 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R245 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R246 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R247 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R248 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R249 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R250 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R251 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R252 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R253 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R254 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R255 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R256 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R257 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R258 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R259 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R260 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R261 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R262 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R263 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R264 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R265 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R266 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R267 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R268 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R269 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R270 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R271 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R272 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R273 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R274 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R275 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R276 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R277 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R278 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R279 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R280 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R281 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R282 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R283 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R284 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R285 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R286 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R287 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R288 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R289 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R290 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R291 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R292 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R293 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R294 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R295 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R296 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R297 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R298 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R299 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R300 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R301 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R302 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R303 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R304 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R305 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R306 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R307 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R308 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R309 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R310 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R311 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R312 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R313 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R314 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R315 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R316 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R317 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R318 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R319 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R320 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R321 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R322 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R323 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R324 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R325 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R326 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R327 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R328 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R329 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R330 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R331 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R332 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R333 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R334 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R335 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R336 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R337 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R338 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R339 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R340 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R341 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R342 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R343 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R344 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R345 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R346 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R347 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R348 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R349 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R350 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R351 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R352 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R353 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R354 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R355 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R356 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R357 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R358 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R359 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R360 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R361 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R362 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R363 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R364 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R365 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R366 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R367 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R368 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R369 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R370 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R371 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R372 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R373 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R374 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R375 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R376 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R377 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R378 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R379 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R380 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R381 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R382 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R383 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R384 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R385 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R386 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R387 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R388 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R389 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R390 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R391 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R392 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R393 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R394 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R395 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R396 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R397 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R398 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R399 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R400 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R401 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R402 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R403 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R404 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R405 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R406 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R407 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R408 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R409 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R410 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R411 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R412 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R413 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R414 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R415 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R416 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R417 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R418 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R419 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R420 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R421 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R422 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R423 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R424 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R425 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R426 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R427 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R428 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R429 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R430 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R431 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R432 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R433 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R434 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R435 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R436 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R437 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R438 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R439 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R440 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R441 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R442 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R443 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R444 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R445 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R446 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R447 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R448 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R449 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R450 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R451 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R452 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R453 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R454 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R455 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R456 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R457 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R458 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R459 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R460 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R461 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R462 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R463 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R464 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R465 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R466 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R467 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R468 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R469 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R470 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R471 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R472 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R473 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R474 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R475 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R476 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R477 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R478 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R479 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R480 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R481 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R482 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R483 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R484 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R485 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R486 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R487 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R488 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R489 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R490 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R491 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R492 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R493 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R494 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R495 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R496 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R497 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R498 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R499 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R500 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R501 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R502 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R503 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R504 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R505 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R506 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R507 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R508 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R509 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R510 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R511 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R512 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R513 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R514 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R515 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R516 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R517 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R518 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R519 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R520 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R521 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R522 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R523 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R524 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R525 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R526 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R527 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R528 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R529 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R530 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R531 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R532 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R533 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R534 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R535 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R536 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R537 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R538 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R539 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R540 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R541 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R542 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R543 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R544 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R545 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R546 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R547 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R548 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R549 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R550 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R551 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R552 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R553 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R554 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R555 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R556 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R557 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R558 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R559 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R560 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R561 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R562 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R563 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R564 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R565 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R566 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R567 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R568 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R569 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R570 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R571 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R572 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R573 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R574 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R575 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R576 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R577 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R578 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R579 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R580 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R581 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R582 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R583 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R584 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R585 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R586 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R587 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R588 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R589 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R590 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R591 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R592 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R593 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R594 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R595 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R596 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R597 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R598 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R599 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R600 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R601 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R602 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R603 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R604 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R605 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R606 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R607 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R608 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R609 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R610 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R611 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R612 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R613 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R614 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R615 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R616 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R617 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R618 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R619 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R620 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R621 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R622 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R623 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R624 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R625 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R626 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R627 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R628 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R629 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R630 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R631 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R632 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R633 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R634 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R635 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R636 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R637 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R638 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R639 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R640 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R641 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R642 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R643 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R644 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R645 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R646 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R647 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R648 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R649 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R650 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R651 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R652 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R653 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R654 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R655 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R656 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R657 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R658 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R659 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R660 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R661 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R662 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R663 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R664 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R665 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R666 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R667 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R668 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R669 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R670 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R671 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R672 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R673 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R674 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R675 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R676 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R677 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R678 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R679 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R680 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R681 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R682 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R683 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R684 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R685 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R686 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R687 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R688 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R689 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R690 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R691 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R692 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R693 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R694 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R695 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R696 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R697 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R698 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R699 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R700 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R701 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R702 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R703 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R704 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R705 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R706 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R707 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R708 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R709 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R710 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R711 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R712 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R713 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R714 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R715 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R716 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R717 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R718 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R719 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R720 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R721 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R722 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R723 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R724 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R725 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R726 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R727 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R728 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R729 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R730 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R731 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R732 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R733 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R734 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R735 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R736 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R737 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R738 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R739 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R740 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R741 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R742 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R743 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R744 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R745 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R746 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R747 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R748 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R749 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R750 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R751 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R752 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R753 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R754 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R755 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R756 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R757 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R758 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R759 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R760 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R761 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R762 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R763 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R764 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R765 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R766 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R767 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R768 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R769 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R770 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R771 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R772 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R773 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R774 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R775 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R776 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R777 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R778 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R779 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R780 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R781 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R782 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R783 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R784 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R785 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R786 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R787 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R788 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R789 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R790 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R791 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R792 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R793 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R794 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R795 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R796 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R797 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R798 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R799 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R800 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R801 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R802 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R803 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R804 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R805 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R806 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R807 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R808 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R809 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R810 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R811 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R812 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R813 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R814 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R815 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R816 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R817 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R818 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R819 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R820 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R821 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R822 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R823 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R824 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R825 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R826 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R827 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R828 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R829 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R830 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R831 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R832 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R833 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R834 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R835 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R836 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R837 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R838 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R839 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R840 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R841 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R842 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R843 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R844 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R845 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R846 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R847 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R848 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R849 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R850 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R851 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R852 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R853 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R854 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R855 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R856 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R857 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R858 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R859 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R860 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R861 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R862 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R863 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R864 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R865 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R866 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R867 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R868 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R869 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R870 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R871 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R872 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R873 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R874 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R875 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R876 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R877 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R878 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R879 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R880 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R881 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R882 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R883 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R884 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R885 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R886 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R887 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R888 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R889 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R890 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R891 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R892 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R893 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R894 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R895 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R896 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R897 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R898 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R899 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R900 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R901 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R902 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R903 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R904 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R905 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R906 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R907 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R908 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R909 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R910 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R911 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R912 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R913 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R914 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R915 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R916 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R917 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R918 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R919 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R920 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R921 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R922 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R923 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R924 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R925 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R926 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R927 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R928 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R929 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R930 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R931 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R932 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R933 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R934 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R935 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R936 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R937 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R938 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R939 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R940 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R941 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R942 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R943 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R944 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R945 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R946 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R947 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R948 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R949 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R950 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R951 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R952 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R953 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R954 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R955 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R956 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R957 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R958 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R959 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R960 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R961 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R962 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R963 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R964 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R965 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R966 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R967 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R968 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R969 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R970 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R971 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R972 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R973 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R974 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R975 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R976 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R977 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R978 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R979 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R980 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R981 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R982 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R983 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R984 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R985 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R986 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R987 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R988 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R989 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R990 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R991 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R992 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R993 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R994 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R995 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R996 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R997 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R998 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R999 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1000 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1001 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1002 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1003 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1004 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1005 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1006 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1007 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1008 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1009 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1010 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1011 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1012 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1013 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1014 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1015 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1016 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1017 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1018 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1019 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1020 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1021 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1022 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1023 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1024 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1025 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1026 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1027 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1028 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1029 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1030 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1031 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1032 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1033 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1034 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1035 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1036 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1037 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1038 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1039 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1040 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1041 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1042 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1043 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1044 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1045 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1046 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1047 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1048 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1049 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1050 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1051 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1052 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1053 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1054 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1055 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1056 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1057 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1058 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1059 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1060 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1061 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1062 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1063 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1064 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1065 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1066 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1067 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1068 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1069 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1070 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1071 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1072 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1073 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1074 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1075 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1076 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1077 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1078 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1079 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1080 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1081 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1082 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1083 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1084 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1085 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1086 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1087 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1088 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1089 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1090 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1091 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1092 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1093 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1094 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1095 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1096 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1097 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1098 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1099 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1100 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1101 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1102 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1103 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1104 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1105 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1106 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1107 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1108 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1109 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1110 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1111 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1112 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1113 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1114 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1115 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1116 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1117 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1118 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1119 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1120 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1121 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1122 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1123 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1124 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1125 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1126 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1127 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1128 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1129 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1130 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1131 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1132 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1133 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1134 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1135 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1136 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1137 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1138 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1139 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1140 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1141 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1142 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1143 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1144 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1145 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1146 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1147 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1148 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1149 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1150 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1151 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1152 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1153 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1154 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1155 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1156 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1157 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1158 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1159 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1160 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1161 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1162 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1163 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1164 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1165 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1166 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1167 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1168 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1169 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1170 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1171 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1172 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1173 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1174 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1175 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1176 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1177 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1178 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1179 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1180 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1181 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1182 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1183 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1184 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1185 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1186 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1187 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1188 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1189 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1190 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1191 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1192 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1193 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1194 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1195 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1196 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1197 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1198 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1199 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1200 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1201 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1202 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1203 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1204 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1205 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1206 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1207 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1208 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1209 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1210 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1211 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1212 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1213 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1214 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1215 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1216 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1217 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1218 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1219 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1220 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1221 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1222 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1223 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1224 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1225 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1226 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1227 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1228 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1229 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1230 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1231 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1232 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1233 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1234 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1235 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1236 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1237 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1238 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1239 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1240 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1241 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1242 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1243 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1244 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1245 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1246 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1247 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1248 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1249 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1250 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1251 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1252 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1253 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1254 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1255 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1256 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1257 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1258 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1259 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1260 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1261 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1262 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1263 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1264 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1265 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1266 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1267 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1268 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1269 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1270 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1271 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1272 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1273 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1274 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1275 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1276 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1277 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1278 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1279 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1280 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1281 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1282 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1283 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1284 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1285 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1286 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1287 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1288 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1289 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1290 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1291 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1292 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1293 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1294 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1295 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1296 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1297 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1298 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1299 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1300 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1301 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1302 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1303 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1304 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1305 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1306 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1307 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1308 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1309 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1310 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1311 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1312 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1313 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1314 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1315 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1316 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1317 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1318 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1319 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1320 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1321 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1322 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1323 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1324 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1325 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1326 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1327 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1328 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1329 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1330 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1331 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1332 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1333 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1334 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1335 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1336 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1337 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1338 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1339 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1340 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1341 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1342 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1343 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1344 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1345 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1346 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1347 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1348 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1349 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1350 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1351 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1352 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1353 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1354 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1355 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1356 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1357 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1358 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R1359 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R1360 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R1361 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R1362 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R1363 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R1364 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R1365 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R1366 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R1367 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R1368 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R1369 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R1370 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R1371 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R1372 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R1373 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R1374 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R1375 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R1376 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R1377 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R1378 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R1379 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R1380 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R1381 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R1382 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R1383 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R1384 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R1385 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R1386 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R1387 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R1388 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R1389 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R1390 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R1391 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R1392 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R1393 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R1394 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R1395 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R1396 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R1397 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R1398 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R1399 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R1400 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R1401 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R1402 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R1403 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R1404 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R1405 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R1406 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R1407 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R1408 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R1409 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R1410 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R1411 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R1412 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R1413 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R1414 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R1415 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R1416 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R1417 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R1418 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R1419 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R1420 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R1421 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R1422 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R1423 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R1424 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R1425 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R1426 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R1427 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R1428 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R1429 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R1430 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R1431 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R1432 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R1433 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R1434 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R1435 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R1436 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R1437 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R1438 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R1439 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R1440 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R1441 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R1442 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R1443 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R1444 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R1445 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R1446 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R1447 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R1448 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R1449 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R1450 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R1451 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R1452 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R1453 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R1454 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R1455 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R1456 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R1457 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R1458 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R1459 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R1460 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R1461 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R1462 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R1463 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R1464 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R1465 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R1466 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R1467 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R1468 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R1469 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R1470 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R1471 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R1472 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R1473 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R1474 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R1475 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R1476 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R1477 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R1478 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R1479 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R1480 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R1481 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R1482 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R1483 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R1484 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R1485 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R1486 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R1487 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R1488 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R1489 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R1490 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R1491 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R1492 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R1493 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R1494 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R1495 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R1496 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R1497 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R1498 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R1499 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R1500 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R1501 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R1502 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R1503 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R1504 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R1505 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R1506 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R1507 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R1508 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R1509 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R1510 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R1511 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R1512 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R1513 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R1514 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R1515 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R1516 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R1517 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R1518 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R1519 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R1520 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R1521 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R1522 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R1523 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R1524 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R1525 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R1526 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R1527 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R1528 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R1529 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R1530 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R1531 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R1532 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R1533 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R1534 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R1535 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R1536 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R1537 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R1538 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R1539 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R1540 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R1541 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R1542 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R1543 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R1544 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R1545 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R1546 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R1547 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R1548 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R1549 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R1550 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R1551 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R1552 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R1553 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R1554 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R1555 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R1556 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R1557 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R1558 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R1559 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R1560 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R1561 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R1562 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R1563 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R1564 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R1565 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R1566 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R1567 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R1568 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R1569 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R1570 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R1571 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R1572 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R1573 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R1574 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R1575 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R1576 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R1577 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R1578 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R1579 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R1580 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R1581 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R1582 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R1583 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R1584 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R1585 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R1586 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R1587 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R1588 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R1589 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R1590 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R1591 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R1592 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R1593 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R1594 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R1595 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R1596 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R1597 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R1598 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R1599 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R1600 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R1601 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R1602 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R1603 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R1604 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R1605 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R1606 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R1607 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R1608 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R1609 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R1610 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R1611 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R1612 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R1613 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R1614 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R1615 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R1616 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R1617 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R1618 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R1619 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R1620 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R1621 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R1622 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R1623 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R1624 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R1625 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R1626 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R1627 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R1628 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R1629 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R1630 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R1631 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R1632 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R1633 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R1634 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R1635 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R1636 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R1637 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R1638 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R1639 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R1640 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R1641 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R1642 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R1643 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R1644 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R1645 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R1646 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R1647 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R1648 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R1649 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R1650 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R1651 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R1652 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R1653 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R1654 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R1655 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R1656 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R1657 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R1658 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R1659 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R1660 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R1661 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R1662 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R1663 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R1664 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R1665 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R1666 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R1667 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R1668 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R1669 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R1670 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R1671 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R1672 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R1673 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R1674 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R1675 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R1676 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R1677 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R1678 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R1679 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R1680 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R1681 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R1682 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R1683 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R1684 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R1685 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R1686 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R1687 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R1688 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R1689 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R1690 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R1691 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R1692 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R1693 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R1694 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R1695 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R1696 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R1697 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R1698 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R1699 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R1700 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R1701 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R1702 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R1703 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R1704 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R1705 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R1706 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R1707 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R1708 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R1709 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R1710 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R1711 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R1712 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R1713 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R1714 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R1715 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R1716 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R1717 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R1718 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R1719 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R1720 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R1721 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R1722 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R1723 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R1724 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R1725 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R1726 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R1727 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R1728 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R1729 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R1730 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R1731 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R1732 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R1733 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R1734 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R1735 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R1736 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R1737 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R1738 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R1739 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R1740 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R1741 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R1742 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R1743 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R1744 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R1745 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R1746 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R1747 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R1748 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R1749 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R1750 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R1751 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R1752 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R1753 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R1754 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R1755 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R1756 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R1757 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R1758 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R1759 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R1760 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R1761 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R1762 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R1763 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R1764 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R1765 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R1766 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R1767 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R1768 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R1769 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R1770 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R1771 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R1772 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R1773 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R1774 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R1775 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R1776 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R1777 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R1778 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R1779 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R1780 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R1781 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R1782 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R1783 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R1784 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R1785 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R1786 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R1787 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R1788 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R1789 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R1790 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R1791 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R1792 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R1793 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R1794 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R1795 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R1796 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R1797 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R1798 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R1799 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R1800 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R1801 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R1802 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R1803 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R1804 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R1805 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R1806 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R1807 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R1808 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R1809 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R1810 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R1811 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R1812 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R1813 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R1814 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R1815 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R1816 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R1817 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R1818 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R1819 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R1820 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R1821 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R1822 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R1823 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R1824 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R1825 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R1826 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R1827 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R1828 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R1829 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R1830 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R1831 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R1832 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R1833 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R1834 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R1835 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R1836 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R1837 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R1838 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R1839 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R1840 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R1841 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R1842 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R1843 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R1844 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R1845 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R1846 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R1847 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R1848 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R1849 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R1850 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R1851 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R1852 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R1853 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R1854 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R1855 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R1856 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R1857 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R1858 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R1859 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R1860 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R1861 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R1862 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R1863 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R1864 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R1865 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R1866 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R1867 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R1868 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R1869 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R1870 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R1871 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R1872 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R1873 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R1874 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R1875 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R1876 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R1877 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R1878 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R1879 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R1880 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R1881 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R1882 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R1883 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R1884 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R1885 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R1886 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R1887 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R1888 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R1889 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R1890 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R1891 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R1892 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R1893 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R1894 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R1895 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R1896 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R1897 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R1898 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R1899 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R1900 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R1901 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R1902 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R1903 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R1904 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R1905 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R1906 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R1907 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R1908 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R1909 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R1910 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R1911 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R1912 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R1913 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R1914 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R1915 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R1916 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R1917 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R1918 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R1919 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R1920 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R1921 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R1922 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R1923 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R1924 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R1925 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R1926 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R1927 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R1928 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R1929 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R1930 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R1931 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R1932 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R1933 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R1934 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R1935 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R1936 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R1937 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R1938 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R1939 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R1940 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R1941 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R1942 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R1943 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R1944 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R1945 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R1946 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R1947 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R1948 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R1949 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R1950 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R1951 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R1952 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R1953 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R1954 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R1955 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R1956 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R1957 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R1958 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R1959 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R1960 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R1961 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R1962 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R1963 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R1964 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R1965 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R1966 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R1967 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R1968 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R1969 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R1970 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R1971 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R1972 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R1973 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R1974 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R1975 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R1976 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R1977 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R1978 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R1979 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R1980 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R1981 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R1982 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R1983 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R1984 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R1985 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R1986 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R1987 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R1988 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R1989 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R1990 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R1991 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R1992 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R1993 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R1994 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R1995 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R1996 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R1997 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R1998 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R1999 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2000 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2001 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2002 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2003 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2004 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2005 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2006 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2007 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2008 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2009 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2010 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2011 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2012 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2013 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2014 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2015 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2016 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2017 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2018 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2019 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2020 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2021 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2022 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2023 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2024 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2025 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2026 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2027 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2028 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2029 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2030 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2031 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2032 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2033 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2034 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2035 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2036 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2037 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R2038 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R2039 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R2040 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R2041 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R2042 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R2043 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R2044 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R2045 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R2046 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R2047 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R2048 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R2049 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R2050 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R2051 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R2052 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R2053 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R2054 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R2055 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R2056 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R2057 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R2058 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R2059 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R2060 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R2061 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R2062 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R2063 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R2064 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R2065 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R2066 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R2067 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R2068 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R2069 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R2070 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R2071 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R2072 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R2073 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R2074 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R2075 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R2076 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R2077 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R2078 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R2079 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R2080 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R2081 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R2082 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R2083 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R2084 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R2085 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R2086 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R2087 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R2088 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R2089 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R2090 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R2091 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R2092 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R2093 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R2094 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R2095 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R2096 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R2097 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R2098 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R2099 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R2100 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R2101 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R2102 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R2103 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R2104 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R2105 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R2106 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R2107 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R2108 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R2109 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R2110 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R2111 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R2112 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R2113 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R2114 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R2115 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R2116 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R2117 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R2118 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R2119 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R2120 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R2121 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R2122 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R2123 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R2124 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R2125 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R2126 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R2127 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R2128 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R2129 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R2130 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R2131 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R2132 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R2133 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R2134 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R2135 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R2136 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R2137 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R2138 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R2139 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R2140 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R2141 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R2142 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R2143 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R2144 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R2145 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R2146 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R2147 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R2148 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R2149 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R2150 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R2151 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R2152 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R2153 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R2154 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R2155 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R2156 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R2157 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R2158 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R2159 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R2160 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R2161 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R2162 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R2163 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R2164 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R2165 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R2166 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R2167 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R2168 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R2169 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R2170 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R2171 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R2172 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R2173 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R2174 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R2175 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R2176 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R2177 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R2178 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R2179 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R2180 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R2181 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R2182 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R2183 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R2184 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R2185 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R2186 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R2187 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R2188 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R2189 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R2190 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R2191 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R2192 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R2193 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R2194 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R2195 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R2196 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R2197 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R2198 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R2199 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R2200 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R2201 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R2202 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R2203 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R2204 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R2205 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R2206 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R2207 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R2208 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R2209 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R2210 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R2211 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R2212 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R2213 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R2214 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R2215 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R2216 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R2217 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R2218 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R2219 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R2220 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R2221 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R2222 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R2223 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R2224 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R2225 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R2226 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R2227 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R2228 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R2229 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R2230 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R2231 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R2232 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R2233 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R2234 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R2235 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R2236 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R2237 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R2238 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R2239 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R2240 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R2241 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R2242 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R2243 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R2244 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R2245 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R2246 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R2247 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R2248 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R2249 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R2250 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R2251 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R2252 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R2253 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R2254 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R2255 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R2256 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R2257 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R2258 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R2259 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R2260 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R2261 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R2262 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R2263 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R2264 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R2265 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R2266 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R2267 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R2268 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R2269 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R2270 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R2271 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R2272 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R2273 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R2274 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R2275 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R2276 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R2277 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R2278 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R2279 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R2280 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R2281 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R2282 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R2283 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R2284 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R2285 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R2286 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R2287 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R2288 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R2289 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R2290 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R2291 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R2292 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R2293 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R2294 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R2295 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R2296 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R2297 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R2298 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R2299 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R2300 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R2301 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R2302 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R2303 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R2304 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R2305 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R2306 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R2307 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R2308 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R2309 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R2310 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R2311 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R2312 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R2313 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R2314 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R2315 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R2316 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R2317 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R2318 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R2319 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R2320 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R2321 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R2322 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R2323 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R2324 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R2325 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R2326 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R2327 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R2328 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R2329 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R2330 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R2331 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R2332 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R2333 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R2334 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R2335 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R2336 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R2337 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R2338 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R2339 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R2340 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R2341 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R2342 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R2343 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R2344 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R2345 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R2346 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R2347 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R2348 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R2349 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R2350 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R2351 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R2352 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R2353 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R2354 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R2355 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R2356 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R2357 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R2358 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R2359 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R2360 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R2361 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R2362 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R2363 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R2364 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R2365 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R2366 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R2367 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R2368 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R2369 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R2370 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R2371 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R2372 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R2373 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R2374 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R2375 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R2376 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R2377 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R2378 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R2379 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R2380 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R2381 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R2382 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R2383 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R2384 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R2385 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R2386 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R2387 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R2388 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R2389 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R2390 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R2391 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R2392 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R2393 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R2394 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R2395 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R2396 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R2397 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R2398 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R2399 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R2400 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R2401 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R2402 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R2403 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R2404 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R2405 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R2406 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R2407 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R2408 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R2409 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R2410 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R2411 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R2412 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R2413 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R2414 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R2415 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R2416 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R2417 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R2418 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R2419 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R2420 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R2421 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R2422 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R2423 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R2424 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R2425 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R2426 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R2427 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R2428 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R2429 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R2430 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R2431 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R2432 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R2433 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R2434 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R2435 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R2436 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R2437 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R2438 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R2439 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R2440 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R2441 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R2442 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R2443 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R2444 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R2445 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R2446 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R2447 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R2448 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R2449 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R2450 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R2451 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R2452 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R2453 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R2454 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R2455 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R2456 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R2457 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R2458 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R2459 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R2460 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R2461 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R2462 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R2463 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R2464 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R2465 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R2466 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R2467 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R2468 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R2469 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R2470 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R2471 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R2472 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R2473 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R2474 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R2475 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R2476 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R2477 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R2478 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R2479 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R2480 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R2481 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R2482 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R2483 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R2484 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R2485 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R2486 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R2487 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R2488 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R2489 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R2490 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R2491 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R2492 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R2493 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R2494 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R2495 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R2496 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R2497 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R2498 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R2499 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R2500 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R2501 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R2502 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R2503 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R2504 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R2505 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R2506 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R2507 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R2508 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R2509 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R2510 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R2511 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R2512 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R2513 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R2514 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R2515 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R2516 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R2517 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R2518 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R2519 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R2520 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R2521 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R2522 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R2523 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R2524 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R2525 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R2526 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R2527 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R2528 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R2529 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R2530 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R2531 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R2532 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R2533 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R2534 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R2535 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R2536 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R2537 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R2538 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R2539 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R2540 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R2541 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R2542 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R2543 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R2544 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R2545 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R2546 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R2547 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R2548 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R2549 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R2550 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R2551 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R2552 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R2553 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R2554 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R2555 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R2556 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R2557 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R2558 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R2559 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R2560 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R2561 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R2562 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R2563 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R2564 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R2565 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R2566 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R2567 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R2568 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R2569 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R2570 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R2571 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R2572 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R2573 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R2574 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R2575 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R2576 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R2577 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R2578 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R2579 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R2580 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R2581 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R2582 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R2583 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R2584 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R2585 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R2586 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R2587 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R2588 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R2589 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R2590 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R2591 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R2592 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R2593 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R2594 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R2595 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R2596 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R2597 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R2598 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R2599 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R2600 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R2601 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R2602 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R2603 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R2604 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R2605 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R2606 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R2607 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R2608 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R2609 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R2610 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R2611 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R2612 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R2613 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R2614 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R2615 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R2616 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R2617 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R2618 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R2619 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R2620 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R2621 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R2622 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R2623 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R2624 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R2625 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R2626 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R2627 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R2628 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R2629 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R2630 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R2631 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R2632 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R2633 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R2634 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R2635 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R2636 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R2637 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R2638 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R2639 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R2640 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R2641 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R2642 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R2643 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R2644 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R2645 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R2646 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R2647 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R2648 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R2649 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R2650 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R2651 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R2652 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R2653 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R2654 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R2655 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R2656 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R2657 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R2658 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R2659 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R2660 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R2661 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R2662 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R2663 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R2664 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R2665 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R2666 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R2667 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R2668 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R2669 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R2670 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R2671 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R2672 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R2673 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R2674 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R2675 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R2676 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R2677 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R2678 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R2679 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R2680 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R2681 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R2682 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R2683 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R2684 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R2685 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R2686 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R2687 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R2688 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R2689 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R2690 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R2691 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R2692 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R2693 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R2694 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R2695 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R2696 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R2697 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R2698 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R2699 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R2700 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R2701 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R2702 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R2703 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R2704 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R2705 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R2706 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R2707 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R2708 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R2709 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R2710 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R2711 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R2712 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R2713 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R2714 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R2715 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R2716 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R2717 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R2718 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R2719 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R2720 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R2721 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R2722 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R2723 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R2724 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R2725 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R2726 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R2727 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R2728 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R2729 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R2730 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R2731 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R2732 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R2733 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R2734 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R2735 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R2736 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R2737 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R2738 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R2739 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R2740 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R2741 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R2742 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R2743 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R2744 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R2745 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R2746 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R2747 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R2748 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R2749 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R2750 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R2751 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R2752 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R2753 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R2754 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R2755 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R2756 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R2757 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R2758 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R2759 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R2760 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R2761 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R2762 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R2763 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R2764 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R2765 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R2766 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R2767 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R2768 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R2769 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R2770 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R2771 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R2772 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R2773 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R2774 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R2775 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R2776 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R2777 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R2778 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R2779 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R2780 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R2781 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R2782 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R2783 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R2784 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R2785 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R2786 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R2787 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R2788 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R2789 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R2790 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R2791 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R2792 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R2793 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R2794 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R2795 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R2796 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R2797 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R2798 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R2799 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R2800 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R2801 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R2802 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R2803 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R2804 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R2805 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R2806 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R2807 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R2808 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R2809 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R2810 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R2811 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R2812 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R2813 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R2814 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R2815 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R2816 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R2817 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R2818 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R2819 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R2820 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R2821 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R2822 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R2823 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R2824 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R2825 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R2826 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R2827 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R2828 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R2829 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R2830 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R2831 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R2832 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R2833 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R2834 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R2835 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R2836 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R2837 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R2838 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R2839 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R2840 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R2841 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R2842 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R2843 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R2844 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R2845 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R2846 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R2847 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R2848 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R2849 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R2850 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R2851 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R2852 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R2853 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R2854 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R2855 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R2856 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R2857 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R2858 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R2859 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R2860 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R2861 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R2862 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R2863 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R2864 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R2865 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R2866 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R2867 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R2868 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R2869 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R2870 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R2871 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R2872 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R2873 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R2874 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R2875 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R2876 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R2877 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R2878 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R2879 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R2880 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R2881 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R2882 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R2883 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R2884 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R2885 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R2886 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R2887 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R2888 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R2889 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R2890 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R2891 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R2892 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R2893 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R2894 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R2895 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R2896 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R2897 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R2898 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R2899 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R2900 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R2901 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R2902 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R2903 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R2904 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R2905 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R2906 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R2907 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R2908 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R2909 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R2910 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R2911 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R2912 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R2913 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R2914 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R2915 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R2916 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R2917 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R2918 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R2919 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R2920 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R2921 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R2922 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R2923 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R2924 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R2925 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R2926 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R2927 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R2928 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R2929 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R2930 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R2931 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R2932 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R2933 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R2934 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R2935 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R2936 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R2937 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R2938 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R2939 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R2940 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R2941 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R2942 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R2943 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R2944 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R2945 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R2946 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R2947 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R2948 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R2949 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R2950 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R2951 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R2952 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R2953 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R2954 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R2955 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R2956 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R2957 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R2958 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R2959 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R2960 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R2961 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R2962 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R2963 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R2964 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R2965 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R2966 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R2967 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R2968 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R2969 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R2970 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R2971 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R2972 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R2973 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R2974 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R2975 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R2976 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R2977 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R2978 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R2979 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R2980 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R2981 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R2982 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R2983 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R2984 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R2985 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R2986 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R2987 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R2988 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R2989 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R2990 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R2991 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R2992 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R2993 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R2994 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R2995 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R2996 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R2997 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R2998 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R2999 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R3000 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R3001 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R3002 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R3003 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R3004 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R3005 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R3006 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R3007 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R3008 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R3009 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R3010 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R3011 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R3012 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R3013 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R3014 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R3015 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R3016 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R3017 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R3018 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R3019 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R3020 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R3021 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R3022 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R3023 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R3024 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R3025 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R3026 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R3027 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R3028 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R3029 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R3030 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R3031 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R3032 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R3033 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R3034 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R3035 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R3036 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R3037 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R3038 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R3039 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R3040 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R3041 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R3042 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R3043 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R3044 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R3045 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R3046 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R3047 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R3048 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R3049 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R3050 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R3051 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R3052 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R3053 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R3054 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R3055 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R3056 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R3057 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R3058 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R3059 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R3060 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R3061 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R3062 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R3063 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R3064 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R3065 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R3066 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R3067 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R3068 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R3069 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R3070 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R3071 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R3072 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R3073 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R3074 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R3075 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R3076 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R3077 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R3078 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R3079 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R3080 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R3081 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R3082 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R3083 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R3084 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R3085 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R3086 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R3087 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R3088 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R3089 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R3090 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R3091 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R3092 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R3093 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R3094 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R3095 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R3096 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R3097 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R3098 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R3099 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R3100 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R3101 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R3102 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R3103 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R3104 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R3105 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R3106 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R3107 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R3108 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R3109 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R3110 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R3111 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R3112 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R3113 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R3114 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R3115 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R3116 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R3117 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R3118 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R3119 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R3120 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R3121 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R3122 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R3123 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R3124 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R3125 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R3126 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R3127 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R3128 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R3129 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R3130 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R3131 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R3132 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R3133 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R3134 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R3135 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R3136 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R3137 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R3138 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R3139 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R3140 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R3141 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R3142 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R3143 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R3144 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R3145 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R3146 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R3147 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R3148 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R3149 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R3150 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R3151 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R3152 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R3153 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R3154 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R3155 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R3156 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R3157 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R3158 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R3159 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R3160 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R3161 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R3162 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R3163 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R3164 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R3165 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R3166 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R3167 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R3168 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R3169 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R3170 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R3171 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R3172 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R3173 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R3174 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R3175 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R3176 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R3177 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R3178 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R3179 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R3180 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R3181 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R3182 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R3183 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R3184 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R3185 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R3186 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R3187 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R3188 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R3189 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R3190 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R3191 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R3192 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R3193 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R3194 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R3195 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R3196 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R3197 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R3198 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R3199 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R3200 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R3201 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R3202 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R3203 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R3204 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R3205 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R3206 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R3207 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R3208 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R3209 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R3210 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R3211 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R3212 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R3213 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R3214 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R3215 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R3216 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R3217 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R3218 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R3219 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R3220 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R3221 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R3222 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R3223 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R3224 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R3225 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R3226 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R3227 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R3228 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R3229 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R3230 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R3231 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R3232 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R3233 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R3234 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R3235 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R3236 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R3237 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R3238 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R3239 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R3240 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R3241 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R3242 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R3243 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R3244 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R3245 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R3246 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R3247 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R3248 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R3249 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R3250 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R3251 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R3252 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R3253 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R3254 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R3255 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R3256 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R3257 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R3258 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R3259 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R3260 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R3261 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R3262 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R3263 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R3264 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R3265 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R3266 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R3267 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R3268 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R3269 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R3270 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R3271 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R3272 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R3273 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R3274 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R3275 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R3276 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R3277 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R3278 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R3279 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R3280 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R3281 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R3282 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R3283 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R3284 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R3285 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R3286 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R3287 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R3288 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R3289 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R3290 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R3291 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R3292 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R3293 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R3294 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R3295 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R3296 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R3297 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R3298 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R3299 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R3300 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R3301 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R3302 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R3303 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R3304 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R3305 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R3306 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R3307 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R3308 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R3309 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R3310 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R3311 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R3312 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R3313 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R3314 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R3315 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R3316 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R3317 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R3318 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R3319 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R3320 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R3321 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R3322 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R3323 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R3324 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R3325 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R3326 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R3327 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R3328 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R3329 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R3330 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R3331 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R3332 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R3333 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R3334 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R3335 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R3336 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R3337 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R3338 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R3339 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R3340 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R3341 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R3342 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R3343 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R3344 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R3345 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R3346 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R3347 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R3348 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R3349 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R3350 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R3351 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R3352 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R3353 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R3354 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R3355 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R3356 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R3357 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R3358 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R3359 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R3360 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R3361 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R3362 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R3363 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R3364 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R3365 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R3366 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R3367 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R3368 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R3369 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R3370 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R3371 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R3372 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R3373 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R3374 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R3375 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R3376 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R3377 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R3378 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R3379 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R3380 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R3381 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R3382 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R3383 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R3384 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R3385 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R3386 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R3387 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R3388 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R3389 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R3390 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R3391 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R3392 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R3393 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R3394 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R3395 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R3396 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R3397 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R3398 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R3399 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R3400 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R3401 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R3402 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R3403 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R3404 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R3405 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R3406 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R3407 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R3408 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R3409 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R3410 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R3411 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R3412 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R3413 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R3414 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R3415 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R3416 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R3417 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R3418 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R3419 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R3420 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R3421 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R3422 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R3423 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R3424 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R3425 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R3426 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R3427 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R3428 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R3429 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R3430 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R3431 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R3432 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R3433 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R3434 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R3435 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R3436 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R3437 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R3438 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R3439 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R3440 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R3441 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R3442 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R3443 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R3444 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R3445 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R3446 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R3447 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R3448 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R3449 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R3450 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R3451 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R3452 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R3453 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R3454 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R3455 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R3456 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R3457 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R3458 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R3459 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R3460 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R3461 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R3462 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R3463 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R3464 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R3465 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R3466 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R3467 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R3468 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R3469 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R3470 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R3471 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R3472 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R3473 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R3474 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R3475 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R3476 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R3477 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R3478 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R3479 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R3480 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R3481 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R3482 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R3483 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R3484 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R3485 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R3486 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R3487 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R3488 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R3489 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R3490 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R3491 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R3492 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R3493 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R3494 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R3495 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R3496 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R3497 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R3498 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R3499 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R3500 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R3501 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R3502 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R3503 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R3504 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R3505 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R3506 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R3507 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R3508 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R3509 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R3510 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R3511 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R3512 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R3513 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R3514 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R3515 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R3516 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R3517 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R3518 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R3519 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R3520 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R3521 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R3522 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R3523 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R3524 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R3525 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R3526 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R3527 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R3528 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R3529 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R3530 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R3531 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R3532 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R3533 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R3534 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R3535 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R3536 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R3537 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R3538 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R3539 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R3540 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R3541 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R3542 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R3543 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R3544 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R3545 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R3546 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R3547 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R3548 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R3549 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R3550 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R3551 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R3552 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R3553 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R3554 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R3555 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R3556 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R3557 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R3558 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R3559 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R3560 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R3561 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R3562 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R3563 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R3564 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R3565 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R3566 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R3567 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R3568 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R3569 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R3570 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R3571 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R3572 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R3573 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R3574 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R3575 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R3576 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R3577 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R3578 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R3579 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R3580 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R3581 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R3582 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R3583 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R3584 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R3585 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R3586 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R3587 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R3588 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R3589 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R3590 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R3591 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R3592 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R3593 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R3594 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R3595 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R3596 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R3597 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R3598 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R3599 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R3600 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R3601 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R3602 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R3603 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R3604 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R3605 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R3606 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R3607 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R3608 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R3609 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R3610 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R3611 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R3612 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R3613 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R3614 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R3615 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R3616 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R3617 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R3618 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R3619 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R3620 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R3621 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R3622 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R3623 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R3624 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R3625 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R3626 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R3627 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R3628 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R3629 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R3630 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R3631 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R3632 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R3633 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R3634 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R3635 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R3636 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R3637 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R3638 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R3639 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R3640 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R3641 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R3642 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R3643 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R3644 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R3645 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R3646 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R3647 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R3648 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R3649 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R3650 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R3651 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R3652 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R3653 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R3654 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R3655 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R3656 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R3657 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R3658 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R3659 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R3660 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R3661 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R3662 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R3663 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R3664 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R3665 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R3666 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R3667 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R3668 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R3669 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R3670 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R3671 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R3672 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R3673 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R3674 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R3675 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R3676 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R3677 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R3678 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R3679 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R3680 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R3681 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R3682 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R3683 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R3684 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R3685 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R3686 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R3687 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R3688 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R3689 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R3690 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R3691 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R3692 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R3693 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R3694 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R3695 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R3696 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R3697 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R3698 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R3699 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R3700 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R3701 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R3702 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R3703 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R3704 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R3705 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R3706 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R3707 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R3708 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R3709 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R3710 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R3711 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R3712 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R3713 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R3714 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R3715 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R3716 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R3717 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R3718 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R3719 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R3720 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R3721 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R3722 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R3723 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R3724 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R3725 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R3726 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R3727 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R3728 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R3729 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R3730 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R3731 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R3732 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R3733 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R3734 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R3735 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R3736 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R3737 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R3738 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R3739 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R3740 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R3741 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R3742 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R3743 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R3744 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R3745 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R3746 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R3747 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R3748 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R3749 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R3750 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R3751 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R3752 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R3753 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R3754 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R3755 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R3756 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R3757 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R3758 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R3759 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R3760 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R3761 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R3762 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R3763 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R3764 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R3765 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R3766 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R3767 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R3768 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R3769 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R3770 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R3771 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R3772 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R3773 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R3774 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R3775 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R3776 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R3777 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R3778 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R3779 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R3780 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R3781 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R3782 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R3783 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R3784 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R3785 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R3786 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R3787 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R3788 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R3789 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R3790 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R3791 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R3792 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R3793 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R3794 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R3795 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R3796 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R3797 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R3798 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R3799 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R3800 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R3801 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R3802 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R3803 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R3804 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R3805 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R3806 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R3807 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R3808 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R3809 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R3810 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R3811 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R3812 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R3813 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R3814 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R3815 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R3816 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R3817 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R3818 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R3819 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R3820 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R3821 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R3822 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R3823 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R3824 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R3825 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R3826 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R3827 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R3828 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R3829 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R3830 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R3831 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R3832 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R3833 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R3834 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R3835 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R3836 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R3837 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R3838 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R3839 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R3840 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R3841 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R3842 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R3843 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R3844 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R3845 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R3846 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R3847 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R3848 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R3849 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R3850 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R3851 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R3852 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R3853 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R3854 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R3855 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R3856 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R3857 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R3858 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R3859 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R3860 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R3861 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R3862 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R3863 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R3864 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R3865 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R3866 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R3867 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R3868 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R3869 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R3870 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R3871 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R3872 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R3873 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R3874 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R3875 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R3876 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R3877 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R3878 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R3879 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R3880 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R3881 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R3882 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R3883 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R3884 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R3885 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R3886 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R3887 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R3888 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R3889 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R3890 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R3891 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R3892 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R3893 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R3894 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R3895 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R3896 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R3897 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R3898 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R3899 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R3900 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R3901 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R3902 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R3903 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R3904 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R3905 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R3906 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R3907 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R3908 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R3909 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R3910 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R3911 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R3912 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R3913 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R3914 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R3915 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R3916 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R3917 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R3918 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R3919 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R3920 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R3921 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R3922 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R3923 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R3924 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R3925 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R3926 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R3927 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R3928 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R3929 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R3930 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R3931 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R3932 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R3933 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R3934 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R3935 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R3936 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R3937 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R3938 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R3939 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R3940 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R3941 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R3942 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R3943 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R3944 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R3945 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R3946 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R3947 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R3948 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R3949 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R3950 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R3951 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R3952 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R3953 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R3954 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R3955 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R3956 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R3957 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R3958 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R3959 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R3960 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R3961 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R3962 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R3963 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R3964 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R3965 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R3966 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R3967 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R3968 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R3969 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R3970 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R3971 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R3972 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R3973 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R3974 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R3975 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R3976 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R3977 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R3978 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R3979 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R3980 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R3981 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R3982 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R3983 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R3984 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R3985 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R3986 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R3987 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R3988 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R3989 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R3990 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R3991 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R3992 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R3993 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R3994 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R3995 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R3996 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R3997 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R3998 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R3999 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R4000 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R4001 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R4002 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R4003 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R4004 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R4005 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R4006 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R4007 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R4008 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R4009 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R4010 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R4011 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R4012 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R4013 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R4014 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R4015 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R4016 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R4017 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R4018 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R4019 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R4020 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R4021 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R4022 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R4023 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R4024 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R4025 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R4026 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R4027 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R4028 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R4029 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R4030 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R4031 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R4032 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R4033 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R4034 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R4035 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R4036 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R4037 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R4038 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R4039 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R4040 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R4041 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R4042 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R4043 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R4044 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R4045 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R4046 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R4047 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R4048 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R4049 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R4050 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R4051 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R4052 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R4053 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R4054 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R4055 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R4056 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R4057 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R4058 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R4059 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R4060 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R4061 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R4062 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R4063 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R4064 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R4065 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R4066 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R4067 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R4068 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R4069 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R4070 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R4071 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R4072 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R4073 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R4074 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R4075 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R4076 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R4077 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R4078 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R4079 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R4080 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R4081 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R4082 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R4083 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R4084 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R4085 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R4086 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R4087 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R4088 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R4089 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R4090 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R4091 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R4092 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R4093 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R4094 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R4095 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R4096 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R4097 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R4098 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R4099 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R4100 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R4101 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R4102 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R4103 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R4104 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R4105 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R4106 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R4107 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R4108 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R4109 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R4110 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R4111 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R4112 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R4113 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R4114 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R4115 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R4116 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R4117 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R4118 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R4119 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R4120 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R4121 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R4122 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R4123 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R4124 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R4125 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R4126 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R4127 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R4128 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R4129 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R4130 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R4131 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R4132 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R4133 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R4134 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R4135 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R4136 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R4137 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R4138 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R4139 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R4140 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R4141 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R4142 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R4143 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R4144 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R4145 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R4146 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R4147 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R4148 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R4149 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R4150 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R4151 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R4152 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R4153 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R4154 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R4155 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R4156 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R4157 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R4158 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R4159 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R4160 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R4161 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R4162 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R4163 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R4164 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R4165 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R4166 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R4167 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R4168 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R4169 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R4170 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R4171 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R4172 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R4173 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R4174 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R4175 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R4176 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R4177 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R4178 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R4179 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R4180 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R4181 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R4182 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R4183 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R4184 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R4185 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R4186 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R4187 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R4188 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R4189 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R4190 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R4191 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R4192 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R4193 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R4194 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R4195 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R4196 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R4197 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R4198 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R4199 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R4200 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R4201 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R4202 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R4203 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R4204 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R4205 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R4206 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R4207 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R4208 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R4209 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R4210 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R4211 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R4212 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R4213 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R4214 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R4215 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R4216 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R4217 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R4218 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R4219 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R4220 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R4221 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R4222 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R4223 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R4224 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R4225 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R4226 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R4227 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R4228 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R4229 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R4230 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R4231 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R4232 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R4233 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R4234 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R4235 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R4236 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R4237 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R4238 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R4239 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R4240 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R4241 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R4242 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R4243 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R4244 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R4245 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R4246 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R4247 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R4248 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R4249 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R4250 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R4251 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R4252 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R4253 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R4254 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R4255 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R4256 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R4257 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R4258 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R4259 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R4260 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R4261 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R4262 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R4263 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R4264 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R4265 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R4266 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R4267 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R4268 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R4269 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R4270 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R4271 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R4272 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R4273 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R4274 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R4275 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R4276 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R4277 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R4278 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R4279 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R4280 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R4281 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R4282 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R4283 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R4284 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R4285 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R4286 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R4287 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R4288 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R4289 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R4290 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R4291 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R4292 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R4293 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R4294 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R4295 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R4296 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R4297 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R4298 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R4299 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R4300 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R4301 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R4302 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R4303 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R4304 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R4305 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R4306 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R4307 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R4308 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R4309 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R4310 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R4311 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R4312 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R4313 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R4314 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R4315 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R4316 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R4317 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R4318 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R4319 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R4320 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R4321 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R4322 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R4323 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R4324 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R4325 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R4326 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R4327 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R4328 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R4329 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R4330 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R4331 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R4332 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R4333 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R4334 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R4335 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R4336 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R4337 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R4338 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R4339 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R4340 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R4341 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R4342 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R4343 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R4344 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R4345 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R4346 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R4347 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R4348 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R4349 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R4350 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R4351 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R4352 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R4353 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R4354 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R4355 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R4356 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R4357 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R4358 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R4359 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R4360 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R4361 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R4362 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R4363 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R4364 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R4365 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R4366 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R4367 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R4368 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R4369 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R4370 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R4371 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R4372 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R4373 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R4374 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R4375 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R4376 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R4377 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R4378 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R4379 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R4380 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R4381 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R4382 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R4383 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R4384 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R4385 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R4386 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R4387 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R4388 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R4389 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R4390 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R4391 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R4392 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R4393 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R4394 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R4395 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R4396 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R4397 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R4398 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R4399 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R4400 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R4401 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R4402 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R4403 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R4404 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R4405 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R4406 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R4407 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R4408 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R4409 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R4410 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R4411 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R4412 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R4413 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R4414 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R4415 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R4416 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R4417 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R4418 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R4419 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R4420 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R4421 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R4422 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R4423 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R4424 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R4425 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R4426 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R4427 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R4428 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R4429 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R4430 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R4431 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R4432 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R4433 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R4434 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R4435 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R4436 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R4437 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R4438 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R4439 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R4440 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R4441 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R4442 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R4443 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R4444 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R4445 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R4446 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R4447 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R4448 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R4449 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R4450 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R4451 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R4452 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R4453 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R4454 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R4455 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R4456 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R4457 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R4458 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R4459 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R4460 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R4461 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R4462 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R4463 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R4464 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R4465 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R4466 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R4467 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R4468 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R4469 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R4470 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R4471 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R4472 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R4473 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R4474 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R4475 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R4476 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R4477 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R4478 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R4479 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R4480 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R4481 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R4482 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R4483 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R4484 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R4485 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R4486 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R4487 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R4488 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R4489 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R4490 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R4491 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R4492 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R4493 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R4494 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R4495 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R4496 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R4497 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R4498 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R4499 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R4500 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R4501 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R4502 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R4503 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R4504 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R4505 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R4506 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R4507 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R4508 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R4509 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R4510 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R4511 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R4512 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R4513 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R4514 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R4515 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R4516 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R4517 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R4518 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R4519 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R4520 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R4521 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R4522 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R4523 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R4524 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R4525 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R4526 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R4527 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R4528 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R4529 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R4530 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R4531 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R4532 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R4533 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R4534 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R4535 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R4536 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R4537 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R4538 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R4539 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R4540 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R4541 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R4542 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R4543 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R4544 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R4545 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R4546 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R4547 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R4548 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R4549 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R4550 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R4551 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R4552 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R4553 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R4554 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R4555 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R4556 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R4557 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R4558 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R4559 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R4560 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R4561 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R4562 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R4563 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R4564 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R4565 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R4566 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R4567 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R4568 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R4569 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R4570 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R4571 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R4572 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R4573 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R4574 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R4575 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R4576 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R4577 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R4578 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R4579 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R4580 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R4581 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R4582 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R4583 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R4584 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R4585 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R4586 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R4587 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R4588 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R4589 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R4590 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R4591 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R4592 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R4593 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R4594 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R4595 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R4596 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R4597 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R4598 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R4599 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R4600 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R4601 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R4602 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R4603 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R4604 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R4605 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R4606 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R4607 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R4608 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R4609 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R4610 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R4611 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R4612 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R4613 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R4614 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R4615 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R4616 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R4617 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R4618 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R4619 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R4620 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R4621 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R4622 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R4623 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R4624 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R4625 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R4626 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R4627 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R4628 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R4629 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R4630 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R4631 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R4632 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R4633 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R4634 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R4635 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R4636 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R4637 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R4638 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R4639 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R4640 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R4641 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R4642 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R4643 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R4644 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R4645 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R4646 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R4647 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R4648 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R4649 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R4650 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R4651 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R4652 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R4653 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R4654 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R4655 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R4656 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R4657 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R4658 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R4659 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R4660 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R4661 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R4662 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R4663 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R4664 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R4665 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R4666 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R4667 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R4668 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R4669 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R4670 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R4671 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R4672 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R4673 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R4674 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R4675 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R4676 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R4677 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R4678 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R4679 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R4680 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R4681 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R4682 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R4683 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R4684 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R4685 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R4686 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R4687 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R4688 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R4689 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R4690 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R4691 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R4692 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R4693 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R4694 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R4695 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R4696 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R4697 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R4698 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R4699 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R4700 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R4701 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R4702 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R4703 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R4704 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R4705 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R4706 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R4707 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R4708 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R4709 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R4710 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R4711 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R4712 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R4713 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R4714 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R4715 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R4716 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R4717 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R4718 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R4719 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R4720 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R4721 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R4722 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R4723 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R4724 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R4725 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R4726 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R4727 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R4728 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R4729 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R4730 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R4731 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R4732 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R4733 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R4734 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R4735 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R4736 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R4737 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R4738 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R4739 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R4740 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R4741 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R4742 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R4743 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R4744 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R4745 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R4746 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R4747 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R4748 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R4749 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R4750 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R4751 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R4752 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R4753 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R4754 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R4755 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R4756 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R4757 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R4758 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R4759 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R4760 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R4761 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R4762 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R4763 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R4764 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R4765 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R4766 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R4767 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R4768 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R4769 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R4770 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R4771 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R4772 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R4773 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R4774 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R4775 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R4776 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R4777 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R4778 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R4779 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R4780 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R4781 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R4782 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R4783 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R4784 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R4785 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R4786 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R4787 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R4788 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R4789 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R4790 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R4791 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R4792 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R4793 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R4794 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R4795 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R4796 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R4797 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R4798 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R4799 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R4800 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R4801 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R4802 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R4803 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R4804 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R4805 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R4806 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R4807 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R4808 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R4809 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R4810 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R4811 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R4812 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R4813 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R4814 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R4815 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R4816 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R4817 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R4818 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R4819 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R4820 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R4821 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R4822 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R4823 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R4824 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R4825 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R4826 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R4827 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R4828 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R4829 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R4830 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R4831 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R4832 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R4833 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R4834 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R4835 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R4836 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R4837 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R4838 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R4839 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R4840 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R4841 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R4842 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R4843 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R4844 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R4845 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R4846 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R4847 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R4848 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R4849 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R4850 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R4851 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R4852 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R4853 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R4854 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R4855 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R4856 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R4857 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R4858 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R4859 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R4860 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R4861 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R4862 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R4863 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R4864 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R4865 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R4866 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R4867 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R4868 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R4869 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R4870 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R4871 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R4872 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R4873 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R4874 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R4875 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R4876 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R4877 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R4878 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R4879 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R4880 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R4881 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R4882 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R4883 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R4884 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R4885 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R4886 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R4887 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R4888 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R4889 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R4890 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R4891 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R4892 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R4893 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R4894 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R4895 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R4896 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R4897 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R4898 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R4899 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R4900 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R4901 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R4902 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R4903 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R4904 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R4905 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R4906 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R4907 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R4908 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R4909 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R4910 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R4911 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R4912 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R4913 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R4914 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R4915 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R4916 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R4917 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R4918 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R4919 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R4920 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R4921 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R4922 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R4923 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R4924 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R4925 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R4926 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R4927 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R4928 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R4929 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R4930 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R4931 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R4932 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R4933 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R4934 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R4935 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R4936 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R4937 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R4938 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R4939 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R4940 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R4941 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R4942 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R4943 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R4944 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R4945 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R4946 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R4947 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R4948 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R4949 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R4950 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R4951 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R4952 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R4953 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R4954 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R4955 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R4956 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R4957 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R4958 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R4959 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R4960 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R4961 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R4962 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R4963 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R4964 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R4965 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R4966 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R4967 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R4968 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R4969 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R4970 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R4971 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R4972 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R4973 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R4974 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R4975 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R4976 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R4977 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R4978 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R4979 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R4980 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R4981 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R4982 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R4983 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R4984 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R4985 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R4986 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R4987 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R4988 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R4989 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R4990 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R4991 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R4992 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R4993 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R4994 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R4995 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R4996 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R4997 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R4998 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R4999 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R5000 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R5001 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R5002 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R5003 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R5004 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R5005 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R5006 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R5007 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R5008 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R5009 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R5010 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R5011 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R5012 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R5013 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R5014 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R5015 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R5016 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R5017 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R5018 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R5019 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R5020 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R5021 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R5022 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R5023 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R5024 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R5025 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R5026 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R5027 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R5028 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R5029 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R5030 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R5031 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R5032 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R5033 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R5034 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R5035 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R5036 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R5037 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R5038 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R5039 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R5040 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R5041 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R5042 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R5043 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R5044 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R5045 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R5046 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R5047 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R5048 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R5049 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R5050 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R5051 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R5052 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R5053 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R5054 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R5055 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R5056 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R5057 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R5058 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R5059 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R5060 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R5061 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R5062 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R5063 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R5064 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R5065 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R5066 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R5067 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R5068 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R5069 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R5070 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R5071 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R5072 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R5073 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R5074 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R5075 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R5076 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R5077 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R5078 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R5079 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R5080 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R5081 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R5082 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R5083 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R5084 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R5085 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R5086 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R5087 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R5088 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R5089 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R5090 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R5091 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R5092 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R5093 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R5094 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R5095 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R5096 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R5097 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R5098 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R5099 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R5100 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R5101 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R5102 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R5103 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R5104 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R5105 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R5106 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R5107 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R5108 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R5109 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R5110 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R5111 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R5112 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R5113 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R5114 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R5115 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R5116 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R5117 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R5118 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R5119 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R5120 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R5121 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R5122 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R5123 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R5124 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R5125 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R5126 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R5127 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R5128 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R5129 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R5130 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R5131 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R5132 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R5133 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R5134 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R5135 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R5136 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R5137 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R5138 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R5139 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R5140 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R5141 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R5142 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R5143 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R5144 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R5145 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R5146 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R5147 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R5148 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R5149 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R5150 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R5151 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R5152 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R5153 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R5154 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R5155 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R5156 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R5157 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R5158 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R5159 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R5160 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R5161 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R5162 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R5163 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R5164 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R5165 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R5166 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R5167 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R5168 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R5169 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R5170 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R5171 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R5172 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R5173 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R5174 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R5175 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R5176 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R5177 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R5178 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R5179 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R5180 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R5181 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R5182 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R5183 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R5184 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R5185 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R5186 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R5187 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R5188 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R5189 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R5190 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R5191 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R5192 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R5193 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R5194 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R5195 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R5196 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R5197 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R5198 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R5199 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R5200 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R5201 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R5202 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R5203 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R5204 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R5205 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R5206 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R5207 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R5208 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R5209 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R5210 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R5211 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R5212 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R5213 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R5214 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R5215 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R5216 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R5217 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R5218 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R5219 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R5220 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R5221 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R5222 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R5223 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R5224 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R5225 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R5226 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R5227 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R5228 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R5229 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R5230 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R5231 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R5232 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R5233 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R5234 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R5235 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R5236 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R5237 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R5238 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R5239 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R5240 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R5241 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R5242 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R5243 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R5244 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R5245 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R5246 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R5247 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R5248 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R5249 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R5250 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R5251 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R5252 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R5253 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R5254 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R5255 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R5256 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R5257 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R5258 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R5259 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R5260 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R5261 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R5262 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R5263 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R5264 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R5265 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R5266 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R5267 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R5268 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R5269 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R5270 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R5271 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R5272 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R5273 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R5274 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R5275 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R5276 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R5277 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R5278 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R5279 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R5280 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R5281 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R5282 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R5283 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R5284 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R5285 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R5286 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R5287 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R5288 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R5289 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R5290 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R5291 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R5292 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R5293 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R5294 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R5295 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R5296 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R5297 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R5298 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R5299 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R5300 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R5301 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R5302 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R5303 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R5304 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R5305 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R5306 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R5307 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R5308 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R5309 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R5310 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R5311 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R5312 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R5313 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R5314 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R5315 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R5316 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R5317 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R5318 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R5319 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R5320 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R5321 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R5322 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R5323 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R5324 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R5325 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R5326 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R5327 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R5328 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R5329 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R5330 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R5331 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R5332 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R5333 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R5334 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R5335 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R5336 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R5337 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R5338 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R5339 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R5340 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R5341 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R5342 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R5343 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R5344 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R5345 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R5346 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R5347 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R5348 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R5349 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R5350 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R5351 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R5352 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R5353 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R5354 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R5355 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R5356 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R5357 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R5358 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R5359 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R5360 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R5361 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R5362 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R5363 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R5364 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R5365 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R5366 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R5367 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R5368 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R5369 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R5370 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R5371 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R5372 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R5373 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R5374 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R5375 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R5376 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R5377 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R5378 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R5379 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R5380 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R5381 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R5382 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R5383 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R5384 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R5385 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R5386 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R5387 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R5388 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R5389 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R5390 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R5391 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R5392 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R5393 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R5394 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R5395 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R5396 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R5397 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R5398 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R5399 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R5400 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R5401 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R5402 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R5403 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R5404 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R5405 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R5406 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R5407 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R5408 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R5409 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R5410 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R5411 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R5412 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R5413 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R5414 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R5415 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R5416 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R5417 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R5418 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R5419 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R5420 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R5421 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R5422 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R5423 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R5424 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R5425 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R5426 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R5427 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R5428 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R5429 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R5430 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R5431 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R5432 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R5433 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R5434 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R5435 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R5436 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R5437 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R5438 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R5439 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R5440 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R5441 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R5442 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R5443 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R5444 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R5445 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R5446 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R5447 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R5448 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R5449 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R5450 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R5451 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R5452 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R5453 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R5454 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R5455 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R5456 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R5457 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R5458 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R5459 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R5460 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R5461 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R5462 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R5463 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R5464 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R5465 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R5466 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R5467 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R5468 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R5469 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R5470 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R5471 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R5472 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R5473 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R5474 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R5475 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R5476 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R5477 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R5478 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R5479 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R5480 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R5481 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R5482 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R5483 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R5484 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R5485 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R5486 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R5487 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R5488 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R5489 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R5490 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R5491 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R5492 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R5493 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R5494 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R5495 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R5496 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R5497 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R5498 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R5499 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R5500 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R5501 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R5502 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R5503 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R5504 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R5505 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R5506 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R5507 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R5508 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R5509 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R5510 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R5511 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R5512 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R5513 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R5514 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R5515 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R5516 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R5517 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R5518 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R5519 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R5520 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R5521 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R5522 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R5523 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R5524 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R5525 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R5526 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R5527 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R5528 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R5529 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R5530 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R5531 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R5532 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R5533 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R5534 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R5535 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R5536 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R5537 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R5538 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R5539 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R5540 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R5541 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R5542 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R5543 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R5544 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R5545 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R5546 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R5547 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R5548 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R5549 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R5550 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R5551 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R5552 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R5553 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R5554 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R5555 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R5556 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R5557 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R5558 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R5559 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R5560 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R5561 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R5562 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R5563 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R5564 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R5565 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R5566 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R5567 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R5568 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R5569 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R5570 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R5571 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R5572 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R5573 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R5574 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R5575 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R5576 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R5577 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R5578 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R5579 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R5580 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R5581 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R5582 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R5583 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R5584 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R5585 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R5586 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R5587 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R5588 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R5589 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R5590 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R5591 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R5592 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R5593 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R5594 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R5595 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R5596 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R5597 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R5598 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R5599 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R5600 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R5601 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R5602 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R5603 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R5604 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R5605 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R5606 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R5607 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R5608 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R5609 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R5610 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R5611 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R5612 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R5613 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R5614 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R5615 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R5616 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R5617 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R5618 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R5619 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R5620 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R5621 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R5622 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R5623 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R5624 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R5625 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R5626 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R5627 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R5628 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R5629 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R5630 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R5631 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R5632 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R5633 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R5634 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R5635 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R5636 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R5637 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R5638 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R5639 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R5640 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R5641 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R5642 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R5643 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R5644 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R5645 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R5646 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R5647 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R5648 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R5649 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R5650 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R5651 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R5652 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R5653 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R5654 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R5655 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R5656 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R5657 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R5658 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R5659 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R5660 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R5661 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R5662 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R5663 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R5664 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R5665 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R5666 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R5667 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R5668 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R5669 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R5670 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R5671 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R5672 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R5673 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R5674 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R5675 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R5676 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R5677 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R5678 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R5679 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R5680 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R5681 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R5682 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R5683 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R5684 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R5685 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R5686 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R5687 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R5688 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R5689 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R5690 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R5691 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R5692 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R5693 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R5694 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R5695 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R5696 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R5697 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R5698 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R5699 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R5700 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R5701 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R5702 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R5703 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R5704 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R5705 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R5706 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R5707 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R5708 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R5709 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R5710 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R5711 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R5712 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R5713 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R5714 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R5715 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R5716 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R5717 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R5718 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R5719 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R5720 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R5721 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R5722 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R5723 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R5724 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R5725 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R5726 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R5727 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R5728 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R5729 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R5730 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R5731 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R5732 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R5733 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R5734 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R5735 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R5736 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R5737 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R5738 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R5739 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R5740 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R5741 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R5742 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R5743 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R5744 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R5745 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R5746 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R5747 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R5748 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R5749 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R5750 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R5751 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R5752 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R5753 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R5754 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R5755 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R5756 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R5757 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R5758 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R5759 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R5760 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R5761 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R5762 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R5763 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R5764 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R5765 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R5766 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R5767 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R5768 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R5769 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R5770 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R5771 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R5772 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R5773 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R5774 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R5775 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R5776 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R5777 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R5778 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R5779 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R5780 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R5781 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R5782 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R5783 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R5784 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R5785 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R5786 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R5787 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R5788 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R5789 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R5790 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R5791 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R5792 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R5793 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R5794 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R5795 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R5796 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R5797 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R5798 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R5799 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R5800 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R5801 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R5802 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R5803 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R5804 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R5805 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R5806 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R5807 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R5808 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R5809 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R5810 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R5811 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R5812 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R5813 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R5814 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R5815 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R5816 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R5817 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R5818 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R5819 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R5820 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R5821 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R5822 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R5823 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R5824 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R5825 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R5826 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R5827 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R5828 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R5829 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R5830 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R5831 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R5832 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R5833 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R5834 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R5835 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R5836 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R5837 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R5838 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R5839 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R5840 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R5841 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R5842 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R5843 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R5844 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R5845 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R5846 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R5847 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R5848 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R5849 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R5850 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R5851 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R5852 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R5853 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R5854 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R5855 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R5856 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R5857 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R5858 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R5859 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R5860 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R5861 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R5862 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R5863 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R5864 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R5865 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R5866 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R5867 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R5868 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R5869 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R5870 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R5871 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R5872 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R5873 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R5874 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R5875 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R5876 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R5877 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R5878 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R5879 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R5880 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R5881 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R5882 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R5883 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R5884 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R5885 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R5886 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R5887 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R5888 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R5889 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R5890 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R5891 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R5892 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R5893 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R5894 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R5895 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R5896 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R5897 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R5898 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R5899 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R5900 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R5901 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R5902 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R5903 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R5904 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R5905 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R5906 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R5907 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R5908 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R5909 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R5910 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R5911 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R5912 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R5913 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R5914 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R5915 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R5916 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R5917 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R5918 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R5919 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R5920 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R5921 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R5922 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R5923 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R5924 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R5925 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R5926 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R5927 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R5928 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R5929 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R5930 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R5931 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R5932 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R5933 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R5934 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R5935 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R5936 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R5937 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R5938 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R5939 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R5940 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R5941 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R5942 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R5943 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R5944 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R5945 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R5946 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R5947 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R5948 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R5949 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R5950 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R5951 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R5952 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R5953 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R5954 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R5955 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R5956 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R5957 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R5958 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R5959 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R5960 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R5961 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R5962 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R5963 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R5964 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R5965 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R5966 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R5967 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R5968 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R5969 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R5970 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R5971 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R5972 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R5973 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R5974 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R5975 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R5976 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R5977 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R5978 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R5979 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R5980 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R5981 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R5982 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R5983 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R5984 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R5985 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R5986 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R5987 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R5988 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R5989 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R5990 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R5991 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R5992 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R5993 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R5994 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R5995 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R5996 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R5997 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R5998 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R5999 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R6000 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R6001 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R6002 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R6003 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R6004 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R6005 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R6006 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R6007 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R6008 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R6009 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R6010 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R6011 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R6012 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R6013 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R6014 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R6015 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R6016 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R6017 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R6018 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R6019 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R6020 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R6021 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R6022 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R6023 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R6024 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R6025 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R6026 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R6027 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R6028 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R6029 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R6030 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R6031 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R6032 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R6033 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R6034 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R6035 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R6036 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R6037 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R6038 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R6039 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R6040 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R6041 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R6042 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R6043 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R6044 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R6045 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R6046 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R6047 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R6048 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R6049 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R6050 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R6051 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R6052 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R6053 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R6054 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R6055 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R6056 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R6057 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R6058 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R6059 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R6060 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R6061 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R6062 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R6063 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R6064 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R6065 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R6066 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R6067 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R6068 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R6069 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R6070 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R6071 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R6072 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R6073 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R6074 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R6075 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R6076 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R6077 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R6078 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R6079 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R6080 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R6081 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R6082 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R6083 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R6084 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R6085 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R6086 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R6087 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R6088 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R6089 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R6090 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R6091 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R6092 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R6093 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R6094 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R6095 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R6096 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R6097 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R6098 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R6099 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R6100 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R6101 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R6102 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R6103 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R6104 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R6105 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R6106 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R6107 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R6108 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R6109 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R6110 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R6111 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R6112 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R6113 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R6114 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R6115 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R6116 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R6117 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R6118 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R6119 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R6120 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R6121 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R6122 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R6123 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R6124 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R6125 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R6126 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R6127 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R6128 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R6129 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R6130 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R6131 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R6132 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R6133 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R6134 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R6135 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R6136 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R6137 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R6138 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R6139 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R6140 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R6141 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R6142 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R6143 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R6144 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R6145 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R6146 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R6147 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R6148 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R6149 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R6150 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R6151 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R6152 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R6153 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R6154 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R6155 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R6156 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R6157 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R6158 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R6159 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R6160 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R6161 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R6162 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R6163 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R6164 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R6165 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R6166 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R6167 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R6168 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R6169 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R6170 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R6171 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R6172 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R6173 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R6174 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R6175 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R6176 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R6177 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R6178 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R6179 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R6180 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R6181 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R6182 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R6183 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R6184 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R6185 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R6186 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R6187 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R6188 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R6189 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R6190 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R6191 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R6192 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R6193 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R6194 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R6195 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R6196 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R6197 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R6198 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R6199 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R6200 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R6201 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R6202 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R6203 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R6204 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R6205 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R6206 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R6207 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R6208 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R6209 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R6210 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R6211 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R6212 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R6213 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R6214 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R6215 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R6216 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R6217 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R6218 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R6219 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R6220 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R6221 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R6222 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R6223 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R6224 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R6225 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R6226 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R6227 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R6228 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R6229 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R6230 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R6231 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R6232 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R6233 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R6234 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R6235 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R6236 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R6237 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R6238 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R6239 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R6240 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R6241 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R6242 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R6243 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R6244 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R6245 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R6246 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R6247 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R6248 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R6249 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R6250 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R6251 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R6252 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R6253 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R6254 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R6255 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R6256 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R6257 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R6258 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R6259 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R6260 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R6261 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R6262 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R6263 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R6264 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R6265 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R6266 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R6267 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R6268 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R6269 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R6270 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R6271 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R6272 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R6273 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R6274 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R6275 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R6276 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R6277 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R6278 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R6279 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R6280 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R6281 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R6282 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R6283 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R6284 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R6285 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R6286 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R6287 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R6288 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R6289 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R6290 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R6291 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R6292 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R6293 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R6294 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R6295 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R6296 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R6297 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R6298 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R6299 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R6300 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R6301 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R6302 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R6303 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R6304 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R6305 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R6306 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R6307 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R6308 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R6309 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R6310 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R6311 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R6312 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R6313 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R6314 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R6315 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R6316 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R6317 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R6318 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R6319 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R6320 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R6321 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R6322 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R6323 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R6324 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R6325 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R6326 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R6327 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R6328 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R6329 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R6330 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R6331 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R6332 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R6333 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R6334 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R6335 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R6336 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R6337 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R6338 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R6339 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R6340 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R6341 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R6342 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R6343 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R6344 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R6345 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R6346 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R6347 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R6348 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R6349 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R6350 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R6351 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R6352 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R6353 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R6354 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R6355 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R6356 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R6357 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R6358 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R6359 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R6360 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R6361 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R6362 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R6363 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R6364 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R6365 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R6366 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R6367 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R6368 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R6369 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R6370 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R6371 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R6372 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R6373 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R6374 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R6375 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R6376 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R6377 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R6378 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R6379 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R6380 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R6381 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R6382 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R6383 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R6384 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R6385 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R6386 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R6387 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R6388 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R6389 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R6390 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R6391 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R6392 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R6393 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R6394 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R6395 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R6396 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R6397 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R6398 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R6399 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R6400 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R6401 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R6402 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R6403 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R6404 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R6405 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R6406 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R6407 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R6408 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R6409 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R6410 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R6411 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R6412 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R6413 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R6414 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R6415 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R6416 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R6417 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R6418 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R6419 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R6420 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R6421 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R6422 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R6423 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R6424 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R6425 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R6426 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R6427 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R6428 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R6429 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R6430 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R6431 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R6432 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R6433 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R6434 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R6435 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R6436 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R6437 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R6438 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R6439 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R6440 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R6441 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R6442 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R6443 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R6444 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R6445 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R6446 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R6447 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R6448 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R6449 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R6450 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R6451 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R6452 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R6453 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R6454 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R6455 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R6456 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R6457 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R6458 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R6459 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R6460 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R6461 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R6462 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R6463 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R6464 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R6465 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R6466 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R6467 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R6468 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R6469 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R6470 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R6471 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R6472 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R6473 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R6474 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R6475 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R6476 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R6477 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R6478 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R6479 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R6480 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R6481 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R6482 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R6483 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R6484 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R6485 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R6486 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R6487 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R6488 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R6489 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R6490 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R6491 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R6492 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R6493 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R6494 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R6495 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R6496 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R6497 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R6498 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R6499 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R6500 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R6501 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R6502 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R6503 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R6504 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R6505 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R6506 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R6507 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R6508 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R6509 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R6510 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R6511 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R6512 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R6513 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R6514 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R6515 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R6516 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R6517 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R6518 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R6519 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R6520 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R6521 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R6522 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R6523 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R6524 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R6525 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R6526 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R6527 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R6528 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R6529 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R6530 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R6531 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R6532 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R6533 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R6534 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R6535 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R6536 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R6537 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R6538 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R6539 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R6540 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R6541 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R6542 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R6543 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R6544 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R6545 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R6546 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R6547 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R6548 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R6549 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R6550 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R6551 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R6552 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R6553 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R6554 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R6555 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R6556 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R6557 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R6558 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R6559 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R6560 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R6561 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R6562 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R6563 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R6564 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R6565 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R6566 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R6567 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R6568 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R6569 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R6570 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R6571 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R6572 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R6573 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R6574 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R6575 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R6576 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R6577 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R6578 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R6579 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R6580 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R6581 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R6582 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R6583 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R6584 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R6585 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R6586 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R6587 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R6588 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R6589 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R6590 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R6591 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R6592 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R6593 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R6594 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R6595 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R6596 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R6597 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R6598 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R6599 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R6600 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R6601 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R6602 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R6603 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R6604 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R6605 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R6606 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R6607 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R6608 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R6609 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R6610 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R6611 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R6612 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R6613 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R6614 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R6615 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R6616 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R6617 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R6618 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R6619 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R6620 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R6621 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R6622 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R6623 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R6624 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R6625 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R6626 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R6627 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R6628 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R6629 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R6630 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R6631 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R6632 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R6633 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R6634 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R6635 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R6636 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R6637 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R6638 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R6639 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R6640 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R6641 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R6642 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R6643 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R6644 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R6645 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R6646 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R6647 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R6648 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R6649 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R6650 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R6651 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R6652 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R6653 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R6654 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R6655 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R6656 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R6657 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R6658 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R6659 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R6660 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R6661 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R6662 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R6663 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R6664 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R6665 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R6666 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R6667 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R6668 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R6669 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R6670 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R6671 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R6672 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R6673 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R6674 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R6675 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R6676 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R6677 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R6678 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R6679 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R6680 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R6681 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R6682 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R6683 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R6684 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R6685 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R6686 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R6687 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R6688 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R6689 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R6690 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R6691 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R6692 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R6693 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R6694 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R6695 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R6696 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R6697 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R6698 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R6699 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R6700 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R6701 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R6702 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R6703 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R6704 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R6705 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R6706 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R6707 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R6708 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R6709 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R6710 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R6711 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R6712 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R6713 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R6714 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R6715 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R6716 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R6717 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R6718 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R6719 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R6720 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R6721 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R6722 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R6723 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R6724 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R6725 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R6726 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R6727 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R6728 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R6729 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R6730 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R6731 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R6732 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R6733 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R6734 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R6735 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R6736 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R6737 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R6738 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R6739 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R6740 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R6741 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R6742 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R6743 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R6744 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R6745 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R6746 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R6747 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R6748 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R6749 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R6750 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R6751 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R6752 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R6753 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R6754 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R6755 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R6756 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R6757 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R6758 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R6759 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R6760 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R6761 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R6762 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R6763 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R6764 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R6765 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R6766 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R6767 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R6768 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R6769 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R6770 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R6771 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R6772 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R6773 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R6774 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R6775 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R6776 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R6777 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R6778 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R6779 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R6780 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R6781 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R6782 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R6783 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R6784 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R6785 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R6786 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R6787 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R6788 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R6789 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R6790 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R6791 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R6792 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R6793 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R6794 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R6795 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R6796 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R6797 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R6798 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R6799 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R6800 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R6801 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R6802 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R6803 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R6804 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R6805 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R6806 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R6807 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R6808 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R6809 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R6810 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R6811 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R6812 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R6813 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R6814 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R6815 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R6816 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R6817 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R6818 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R6819 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R6820 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R6821 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R6822 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R6823 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R6824 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R6825 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R6826 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R6827 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R6828 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R6829 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R6830 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R6831 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R6832 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R6833 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R6834 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R6835 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R6836 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R6837 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R6838 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R6839 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R6840 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R6841 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R6842 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R6843 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R6844 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R6845 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R6846 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R6847 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R6848 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R6849 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R6850 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R6851 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R6852 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R6853 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R6854 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R6855 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R6856 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R6857 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R6858 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R6859 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R6860 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R6861 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R6862 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R6863 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R6864 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R6865 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R6866 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R6867 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R6868 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R6869 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R6870 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R6871 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R6872 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R6873 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R6874 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R6875 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R6876 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R6877 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R6878 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R6879 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R6880 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R6881 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R6882 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R6883 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R6884 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R6885 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R6886 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R6887 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R6888 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R6889 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R6890 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R6891 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R6892 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R6893 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R6894 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R6895 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R6896 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R6897 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R6898 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R6899 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R6900 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R6901 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R6902 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R6903 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R6904 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R6905 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R6906 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R6907 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R6908 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R6909 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R6910 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R6911 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R6912 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R6913 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R6914 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R6915 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R6916 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R6917 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R6918 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R6919 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R6920 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R6921 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R6922 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R6923 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R6924 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R6925 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R6926 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R6927 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R6928 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R6929 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R6930 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R6931 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R6932 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R6933 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R6934 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R6935 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R6936 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R6937 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R6938 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R6939 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R6940 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R6941 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R6942 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R6943 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R6944 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R6945 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R6946 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R6947 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R6948 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R6949 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R6950 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R6951 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R6952 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R6953 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R6954 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R6955 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R6956 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R6957 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R6958 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R6959 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R6960 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R6961 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R6962 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R6963 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R6964 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R6965 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R6966 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R6967 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R6968 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R6969 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R6970 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R6971 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R6972 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R6973 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R6974 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R6975 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R6976 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R6977 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R6978 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R6979 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R6980 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R6981 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R6982 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R6983 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R6984 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R6985 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R6986 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R6987 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R6988 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R6989 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R6990 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R6991 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R6992 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R6993 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R6994 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R6995 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R6996 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R6997 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R6998 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R6999 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R7000 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R7001 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R7002 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R7003 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R7004 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R7005 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R7006 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R7007 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R7008 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R7009 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R7010 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R7011 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R7012 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R7013 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R7014 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R7015 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R7016 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R7017 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R7018 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R7019 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R7020 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R7021 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R7022 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R7023 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R7024 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R7025 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R7026 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R7027 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R7028 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R7029 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R7030 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R7031 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R7032 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R7033 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R7034 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R7035 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R7036 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R7037 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R7038 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R7039 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R7040 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R7041 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R7042 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R7043 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R7044 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R7045 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R7046 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R7047 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R7048 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R7049 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R7050 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R7051 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R7052 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R7053 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R7054 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R7055 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R7056 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R7057 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R7058 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R7059 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R7060 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R7061 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R7062 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R7063 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R7064 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R7065 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R7066 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R7067 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R7068 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R7069 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R7070 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R7071 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R7072 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R7073 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R7074 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R7075 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R7076 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R7077 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R7078 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R7079 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R7080 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R7081 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R7082 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R7083 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R7084 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R7085 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R7086 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R7087 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R7088 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R7089 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R7090 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R7091 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R7092 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R7093 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R7094 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R7095 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R7096 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R7097 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R7098 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R7099 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R7100 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R7101 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R7102 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R7103 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R7104 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R7105 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R7106 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R7107 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R7108 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R7109 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R7110 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R7111 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R7112 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R7113 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R7114 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R7115 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R7116 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R7117 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R7118 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R7119 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R7120 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R7121 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R7122 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R7123 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R7124 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R7125 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R7126 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R7127 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R7128 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R7129 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R7130 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R7131 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R7132 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R7133 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R7134 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R7135 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R7136 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R7137 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R7138 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R7139 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R7140 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R7141 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R7142 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R7143 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R7144 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R7145 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R7146 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R7147 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R7148 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R7149 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R7150 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R7151 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R7152 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R7153 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R7154 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R7155 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R7156 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R7157 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R7158 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R7159 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R7160 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R7161 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R7162 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R7163 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R7164 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R7165 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R7166 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R7167 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R7168 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R7169 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R7170 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R7171 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R7172 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R7173 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R7174 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R7175 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R7176 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R7177 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R7178 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R7179 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R7180 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R7181 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R7182 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R7183 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R7184 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R7185 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R7186 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R7187 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R7188 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R7189 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R7190 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R7191 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R7192 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R7193 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R7194 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R7195 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R7196 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R7197 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R7198 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R7199 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R7200 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R7201 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R7202 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R7203 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R7204 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R7205 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R7206 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R7207 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R7208 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R7209 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R7210 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R7211 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R7212 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R7213 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R7214 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R7215 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R7216 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R7217 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R7218 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R7219 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R7220 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R7221 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R7222 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R7223 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R7224 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R7225 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R7226 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R7227 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R7228 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R7229 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R7230 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R7231 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R7232 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R7233 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R7234 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R7235 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R7236 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R7237 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R7238 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R7239 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R7240 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R7241 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R7242 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R7243 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R7244 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R7245 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R7246 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R7247 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R7248 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R7249 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R7250 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R7251 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R7252 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R7253 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R7254 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R7255 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R7256 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R7257 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R7258 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R7259 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R7260 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R7261 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R7262 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R7263 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R7264 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R7265 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R7266 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R7267 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R7268 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R7269 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R7270 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R7271 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R7272 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R7273 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R7274 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R7275 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R7276 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R7277 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R7278 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R7279 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R7280 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R7281 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R7282 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R7283 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R7284 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R7285 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R7286 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R7287 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R7288 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R7289 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R7290 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R7291 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R7292 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R7293 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R7294 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R7295 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R7296 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R7297 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R7298 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R7299 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R7300 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R7301 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R7302 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R7303 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R7304 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R7305 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R7306 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R7307 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R7308 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R7309 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R7310 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R7311 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R7312 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R7313 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R7314 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R7315 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R7316 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R7317 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R7318 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R7319 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R7320 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R7321 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R7322 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R7323 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R7324 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R7325 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R7326 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R7327 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R7328 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R7329 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R7330 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R7331 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R7332 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R7333 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R7334 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R7335 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R7336 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R7337 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R7338 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R7339 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R7340 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R7341 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R7342 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R7343 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R7344 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R7345 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R7346 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R7347 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R7348 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R7349 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R7350 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R7351 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R7352 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R7353 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R7354 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R7355 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R7356 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R7357 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R7358 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R7359 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R7360 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R7361 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R7362 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R7363 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R7364 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R7365 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R7366 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R7367 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R7368 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R7369 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R7370 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R7371 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R7372 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R7373 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R7374 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R7375 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R7376 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R7377 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R7378 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R7379 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R7380 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R7381 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R7382 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R7383 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R7384 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R7385 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R7386 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R7387 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R7388 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R7389 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R7390 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R7391 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R7392 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R7393 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R7394 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R7395 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R7396 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R7397 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R7398 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R7399 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R7400 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R7401 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R7402 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R7403 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R7404 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R7405 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R7406 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R7407 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R7408 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R7409 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R7410 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R7411 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R7412 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R7413 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R7414 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R7415 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R7416 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R7417 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R7418 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R7419 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R7420 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R7421 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R7422 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R7423 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R7424 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R7425 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R7426 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R7427 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R7428 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R7429 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R7430 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R7431 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R7432 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R7433 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R7434 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R7435 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R7436 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R7437 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R7438 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R7439 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R7440 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R7441 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R7442 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R7443 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R7444 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R7445 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R7446 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R7447 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R7448 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R7449 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R7450 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R7451 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R7452 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R7453 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R7454 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R7455 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R7456 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R7457 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R7458 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R7459 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R7460 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R7461 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R7462 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R7463 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R7464 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R7465 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R7466 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R7467 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R7468 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R7469 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R7470 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R7471 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R7472 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R7473 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R7474 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R7475 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R7476 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R7477 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R7478 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R7479 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R7480 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R7481 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R7482 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R7483 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R7484 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R7485 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R7486 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R7487 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R7488 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R7489 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R7490 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R7491 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R7492 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R7493 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R7494 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R7495 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R7496 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R7497 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R7498 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R7499 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R7500 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R7501 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R7502 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R7503 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R7504 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R7505 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R7506 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R7507 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R7508 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R7509 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R7510 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R7511 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R7512 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R7513 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R7514 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R7515 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R7516 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R7517 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R7518 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R7519 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R7520 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R7521 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R7522 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R7523 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R7524 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R7525 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R7526 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R7527 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R7528 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R7529 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R7530 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R7531 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R7532 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R7533 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R7534 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R7535 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R7536 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R7537 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R7538 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R7539 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R7540 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R7541 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R7542 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R7543 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R7544 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R7545 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R7546 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R7547 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R7548 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R7549 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R7550 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R7551 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R7552 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R7553 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R7554 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R7555 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R7556 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R7557 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R7558 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R7559 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R7560 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R7561 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R7562 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R7563 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R7564 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R7565 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R7566 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R7567 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R7568 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R7569 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R7570 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R7571 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R7572 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R7573 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R7574 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R7575 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R7576 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R7577 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R7578 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R7579 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R7580 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R7581 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R7582 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R7583 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R7584 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R7585 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R7586 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R7587 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R7588 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R7589 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R7590 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R7591 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R7592 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R7593 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R7594 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R7595 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R7596 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R7597 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R7598 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R7599 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R7600 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R7601 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R7602 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R7603 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R7604 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R7605 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R7606 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R7607 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R7608 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R7609 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R7610 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R7611 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R7612 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R7613 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R7614 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R7615 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R7616 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R7617 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R7618 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R7619 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R7620 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R7621 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R7622 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R7623 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R7624 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R7625 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R7626 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R7627 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R7628 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R7629 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R7630 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R7631 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R7632 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R7633 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R7634 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R7635 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R7636 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R7637 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R7638 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R7639 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R7640 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R7641 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R7642 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R7643 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R7644 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R7645 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R7646 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R7647 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R7648 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R7649 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R7650 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R7651 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R7652 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R7653 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R7654 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R7655 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R7656 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R7657 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R7658 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R7659 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R7660 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R7661 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R7662 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R7663 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R7664 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R7665 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R7666 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R7667 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R7668 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R7669 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R7670 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R7671 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R7672 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R7673 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R7674 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R7675 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R7676 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R7677 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R7678 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R7679 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R7680 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R7681 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R7682 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R7683 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R7684 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R7685 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R7686 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R7687 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R7688 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R7689 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R7690 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R7691 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R7692 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R7693 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R7694 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R7695 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R7696 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R7697 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R7698 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R7699 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R7700 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R7701 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R7702 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R7703 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R7704 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R7705 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R7706 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R7707 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R7708 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R7709 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R7710 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R7711 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R7712 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R7713 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R7714 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R7715 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R7716 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R7717 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R7718 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R7719 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R7720 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R7721 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R7722 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R7723 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R7724 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R7725 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R7726 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R7727 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R7728 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R7729 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R7730 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R7731 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R7732 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R7733 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R7734 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R7735 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R7736 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R7737 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R7738 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R7739 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R7740 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R7741 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R7742 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R7743 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R7744 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R7745 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R7746 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R7747 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R7748 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R7749 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R7750 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R7751 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R7752 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R7753 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R7754 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R7755 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R7756 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R7757 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R7758 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R7759 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R7760 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R7761 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R7762 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R7763 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R7764 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R7765 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R7766 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R7767 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R7768 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R7769 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R7770 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R7771 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R7772 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R7773 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R7774 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R7775 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R7776 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R7777 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R7778 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R7779 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R7780 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R7781 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R7782 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R7783 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R7784 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R7785 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R7786 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R7787 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R7788 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R7789 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R7790 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R7791 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R7792 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R7793 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R7794 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R7795 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R7796 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R7797 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R7798 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R7799 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R7800 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R7801 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R7802 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R7803 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R7804 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R7805 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R7806 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R7807 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R7808 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R7809 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R7810 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R7811 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R7812 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R7813 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R7814 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R7815 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R7816 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R7817 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R7818 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R7819 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R7820 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R7821 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R7822 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R7823 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R7824 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R7825 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R7826 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R7827 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R7828 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R7829 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R7830 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R7831 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R7832 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R7833 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R7834 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R7835 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R7836 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R7837 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R7838 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R7839 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R7840 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R7841 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R7842 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R7843 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R7844 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R7845 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R7846 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R7847 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R7848 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R7849 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R7850 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R7851 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R7852 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R7853 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R7854 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R7855 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R7856 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R7857 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R7858 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R7859 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R7860 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R7861 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R7862 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R7863 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R7864 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R7865 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R7866 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R7867 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R7868 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R7869 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R7870 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R7871 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R7872 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R7873 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R7874 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R7875 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R7876 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R7877 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R7878 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R7879 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R7880 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R7881 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R7882 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R7883 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R7884 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R7885 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R7886 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R7887 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R7888 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R7889 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R7890 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R7891 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R7892 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R7893 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R7894 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R7895 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R7896 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R7897 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R7898 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R7899 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R7900 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R7901 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R7902 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R7903 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R7904 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R7905 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R7906 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R7907 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R7908 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R7909 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R7910 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R7911 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R7912 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R7913 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R7914 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R7915 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R7916 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R7917 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R7918 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R7919 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R7920 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R7921 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R7922 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R7923 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R7924 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R7925 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R7926 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R7927 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R7928 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R7929 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R7930 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R7931 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R7932 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R7933 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R7934 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R7935 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R7936 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R7937 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R7938 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R7939 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R7940 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R7941 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R7942 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R7943 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R7944 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R7945 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R7946 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R7947 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R7948 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R7949 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R7950 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R7951 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R7952 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R7953 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R7954 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R7955 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R7956 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R7957 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R7958 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R7959 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R7960 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R7961 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R7962 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R7963 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R7964 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R7965 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R7966 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R7967 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R7968 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R7969 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R7970 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R7971 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R7972 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R7973 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R7974 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R7975 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R7976 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R7977 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R7978 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R7979 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R7980 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R7981 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R7982 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R7983 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R7984 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R7985 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R7986 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R7987 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R7988 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R7989 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R7990 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R7991 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R7992 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R7993 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R7994 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R7995 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R7996 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R7997 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R7998 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R7999 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R8000 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R8001 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R8002 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R8003 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R8004 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R8005 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R8006 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R8007 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R8008 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R8009 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R8010 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R8011 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R8012 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R8013 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R8014 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R8015 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R8016 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R8017 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R8018 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R8019 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R8020 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R8021 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R8022 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R8023 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R8024 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R8025 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R8026 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R8027 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R8028 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R8029 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R8030 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R8031 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R8032 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R8033 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R8034 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R8035 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R8036 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R8037 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R8038 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R8039 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R8040 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R8041 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R8042 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R8043 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R8044 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R8045 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R8046 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R8047 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R8048 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R8049 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R8050 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R8051 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R8052 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R8053 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R8054 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R8055 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R8056 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R8057 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R8058 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R8059 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R8060 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R8061 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R8062 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R8063 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R8064 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R8065 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R8066 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R8067 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R8068 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R8069 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R8070 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R8071 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R8072 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R8073 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R8074 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R8075 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R8076 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R8077 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R8078 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R8079 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R8080 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R8081 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R8082 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R8083 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R8084 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R8085 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R8086 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R8087 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R8088 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R8089 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R8090 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R8091 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R8092 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R8093 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R8094 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R8095 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R8096 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R8097 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R8098 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R8099 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R8100 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R8101 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R8102 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R8103 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R8104 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R8105 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R8106 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R8107 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R8108 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R8109 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R8110 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R8111 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R8112 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R8113 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R8114 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R8115 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R8116 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R8117 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R8118 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R8119 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R8120 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R8121 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R8122 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R8123 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R8124 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R8125 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R8126 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R8127 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R8128 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R8129 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R8130 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R8131 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R8132 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R8133 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R8134 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R8135 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R8136 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R8137 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R8138 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R8139 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R8140 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R8141 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R8142 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R8143 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R8144 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R8145 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R8146 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R8147 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R8148 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R8149 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R8150 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R8151 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R8152 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R8153 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R8154 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R8155 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R8156 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R8157 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R8158 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R8159 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R8160 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R8161 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R8162 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R8163 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R8164 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R8165 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R8166 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R8167 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R8168 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R8169 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R8170 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R8171 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R8172 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R8173 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R8174 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R8175 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R8176 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R8177 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R8178 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R8179 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R8180 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R8181 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R8182 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R8183 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R8184 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R8185 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R8186 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R8187 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R8188 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R8189 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R8190 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R8191 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R8192 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R8193 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R8194 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R8195 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R8196 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R8197 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R8198 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R8199 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R8200 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R8201 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R8202 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R8203 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R8204 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R8205 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R8206 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R8207 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R8208 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R8209 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R8210 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R8211 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R8212 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R8213 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R8214 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R8215 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R8216 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R8217 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R8218 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R8219 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R8220 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R8221 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R8222 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R8223 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R8224 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R8225 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R8226 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R8227 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R8228 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R8229 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R8230 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R8231 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R8232 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R8233 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R8234 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R8235 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R8236 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R8237 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R8238 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R8239 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R8240 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R8241 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R8242 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R8243 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R8244 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R8245 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R8246 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R8247 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R8248 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R8249 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R8250 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R8251 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R8252 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R8253 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R8254 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R8255 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R8256 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R8257 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R8258 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R8259 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R8260 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R8261 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R8262 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R8263 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R8264 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R8265 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R8266 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R8267 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R8268 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R8269 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R8270 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R8271 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R8272 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R8273 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R8274 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R8275 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R8276 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R8277 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R8278 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R8279 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R8280 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R8281 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R8282 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R8283 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R8284 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R8285 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R8286 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R8287 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R8288 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R8289 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R8290 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R8291 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R8292 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R8293 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R8294 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R8295 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R8296 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R8297 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R8298 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R8299 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R8300 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R8301 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R8302 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R8303 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R8304 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R8305 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R8306 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R8307 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R8308 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R8309 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R8310 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R8311 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R8312 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R8313 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R8314 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R8315 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R8316 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R8317 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R8318 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R8319 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R8320 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R8321 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R8322 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R8323 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R8324 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R8325 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R8326 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R8327 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R8328 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R8329 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R8330 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R8331 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R8332 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R8333 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R8334 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R8335 n1_m4_60000_0 n1_m4_60000_4000 1.166667
R8336 n1_m4_60000_4800 n1_m4_60000_4000 0.233333
R8337 n1_m4_60000_4800 n1_m4_60000_9600 1.400000
R8338 n1_m4_60000_9600 n1_m4_60000_14400 1.400000
R8339 n1_m4_60000_14400 n1_m4_60000_19200 1.400000
R8340 n1_m4_60000_19200 n1_m4_60000_24000 1.400000
R8341 n1_m4_60000_24000 n1_m4_60000_28800 1.400000
R8342 n1_m4_60000_28800 n1_m4_60000_33600 1.400000
R8343 n1_m4_60000_33600 n1_m4_60000_38400 1.400000
R8344 n1_m4_60000_38400 n1_m4_60000_43200 1.400000
R8345 n1_m4_60000_43200 n1_m4_60000_48000 1.400000
R8346 n1_m4_60000_48000 n1_m4_60000_52800 1.400000
R8347 n1_m4_60000_52800 n1_m4_60000_57600 1.400000
R8348 n1_m4_60000_57600 n1_m4_60000_62400 1.400000
R8349 n1_m4_60000_62400 n1_m4_60000_67200 1.400000
R8350 n1_m4_60000_67200 n1_m4_60000_72000 1.400000
R8351 n1_m4_60000_72000 n1_m4_60000_76800 1.400000
R8352 n1_m4_60000_76800 n1_m4_60000_81600 1.400000
R8353 n1_m4_60000_81600 n1_m4_60000_84000 0.700000
R8354 n1_m4_60000_86400 n1_m4_60000_84000 0.700000
R8355 n1_m4_60000_86400 n1_m4_60000_91200 1.400000
R8356 n1_m4_60000_91200 n1_m4_60000_96000 1.400000
R8357 n1_m4_60000_96000 n1_m4_60000_100800 1.400000
R8358 n1_m4_60000_100800 n1_m4_60000_105600 1.400000
R8359 n1_m4_60000_105600 n1_m4_60000_110400 1.400000
R8360 n1_m4_60000_110400 n1_m4_60000_115200 1.400000
R8361 n1_m4_60000_115200 n1_m4_60000_120000 1.400000
R8362 n1_m4_60000_120000 n1_m4_60000_124800 1.400000
R8363 n1_m4_60000_124800 n1_m4_60000_129600 1.400000
R8364 n1_m4_60000_129600 n1_m4_60000_134400 1.400000
R8365 n1_m4_60000_134400 n1_m4_60000_139200 1.400000
R8366 n1_m4_60000_139200 n1_m4_60000_144000 1.400000
R8367 n1_m4_60000_144000 n1_m4_60000_148800 1.400000
R8368 n1_m4_60000_148800 n1_m4_60000_153600 1.400000
R8369 n1_m4_60000_153600 n1_m4_60000_158400 1.400000
R8370 n1_m4_60000_158400 n1_m4_60000_163200 1.400000
R8371 n1_m4_60000_163200 n1_m4_60000_164000 0.233333
R8372 n1_m4_60000_168000 n1_m4_60000_164000 1.166667
R8373 n1_m4_60000_168000 n1_m4_60000_172800 1.400000
R8374 n1_m4_60000_172800 n1_m4_60000_177600 1.400000
R8375 n1_m4_60000_177600 n1_m4_60000_182400 1.400000
R8376 n1_m4_60000_182400 n1_m4_60000_187200 1.400000
R8377 n1_m4_60000_187200 n1_m4_60000_192000 1.400000
R8378 n1_m4_60000_192000 n1_m4_60000_196800 1.400000
R8379 n1_m4_88000_196800 n1_m4_88000_201600 1.400000
R8380 n1_m4_88000_201600 n1_m4_88000_206400 1.400000
R8381 n1_m4_88000_206400 n1_m4_88000_211200 1.400000
R8382 n1_m4_88000_211200 n1_m4_88000_216000 1.400000
R8383 n1_m4_88000_216000 n1_m4_88000_220800 1.400000
R8384 n1_m4_88000_220800 n1_m4_88000_225600 1.400000
R8385 n1_m4_88000_225600 n1_m4_88000_230400 1.400000
R8386 n1_m4_88000_230400 n1_m4_88000_235200 1.400000
R8387 n1_m4_88000_235200 n1_m4_88000_240000 1.400000
R8388 n1_m4_88000_240000 n1_m4_88000_244000 1.166667
R8389 n1_m4_88000_244800 n1_m4_88000_244000 0.233333
R8390 n1_m4_88000_244800 n1_m4_88000_249600 1.400000
R8391 n1_m4_88000_249600 n1_m4_88000_254400 1.400000
R8392 n1_m4_88000_254400 n1_m4_88000_259200 1.400000
R8393 n1_m4_88000_259200 n1_m4_88000_264000 1.400000
R8394 n1_m4_88000_264000 n1_m4_88000_268800 1.400000
R8395 n1_m4_88000_268800 n1_m4_88000_273600 1.400000
R8396 n1_m4_88000_273600 n1_m4_88000_278400 1.400000
R8397 n1_m4_88000_278400 n1_m4_88000_283200 1.400000
R8398 n1_m4_88000_283200 n1_m4_88000_288000 1.400000
R8399 n1_m4_88000_288000 n1_m4_88000_292800 1.400000
R8400 n1_m4_88000_292800 n1_m4_88000_297600 1.400000
R8401 n1_m4_88000_297600 n1_m4_88000_302400 1.400000
R8402 n1_m4_88000_302400 n1_m4_88000_307200 1.400000
R8403 n1_m4_88000_307200 n1_m4_88000_312000 1.400000
R8404 n1_m4_88000_312000 n1_m4_88000_316800 1.400000
R8405 n1_m4_88000_316800 n1_m4_88000_321600 1.400000
R8406 n1_m4_88000_321600 n1_m4_88000_324000 0.700000
R8407 n1_m4_88000_326400 n1_m4_88000_324000 0.700000
R8408 n1_m4_88000_326400 n1_m4_88000_331200 1.400000
R8409 n1_m4_88000_331200 n1_m4_88000_336000 1.400000
R8410 n1_m4_88000_336000 n1_m4_88000_340800 1.400000
R8411 n1_m4_88000_340800 n1_m4_88000_345600 1.400000
R8412 n1_m4_88000_345600 n1_m4_88000_350400 1.400000
R8413 n1_m4_88000_350400 n1_m4_88000_355200 1.400000
R8414 n1_m4_88000_355200 n1_m4_88000_360000 1.400000
R8415 n1_m4_88000_360000 n1_m4_88000_364800 1.400000
R8416 n1_m4_88000_364800 n1_m4_88000_369600 1.400000
R8417 n1_m4_88000_369600 n1_m4_88000_374400 1.400000
R8418 n1_m4_88000_374400 n1_m4_88000_379200 1.400000
R8419 n1_m4_88000_379200 n1_m4_88000_384000 1.400000
R8420 n1_m4_88000_384000 n1_m4_88000_388800 1.400000
R8421 n1_m4_88000_388800 n1_m4_88000_393600 1.400000
R8422 n1_m4_88000_393600 n1_m4_88000_398400 1.400000
R8423 n1_m4_88000_398400 n1_m4_88000_403200 1.400000
R8424 n1_m4_88000_403200 n1_m4_88000_404000 0.233333
R8425 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R8426 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R8427 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R8428 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R8429 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R8430 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R8431 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R8432 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R8433 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R8434 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R8435 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R8436 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R8437 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R8438 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R8439 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R8440 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R8441 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R8442 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R8443 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R8444 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R8445 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R8446 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R8447 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R8448 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R8449 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R8450 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R8451 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R8452 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R8453 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R8454 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R8455 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R8456 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R8457 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R8458 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R8459 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R8460 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R8461 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R8462 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R8463 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R8464 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R8465 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R8466 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R8467 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R8468 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R8469 n1_m4_172000_0 n1_m4_172000_4000 1.166667
R8470 n1_m4_172000_4800 n1_m4_172000_4000 0.233333
R8471 n1_m4_172000_4800 n1_m4_172000_9600 1.400000
R8472 n1_m4_172000_9600 n1_m4_172000_14400 1.400000
R8473 n1_m4_172000_14400 n1_m4_172000_19200 1.400000
R8474 n1_m4_172000_19200 n1_m4_172000_24000 1.400000
R8475 n1_m4_172000_24000 n1_m4_172000_28800 1.400000
R8476 n1_m4_172000_28800 n1_m4_172000_33600 1.400000
R8477 n1_m4_172000_33600 n1_m4_172000_38400 1.400000
R8478 n1_m4_172000_38400 n1_m4_172000_43200 1.400000
R8479 n1_m4_172000_43200 n1_m4_172000_48000 1.400000
R8480 n1_m4_172000_48000 n1_m4_172000_52800 1.400000
R8481 n1_m4_172000_52800 n1_m4_172000_57600 1.400000
R8482 n1_m4_172000_57600 n1_m4_172000_62400 1.400000
R8483 n1_m4_172000_62400 n1_m4_172000_67200 1.400000
R8484 n1_m4_172000_67200 n1_m4_172000_72000 1.400000
R8485 n1_m4_172000_72000 n1_m4_172000_76800 1.400000
R8486 n1_m4_172000_76800 n1_m4_172000_81600 1.400000
R8487 n1_m4_172000_81600 n1_m4_172000_84000 0.700000
R8488 n1_m4_172000_86400 n1_m4_172000_84000 0.700000
R8489 n1_m4_172000_86400 n1_m4_172000_91200 1.400000
R8490 n1_m4_172000_91200 n1_m4_172000_96000 1.400000
R8491 n1_m4_172000_96000 n1_m4_172000_100800 1.400000
R8492 n1_m4_172000_100800 n1_m4_172000_105600 1.400000
R8493 n1_m4_172000_105600 n1_m4_172000_110400 1.400000
R8494 n1_m4_172000_110400 n1_m4_172000_115200 1.400000
R8495 n1_m4_172000_115200 n1_m4_172000_120000 1.400000
R8496 n1_m4_172000_120000 n1_m4_172000_124800 1.400000
R8497 n1_m4_172000_124800 n1_m4_172000_129600 1.400000
R8498 n1_m4_172000_129600 n1_m4_172000_134400 1.400000
R8499 n1_m4_172000_134400 n1_m4_172000_139200 1.400000
R8500 n1_m4_172000_139200 n1_m4_172000_144000 1.400000
R8501 n1_m4_172000_144000 n1_m4_172000_148800 1.400000
R8502 n1_m4_172000_148800 n1_m4_172000_153600 1.400000
R8503 n1_m4_172000_153600 n1_m4_172000_158400 1.400000
R8504 n1_m4_172000_158400 n1_m4_172000_163200 1.400000
R8505 n1_m4_172000_163200 n1_m4_172000_164000 0.233333
R8506 n1_m4_172000_168000 n1_m4_172000_164000 1.166667
R8507 n1_m4_172000_168000 n1_m4_172000_172800 1.400000
R8508 n1_m4_172000_172800 n1_m4_172000_177600 1.400000
R8509 n1_m4_172000_177600 n1_m4_172000_182400 1.400000
R8510 n1_m4_172000_182400 n1_m4_172000_187200 1.400000
R8511 n1_m4_172000_187200 n1_m4_172000_192000 1.400000
R8512 n1_m4_172000_192000 n1_m4_172000_196800 1.400000
R8513 n1_m4_172000_196800 n1_m4_172000_201600 1.400000
R8514 n1_m4_172000_201600 n1_m4_172000_206400 1.400000
R8515 n1_m4_172000_206400 n1_m4_172000_211200 1.400000
R8516 n1_m4_172000_211200 n1_m4_172000_216000 1.400000
R8517 n1_m4_172000_216000 n1_m4_172000_220800 1.400000
R8518 n1_m4_172000_220800 n1_m4_172000_225600 1.400000
R8519 n1_m4_172000_225600 n1_m4_172000_230400 1.400000
R8520 n1_m4_172000_230400 n1_m4_172000_235200 1.400000
R8521 n1_m4_172000_235200 n1_m4_172000_240000 1.400000
R8522 n1_m4_172000_240000 n1_m4_172000_244000 1.166667
R8523 n1_m4_172000_244800 n1_m4_172000_244000 0.233333
R8524 n1_m4_172000_244800 n1_m4_172000_249600 1.400000
R8525 n1_m4_172000_249600 n1_m4_172000_254400 1.400000
R8526 n1_m4_172000_254400 n1_m4_172000_259200 1.400000
R8527 n1_m4_172000_259200 n1_m4_172000_264000 1.400000
R8528 n1_m4_172000_264000 n1_m4_172000_268800 1.400000
R8529 n1_m4_172000_268800 n1_m4_172000_273600 1.400000
R8530 n1_m4_172000_273600 n1_m4_172000_278400 1.400000
R8531 n1_m4_172000_278400 n1_m4_172000_283200 1.400000
R8532 n1_m4_172000_283200 n1_m4_172000_288000 1.400000
R8533 n1_m4_172000_288000 n1_m4_172000_292800 1.400000
R8534 n1_m4_172000_292800 n1_m4_172000_297600 1.400000
R8535 n1_m4_172000_297600 n1_m4_172000_302400 1.400000
R8536 n1_m4_172000_302400 n1_m4_172000_307200 1.400000
R8537 n1_m4_172000_307200 n1_m4_172000_312000 1.400000
R8538 n1_m4_172000_312000 n1_m4_172000_316800 1.400000
R8539 n1_m4_172000_316800 n1_m4_172000_321600 1.400000
R8540 n1_m4_172000_321600 n1_m4_172000_324000 0.700000
R8541 n1_m4_172000_326400 n1_m4_172000_324000 0.700000
R8542 n1_m4_172000_326400 n1_m4_172000_331200 1.400000
R8543 n1_m4_172000_331200 n1_m4_172000_336000 1.400000
R8544 n1_m4_172000_336000 n1_m4_172000_340800 1.400000
R8545 n1_m4_172000_340800 n1_m4_172000_345600 1.400000
R8546 n1_m4_172000_345600 n1_m4_172000_350400 1.400000
R8547 n1_m4_172000_350400 n1_m4_172000_355200 1.400000
R8548 n1_m4_172000_355200 n1_m4_172000_360000 1.400000
R8549 n1_m4_172000_360000 n1_m4_172000_364800 1.400000
R8550 n1_m4_172000_364800 n1_m4_172000_369600 1.400000
R8551 n1_m4_172000_369600 n1_m4_172000_374400 1.400000
R8552 n1_m4_172000_374400 n1_m4_172000_379200 1.400000
R8553 n1_m4_172000_379200 n1_m4_172000_384000 1.400000
R8554 n1_m4_172000_384000 n1_m4_172000_388800 1.400000
R8555 n1_m4_172000_388800 n1_m4_172000_393600 1.400000
R8556 n1_m4_172000_393600 n1_m4_172000_398400 1.400000
R8557 n1_m4_172000_398400 n1_m4_172000_403200 1.400000
R8558 n1_m4_172000_403200 n1_m4_172000_404000 0.233333
R8559 n1_m4_256000_0 n1_m4_256000_4000 1.166667
R8560 n1_m4_256000_4800 n1_m4_256000_4000 0.233333
R8561 n1_m4_256000_4800 n1_m4_256000_9600 1.400000
R8562 n1_m4_256000_9600 n1_m4_256000_14400 1.400000
R8563 n1_m4_256000_14400 n1_m4_256000_19200 1.400000
R8564 n1_m4_256000_19200 n1_m4_256000_24000 1.400000
R8565 n1_m4_256000_24000 n1_m4_256000_28800 1.400000
R8566 n1_m4_256000_28800 n1_m4_256000_33600 1.400000
R8567 n1_m4_256000_33600 n1_m4_256000_38400 1.400000
R8568 n1_m4_256000_38400 n1_m4_256000_43200 1.400000
R8569 n1_m4_256000_43200 n1_m4_256000_48000 1.400000
R8570 n1_m4_256000_48000 n1_m4_256000_52800 1.400000
R8571 n1_m4_256000_52800 n1_m4_256000_57600 1.400000
R8572 n1_m4_256000_57600 n1_m4_256000_62400 1.400000
R8573 n1_m4_256000_62400 n1_m4_256000_67200 1.400000
R8574 n1_m4_256000_67200 n1_m4_256000_72000 1.400000
R8575 n1_m4_256000_72000 n1_m4_256000_76800 1.400000
R8576 n1_m4_256000_76800 n1_m4_256000_81600 1.400000
R8577 n1_m4_256000_81600 n1_m4_256000_84000 0.700000
R8578 n1_m4_256000_86400 n1_m4_256000_84000 0.700000
R8579 n1_m4_256000_86400 n1_m4_256000_91200 1.400000
R8580 n1_m4_256000_91200 n1_m4_256000_96000 1.400000
R8581 n1_m4_256000_96000 n1_m4_256000_100800 1.400000
R8582 n1_m4_256000_100800 n1_m4_256000_105600 1.400000
R8583 n1_m4_256000_105600 n1_m4_256000_110400 1.400000
R8584 n1_m4_256000_110400 n1_m4_256000_115200 1.400000
R8585 n1_m4_256000_115200 n1_m4_256000_120000 1.400000
R8586 n1_m4_256000_120000 n1_m4_256000_124800 1.400000
R8587 n1_m4_256000_124800 n1_m4_256000_129600 1.400000
R8588 n1_m4_256000_129600 n1_m4_256000_134400 1.400000
R8589 n1_m4_256000_134400 n1_m4_256000_139200 1.400000
R8590 n1_m4_256000_139200 n1_m4_256000_144000 1.400000
R8591 n1_m4_256000_144000 n1_m4_256000_148800 1.400000
R8592 n1_m4_256000_148800 n1_m4_256000_153600 1.400000
R8593 n1_m4_256000_153600 n1_m4_256000_158400 1.400000
R8594 n1_m4_256000_158400 n1_m4_256000_163200 1.400000
R8595 n1_m4_256000_163200 n1_m4_256000_164000 0.233333
R8596 n1_m4_256000_168000 n1_m4_256000_164000 1.166667
R8597 n1_m4_256000_168000 n1_m4_256000_172800 1.400000
R8598 n1_m4_256000_172800 n1_m4_256000_177600 1.400000
R8599 n1_m4_256000_177600 n1_m4_256000_182400 1.400000
R8600 n1_m4_256000_182400 n1_m4_256000_187200 1.400000
R8601 n1_m4_256000_187200 n1_m4_256000_192000 1.400000
R8602 n1_m4_256000_192000 n1_m4_256000_196800 1.400000
R8603 n1_m4_256000_398400 n1_m4_256000_403200 1.400000
R8604 n1_m4_256000_403200 n1_m4_256000_404000 0.233333
R8605 n1_m4_312000_0 n1_m4_312000_4000 1.166667
R8606 n1_m4_312000_4800 n1_m4_312000_4000 0.233333
R8607 n1_m4_312000_4800 n1_m4_312000_9600 1.400000
R8608 n1_m4_312000_9600 n1_m4_312000_14400 1.400000
R8609 n1_m4_312000_14400 n1_m4_312000_19200 1.400000
R8610 n1_m4_312000_19200 n1_m4_312000_24000 1.400000
R8611 n1_m4_312000_24000 n1_m4_312000_28800 1.400000
R8612 n1_m4_312000_28800 n1_m4_312000_33600 1.400000
R8613 n1_m4_312000_33600 n1_m4_312000_38400 1.400000
R8614 n1_m4_312000_38400 n1_m4_312000_43200 1.400000
R8615 n1_m4_312000_43200 n1_m4_312000_48000 1.400000
R8616 n1_m4_312000_48000 n1_m4_312000_52800 1.400000
R8617 n1_m4_312000_52800 n1_m4_312000_57600 1.400000
R8618 n1_m4_312000_57600 n1_m4_312000_62400 1.400000
R8619 n1_m4_312000_62400 n1_m4_312000_67200 1.400000
R8620 n1_m4_312000_67200 n1_m4_312000_72000 1.400000
R8621 n1_m4_312000_72000 n1_m4_312000_76800 1.400000
R8622 n1_m4_312000_76800 n1_m4_312000_81600 1.400000
R8623 n1_m4_312000_81600 n1_m4_312000_84000 0.700000
R8624 n1_m4_312000_86400 n1_m4_312000_84000 0.700000
R8625 n1_m4_312000_86400 n1_m4_312000_91200 1.400000
R8626 n1_m4_312000_91200 n1_m4_312000_96000 1.400000
R8627 n1_m4_312000_96000 n1_m4_312000_100800 1.400000
R8628 n1_m4_312000_100800 n1_m4_312000_105600 1.400000
R8629 n1_m4_312000_105600 n1_m4_312000_110400 1.400000
R8630 n1_m4_312000_110400 n1_m4_312000_115200 1.400000
R8631 n1_m4_312000_115200 n1_m4_312000_120000 1.400000
R8632 n1_m4_312000_120000 n1_m4_312000_124800 1.400000
R8633 n1_m4_312000_124800 n1_m4_312000_129600 1.400000
R8634 n1_m4_312000_129600 n1_m4_312000_134400 1.400000
R8635 n1_m4_312000_134400 n1_m4_312000_139200 1.400000
R8636 n1_m4_312000_139200 n1_m4_312000_144000 1.400000
R8637 n1_m4_312000_144000 n1_m4_312000_148800 1.400000
R8638 n1_m4_312000_148800 n1_m4_312000_153600 1.400000
R8639 n1_m4_312000_153600 n1_m4_312000_158400 1.400000
R8640 n1_m4_312000_158400 n1_m4_312000_163200 1.400000
R8641 n1_m4_312000_163200 n1_m4_312000_164000 0.233333
R8642 n1_m4_312000_168000 n1_m4_312000_164000 1.166667
R8643 n1_m4_312000_168000 n1_m4_312000_172800 1.400000
R8644 n1_m4_312000_172800 n1_m4_312000_177600 1.400000
R8645 n1_m4_312000_177600 n1_m4_312000_182400 1.400000
R8646 n1_m4_312000_182400 n1_m4_312000_187200 1.400000
R8647 n1_m4_312000_187200 n1_m4_312000_192000 1.400000
R8648 n1_m4_312000_192000 n1_m4_312000_196800 1.400000
R8649 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R8650 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R8651 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R8652 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R8653 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R8654 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R8655 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R8656 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R8657 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R8658 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R8659 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R8660 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R8661 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R8662 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R8663 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R8664 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R8665 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R8666 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R8667 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R8668 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R8669 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R8670 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R8671 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R8672 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R8673 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R8674 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R8675 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R8676 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R8677 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R8678 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R8679 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R8680 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R8681 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R8682 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R8683 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R8684 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R8685 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R8686 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R8687 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R8688 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R8689 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R8690 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R8691 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R8692 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R8693 n1_m4_312000_398400 n1_m4_312000_403200 1.400000
R8694 n1_m4_312000_403200 n1_m4_312000_404000 0.233333
R8695 n1_m4_368000_0 n1_m4_368000_4000 1.166667
R8696 n1_m4_368000_4800 n1_m4_368000_4000 0.233333
R8697 n1_m4_368000_4800 n1_m4_368000_9600 1.400000
R8698 n1_m4_368000_9600 n1_m4_368000_14400 1.400000
R8699 n1_m4_368000_14400 n1_m4_368000_19200 1.400000
R8700 n1_m4_368000_19200 n1_m4_368000_24000 1.400000
R8701 n1_m4_368000_24000 n1_m4_368000_28800 1.400000
R8702 n1_m4_368000_28800 n1_m4_368000_33600 1.400000
R8703 n1_m4_368000_33600 n1_m4_368000_38400 1.400000
R8704 n1_m4_368000_38400 n1_m4_368000_43200 1.400000
R8705 n1_m4_368000_43200 n1_m4_368000_48000 1.400000
R8706 n1_m4_368000_48000 n1_m4_368000_52800 1.400000
R8707 n1_m4_368000_52800 n1_m4_368000_57600 1.400000
R8708 n1_m4_368000_57600 n1_m4_368000_62400 1.400000
R8709 n1_m4_368000_62400 n1_m4_368000_67200 1.400000
R8710 n1_m4_368000_67200 n1_m4_368000_72000 1.400000
R8711 n1_m4_368000_72000 n1_m4_368000_76800 1.400000
R8712 n1_m4_368000_76800 n1_m4_368000_81600 1.400000
R8713 n1_m4_368000_81600 n1_m4_368000_84000 0.700000
R8714 n1_m4_368000_86400 n1_m4_368000_84000 0.700000
R8715 n1_m4_368000_86400 n1_m4_368000_91200 1.400000
R8716 n1_m4_368000_91200 n1_m4_368000_96000 1.400000
R8717 n1_m4_368000_96000 n1_m4_368000_100800 1.400000
R8718 n1_m4_368000_100800 n1_m4_368000_105600 1.400000
R8719 n1_m4_368000_105600 n1_m4_368000_110400 1.400000
R8720 n1_m4_368000_110400 n1_m4_368000_115200 1.400000
R8721 n1_m4_368000_115200 n1_m4_368000_120000 1.400000
R8722 n1_m4_368000_120000 n1_m4_368000_124800 1.400000
R8723 n1_m4_368000_124800 n1_m4_368000_129600 1.400000
R8724 n1_m4_368000_129600 n1_m4_368000_134400 1.400000
R8725 n1_m4_368000_134400 n1_m4_368000_139200 1.400000
R8726 n1_m4_368000_139200 n1_m4_368000_144000 1.400000
R8727 n1_m4_368000_144000 n1_m4_368000_148800 1.400000
R8728 n1_m4_368000_148800 n1_m4_368000_153600 1.400000
R8729 n1_m4_368000_153600 n1_m4_368000_158400 1.400000
R8730 n1_m4_368000_158400 n1_m4_368000_163200 1.400000
R8731 n1_m4_368000_163200 n1_m4_368000_164000 0.233333
R8732 n1_m4_368000_168000 n1_m4_368000_164000 1.166667
R8733 n1_m4_368000_168000 n1_m4_368000_172800 1.400000
R8734 n1_m4_368000_172800 n1_m4_368000_177600 1.400000
R8735 n1_m4_368000_177600 n1_m4_368000_182400 1.400000
R8736 n1_m4_368000_182400 n1_m4_368000_187200 1.400000
R8737 n1_m4_368000_187200 n1_m4_368000_192000 1.400000
R8738 n1_m4_368000_192000 n1_m4_368000_196800 1.400000
R8739 n1_m4_368000_398400 n1_m4_368000_403200 1.400000
R8740 n1_m4_368000_403200 n1_m4_368000_404000 0.233333
R8741 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R8742 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R8743 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R8744 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R8745 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R8746 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R8747 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R8748 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R8749 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R8750 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R8751 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R8752 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R8753 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R8754 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R8755 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R8756 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R8757 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R8758 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R8759 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R8760 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R8761 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R8762 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R8763 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R8764 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R8765 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R8766 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R8767 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R8768 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R8769 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R8770 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R8771 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R8772 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R8773 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R8774 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R8775 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R8776 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R8777 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R8778 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R8779 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R8780 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R8781 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R8782 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R8783 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R8784 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R8785 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R8786 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R8787 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R8788 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R8789 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R8790 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R8791 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R8792 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R8793 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R8794 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R8795 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R8796 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R8797 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R8798 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R8799 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R8800 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R8801 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R8802 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R8803 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R8804 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R8805 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R8806 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R8807 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R8808 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R8809 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R8810 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R8811 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R8812 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R8813 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R8814 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R8815 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R8816 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R8817 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R8818 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R8819 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R8820 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R8821 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R8822 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R8823 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R8824 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R8825 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R8826 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R8827 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R8828 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R8829 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R8830 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R8831 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R8832 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R8833 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R8834 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R8835 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R8836 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R8837 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R8838 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R8839 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R8840 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R8841 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R8842 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R8843 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R8844 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R8845 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R8846 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R8847 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R8848 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R8849 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R8850 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R8851 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R8852 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R8853 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R8854 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R8855 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R8856 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R8857 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R8858 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R8859 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R8860 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R8861 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R8862 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R8863 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R8864 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R8865 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R8866 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R8867 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R8868 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R8869 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R8870 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R8871 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R8872 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R8873 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R8874 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R8875 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R8876 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R8877 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R8878 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R8879 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R8880 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R8881 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R8882 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R8883 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R8884 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R8885 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R8886 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R8887 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R8888 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R8889 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R8890 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R8891 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R8892 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R8893 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R8894 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R8895 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R8896 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R8897 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R8898 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R8899 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R8900 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R8901 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R8902 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R8903 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R8904 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R8905 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R8906 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R8907 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R8908 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R8909 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R8910 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R8911 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R8912 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R8913 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R8914 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R8915 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R8916 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R8917 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R8918 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R8919 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R8920 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R8921 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R8922 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R8923 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R8924 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R8925 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R8926 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R8927 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R8928 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R8929 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R8930 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R8931 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R8932 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R8933 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R8934 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R8935 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R8936 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R8937 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R8938 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R8939 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R8940 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R8941 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R8942 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R8943 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R8944 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R8945 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R8946 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R8947 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R8948 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R8949 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R8950 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R8951 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R8952 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R8953 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R8954 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R8955 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R8956 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R8957 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R8958 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R8959 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R8960 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R8961 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R8962 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R8963 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R8964 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R8965 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R8966 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R8967 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R8968 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R8969 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R8970 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R8971 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R8972 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R8973 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R8974 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R8975 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R8976 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R8977 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R8978 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R8979 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R8980 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R8981 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R8982 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R8983 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R8984 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R8985 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R8986 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R8987 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R8988 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R8989 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R8990 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R8991 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R8992 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R8993 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R8994 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R8995 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R8996 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R8997 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R8998 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R8999 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R9000 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R9001 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R9002 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R9003 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R9004 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R9005 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R9006 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R9007 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R9008 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R9009 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R9010 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R9011 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R9012 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R9013 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R9014 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R9015 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R9016 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R9017 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R9018 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R9019 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R9020 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R9021 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R9022 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R9023 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R9024 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R9025 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R9026 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R9027 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R9028 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R9029 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R9030 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R9031 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R9032 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R9033 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R9034 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R9035 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R9036 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R9037 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R9038 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R9039 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R9040 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R9041 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R9042 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R9043 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R9044 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R9045 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R9046 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R9047 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R9048 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R9049 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R9050 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R9051 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R9052 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R9053 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R9054 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R9055 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R9056 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R9057 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R9058 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R9059 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R9060 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R9061 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R9062 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R9063 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R9064 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R9065 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R9066 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R9067 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R9068 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R9069 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R9070 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R9071 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R9072 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R9073 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R9074 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R9075 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R9076 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R9077 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R9078 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R9079 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R9080 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R9081 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R9082 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R9083 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R9084 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R9085 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R9086 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R9087 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R9088 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R9089 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R9090 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R9091 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R9092 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R9093 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R9094 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R9095 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R9096 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R9097 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R9098 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R9099 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R9100 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R9101 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R9102 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R9103 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R9104 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R9105 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R9106 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R9107 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R9108 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R9109 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R9110 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R9111 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R9112 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R9113 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R9114 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R9115 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R9116 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R9117 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R9118 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R9119 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R9120 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R9121 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R9122 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R9123 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R9124 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R9125 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R9126 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R9127 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R9128 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R9129 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R9130 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R9131 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R9132 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R9133 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R9134 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R9135 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R9136 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R9137 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R9138 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R9139 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R9140 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R9141 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R9142 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R9143 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R9144 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R9145 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R9146 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R9147 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R9148 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R9149 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R9150 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R9151 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R9152 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R9153 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R9154 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R9155 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R9156 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R9157 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R9158 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R9159 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R9160 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R9161 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R9162 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R9163 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R9164 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R9165 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R9166 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R9167 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R9168 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R9169 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R9170 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R9171 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R9172 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R9173 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R9174 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R9175 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R9176 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R9177 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R9178 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R9179 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R9180 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R9181 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R9182 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R9183 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R9184 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R9185 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R9186 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R9187 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R9188 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R9189 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R9190 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R9191 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R9192 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R9193 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R9194 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R9195 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R9196 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R9197 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R9198 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R9199 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R9200 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R9201 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R9202 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R9203 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R9204 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R9205 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R9206 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R9207 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R9208 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R9209 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R9210 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R9211 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R9212 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R9213 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R9214 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R9215 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R9216 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R9217 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R9218 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R9219 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R9220 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R9221 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R9222 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R9223 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R9224 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R9225 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R9226 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R9227 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R9228 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R9229 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R9230 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R9231 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R9232 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R9233 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R9234 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R9235 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R9236 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R9237 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R9238 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R9239 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R9240 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R9241 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R9242 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R9243 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R9244 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R9245 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R9246 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R9247 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R9248 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R9249 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R9250 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R9251 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R9252 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R9253 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R9254 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R9255 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R9256 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R9257 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R9258 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R9259 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R9260 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R9261 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R9262 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R9263 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R9264 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R9265 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R9266 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R9267 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R9268 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R9269 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R9270 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R9271 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R9272 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R9273 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R9274 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R9275 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R9276 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R9277 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R9278 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R9279 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R9280 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R9281 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R9282 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R9283 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R9284 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R9285 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R9286 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R9287 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R9288 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R9289 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R9290 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R9291 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R9292 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R9293 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R9294 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R9295 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R9296 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R9297 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R9298 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R9299 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R9300 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R9301 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R9302 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R9303 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R9304 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R9305 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R9306 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R9307 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R9308 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R9309 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R9310 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R9311 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R9312 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R9313 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R9314 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R9315 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R9316 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R9317 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R9318 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R9319 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R9320 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R9321 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R9322 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R9323 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R9324 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R9325 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R9326 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R9327 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R9328 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R9329 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R9330 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R9331 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R9332 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R9333 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R9334 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R9335 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R9336 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R9337 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R9338 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R9339 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R9340 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R9341 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R9342 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R9343 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R9344 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R9345 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R9346 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R9347 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R9348 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R9349 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R9350 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R9351 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R9352 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R9353 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R9354 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R9355 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R9356 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R9357 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R9358 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R9359 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R9360 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R9361 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R9362 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R9363 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R9364 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R9365 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R9366 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R9367 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R9368 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R9369 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R9370 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R9371 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R9372 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R9373 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R9374 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R9375 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R9376 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R9377 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R9378 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R9379 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R9380 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R9381 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R9382 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R9383 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R9384 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R9385 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R9386 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R9387 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R9388 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R9389 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R9390 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R9391 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R9392 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R9393 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R9394 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R9395 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R9396 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R9397 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R9398 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R9399 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R9400 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R9401 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R9402 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R9403 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R9404 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R9405 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R9406 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R9407 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R9408 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R9409 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R9410 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R9411 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R9412 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R9413 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R9414 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R9415 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R9416 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R9417 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R9418 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R9419 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R9420 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R9421 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R9422 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R9423 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R9424 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R9425 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R9426 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R9427 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R9428 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R9429 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R9430 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R9431 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R9432 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R9433 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R9434 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R9435 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R9436 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R9437 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R9438 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R9439 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R9440 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R9441 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R9442 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R9443 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R9444 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R9445 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R9446 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R9447 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R9448 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R9449 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R9450 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R9451 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R9452 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R9453 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R9454 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R9455 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R9456 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R9457 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R9458 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R9459 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R9460 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R9461 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R9462 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R9463 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R9464 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R9465 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R9466 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R9467 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R9468 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R9469 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R9470 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R9471 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R9472 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R9473 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R9474 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R9475 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R9476 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R9477 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R9478 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R9479 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R9480 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R9481 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R9482 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R9483 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R9484 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R9485 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R9486 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R9487 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R9488 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R9489 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R9490 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R9491 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R9492 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R9493 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R9494 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R9495 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R9496 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R9497 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R9498 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R9499 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R9500 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R9501 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R9502 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R9503 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R9504 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R9505 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R9506 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R9507 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R9508 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R9509 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R9510 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R9511 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R9512 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R9513 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R9514 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R9515 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R9516 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R9517 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R9518 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R9519 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R9520 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R9521 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R9522 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R9523 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R9524 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R9525 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R9526 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R9527 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R9528 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R9529 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R9530 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R9531 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R9532 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R9533 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R9534 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R9535 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R9536 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R9537 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R9538 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R9539 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R9540 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R9541 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R9542 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R9543 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R9544 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R9545 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R9546 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R9547 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R9548 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R9549 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R9550 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R9551 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R9552 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R9553 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R9554 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R9555 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R9556 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R9557 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R9558 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R9559 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R9560 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R9561 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R9562 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R9563 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R9564 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R9565 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R9566 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R9567 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R9568 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R9569 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R9570 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R9571 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R9572 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R9573 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R9574 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R9575 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R9576 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R9577 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R9578 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R9579 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R9580 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R9581 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R9582 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R9583 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R9584 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R9585 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R9586 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R9587 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R9588 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R9589 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R9590 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R9591 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R9592 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R9593 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R9594 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R9595 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R9596 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R9597 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R9598 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R9599 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R9600 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R9601 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R9602 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R9603 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R9604 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R9605 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R9606 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R9607 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R9608 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R9609 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R9610 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R9611 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R9612 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R9613 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R9614 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R9615 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R9616 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R9617 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R9618 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R9619 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R9620 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R9621 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R9622 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R9623 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R9624 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R9625 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R9626 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R9627 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R9628 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R9629 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R9630 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R9631 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R9632 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R9633 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R9634 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R9635 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R9636 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R9637 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R9638 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R9639 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R9640 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R9641 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R9642 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R9643 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R9644 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R9645 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R9646 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R9647 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R9648 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R9649 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R9650 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R9651 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R9652 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R9653 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R9654 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R9655 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R9656 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R9657 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R9658 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R9659 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R9660 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R9661 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R9662 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R9663 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R9664 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R9665 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R9666 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R9667 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R9668 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R9669 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R9670 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R9671 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R9672 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R9673 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R9674 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R9675 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R9676 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R9677 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R9678 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R9679 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R9680 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R9681 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R9682 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R9683 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R9684 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R9685 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R9686 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R9687 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R9688 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R9689 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R9690 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R9691 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R9692 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R9693 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R9694 n1_m1_4000_0 n1_m4_4000_0 15.000000
R9695 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R9696 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R9697 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R9698 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R9699 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R9700 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R9701 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R9702 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R9703 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R9704 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R9705 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R9706 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R9707 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R9708 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R9709 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R9710 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R9711 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R9712 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R9713 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R9714 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R9715 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R9716 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R9717 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R9718 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R9719 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R9720 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R9721 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R9722 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R9723 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R9724 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R9725 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R9726 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R9727 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R9728 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R9729 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R9730 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R9731 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R9732 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R9733 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R9734 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R9735 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R9736 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R9737 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R9738 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R9739 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R9740 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R9741 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R9742 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R9743 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R9744 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R9745 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R9746 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R9747 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R9748 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R9749 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R9750 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R9751 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R9752 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R9753 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R9754 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R9755 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R9756 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R9757 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R9758 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R9759 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R9760 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R9761 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R9762 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R9763 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R9764 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R9765 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R9766 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R9767 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R9768 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R9769 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R9770 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R9771 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R9772 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R9773 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R9774 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R9775 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R9776 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R9777 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R9778 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R9779 n1_m1_32000_0 n1_m4_32000_0 15.000000
R9780 n1_m1_60000_0 n1_m4_60000_0 15.000000
R9781 n1_m1_60000_4800 n1_m4_60000_4800 15.000000
R9782 n1_m1_60000_9600 n1_m4_60000_9600 15.000000
R9783 n1_m1_60000_14400 n1_m4_60000_14400 15.000000
R9784 n1_m1_60000_19200 n1_m4_60000_19200 15.000000
R9785 n1_m1_60000_24000 n1_m4_60000_24000 15.000000
R9786 n1_m1_60000_28800 n1_m4_60000_28800 15.000000
R9787 n1_m1_60000_33600 n1_m4_60000_33600 15.000000
R9788 n1_m1_60000_38400 n1_m4_60000_38400 15.000000
R9789 n1_m1_60000_43200 n1_m4_60000_43200 15.000000
R9790 n1_m1_60000_48000 n1_m4_60000_48000 15.000000
R9791 n1_m1_60000_52800 n1_m4_60000_52800 15.000000
R9792 n1_m1_60000_57600 n1_m4_60000_57600 15.000000
R9793 n1_m1_60000_62400 n1_m4_60000_62400 15.000000
R9794 n1_m1_60000_67200 n1_m4_60000_67200 15.000000
R9795 n1_m1_60000_72000 n1_m4_60000_72000 15.000000
R9796 n1_m1_60000_76800 n1_m4_60000_76800 15.000000
R9797 n1_m1_60000_81600 n1_m4_60000_81600 15.000000
R9798 n1_m1_60000_86400 n1_m4_60000_86400 15.000000
R9799 n1_m1_60000_91200 n1_m4_60000_91200 15.000000
R9800 n1_m1_60000_96000 n1_m4_60000_96000 15.000000
R9801 n1_m1_60000_100800 n1_m4_60000_100800 15.000000
R9802 n1_m1_60000_105600 n1_m4_60000_105600 15.000000
R9803 n1_m1_60000_110400 n1_m4_60000_110400 15.000000
R9804 n1_m1_60000_115200 n1_m4_60000_115200 15.000000
R9805 n1_m1_60000_120000 n1_m4_60000_120000 15.000000
R9806 n1_m1_60000_124800 n1_m4_60000_124800 15.000000
R9807 n1_m1_60000_129600 n1_m4_60000_129600 15.000000
R9808 n1_m1_60000_134400 n1_m4_60000_134400 15.000000
R9809 n1_m1_60000_139200 n1_m4_60000_139200 15.000000
R9810 n1_m1_60000_144000 n1_m4_60000_144000 15.000000
R9811 n1_m1_60000_148800 n1_m4_60000_148800 15.000000
R9812 n1_m1_60000_153600 n1_m4_60000_153600 15.000000
R9813 n1_m1_60000_158400 n1_m4_60000_158400 15.000000
R9814 n1_m1_60000_163200 n1_m4_60000_163200 15.000000
R9815 n1_m1_60000_168000 n1_m4_60000_168000 15.000000
R9816 n1_m1_60000_172800 n1_m4_60000_172800 15.000000
R9817 n1_m1_60000_177600 n1_m4_60000_177600 15.000000
R9818 n1_m1_60000_182400 n1_m4_60000_182400 15.000000
R9819 n1_m1_60000_187200 n1_m4_60000_187200 15.000000
R9820 n1_m1_60000_192000 n1_m4_60000_192000 15.000000
R9821 n1_m1_60000_196800 n1_m4_60000_196800 15.000000
R9822 n1_m1_88000_0 n1_m4_88000_0 15.000000
R9823 n1_m1_88000_201600 n1_m4_88000_201600 15.000000
R9824 n1_m1_88000_206400 n1_m4_88000_206400 15.000000
R9825 n1_m1_88000_211200 n1_m4_88000_211200 15.000000
R9826 n1_m1_88000_216000 n1_m4_88000_216000 15.000000
R9827 n1_m1_88000_220800 n1_m4_88000_220800 15.000000
R9828 n1_m1_88000_225600 n1_m4_88000_225600 15.000000
R9829 n1_m1_88000_230400 n1_m4_88000_230400 15.000000
R9830 n1_m1_88000_235200 n1_m4_88000_235200 15.000000
R9831 n1_m1_88000_240000 n1_m4_88000_240000 15.000000
R9832 n1_m1_88000_244800 n1_m4_88000_244800 15.000000
R9833 n1_m1_88000_249600 n1_m4_88000_249600 15.000000
R9834 n1_m1_88000_254400 n1_m4_88000_254400 15.000000
R9835 n1_m1_88000_259200 n1_m4_88000_259200 15.000000
R9836 n1_m1_88000_264000 n1_m4_88000_264000 15.000000
R9837 n1_m1_88000_268800 n1_m4_88000_268800 15.000000
R9838 n1_m1_88000_273600 n1_m4_88000_273600 15.000000
R9839 n1_m1_88000_278400 n1_m4_88000_278400 15.000000
R9840 n1_m1_88000_283200 n1_m4_88000_283200 15.000000
R9841 n1_m1_88000_288000 n1_m4_88000_288000 15.000000
R9842 n1_m1_88000_292800 n1_m4_88000_292800 15.000000
R9843 n1_m1_88000_297600 n1_m4_88000_297600 15.000000
R9844 n1_m1_88000_302400 n1_m4_88000_302400 15.000000
R9845 n1_m1_88000_307200 n1_m4_88000_307200 15.000000
R9846 n1_m1_88000_312000 n1_m4_88000_312000 15.000000
R9847 n1_m1_88000_316800 n1_m4_88000_316800 15.000000
R9848 n1_m1_88000_321600 n1_m4_88000_321600 15.000000
R9849 n1_m1_88000_326400 n1_m4_88000_326400 15.000000
R9850 n1_m1_88000_331200 n1_m4_88000_331200 15.000000
R9851 n1_m1_88000_336000 n1_m4_88000_336000 15.000000
R9852 n1_m1_88000_340800 n1_m4_88000_340800 15.000000
R9853 n1_m1_88000_345600 n1_m4_88000_345600 15.000000
R9854 n1_m1_88000_350400 n1_m4_88000_350400 15.000000
R9855 n1_m1_88000_355200 n1_m4_88000_355200 15.000000
R9856 n1_m1_88000_360000 n1_m4_88000_360000 15.000000
R9857 n1_m1_88000_364800 n1_m4_88000_364800 15.000000
R9858 n1_m1_88000_369600 n1_m4_88000_369600 15.000000
R9859 n1_m1_88000_374400 n1_m4_88000_374400 15.000000
R9860 n1_m1_88000_379200 n1_m4_88000_379200 15.000000
R9861 n1_m1_88000_384000 n1_m4_88000_384000 15.000000
R9862 n1_m1_88000_388800 n1_m4_88000_388800 15.000000
R9863 n1_m1_88000_393600 n1_m4_88000_393600 15.000000
R9864 n1_m1_88000_398400 n1_m4_88000_398400 15.000000
R9865 n1_m1_88000_403200 n1_m4_88000_403200 15.000000
R9866 n1_m1_116000_0 n1_m4_116000_0 15.000000
R9867 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R9868 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R9869 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R9870 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R9871 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R9872 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R9873 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R9874 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R9875 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R9876 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R9877 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R9878 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R9879 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R9880 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R9881 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R9882 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R9883 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R9884 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R9885 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R9886 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R9887 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R9888 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R9889 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R9890 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R9891 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R9892 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R9893 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R9894 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R9895 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R9896 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R9897 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R9898 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R9899 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R9900 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R9901 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R9902 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R9903 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R9904 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R9905 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R9906 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R9907 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R9908 n1_m1_144000_0 n1_m4_144000_0 15.000000
R9909 n1_m1_172000_0 n1_m4_172000_0 15.000000
R9910 n1_m1_172000_4800 n1_m4_172000_4800 15.000000
R9911 n1_m1_172000_9600 n1_m4_172000_9600 15.000000
R9912 n1_m1_172000_14400 n1_m4_172000_14400 15.000000
R9913 n1_m1_172000_19200 n1_m4_172000_19200 15.000000
R9914 n1_m1_172000_24000 n1_m4_172000_24000 15.000000
R9915 n1_m1_172000_28800 n1_m4_172000_28800 15.000000
R9916 n1_m1_172000_33600 n1_m4_172000_33600 15.000000
R9917 n1_m1_172000_38400 n1_m4_172000_38400 15.000000
R9918 n1_m1_172000_43200 n1_m4_172000_43200 15.000000
R9919 n1_m1_172000_48000 n1_m4_172000_48000 15.000000
R9920 n1_m1_172000_52800 n1_m4_172000_52800 15.000000
R9921 n1_m1_172000_57600 n1_m4_172000_57600 15.000000
R9922 n1_m1_172000_62400 n1_m4_172000_62400 15.000000
R9923 n1_m1_172000_67200 n1_m4_172000_67200 15.000000
R9924 n1_m1_172000_72000 n1_m4_172000_72000 15.000000
R9925 n1_m1_172000_76800 n1_m4_172000_76800 15.000000
R9926 n1_m1_172000_81600 n1_m4_172000_81600 15.000000
R9927 n1_m1_172000_86400 n1_m4_172000_86400 15.000000
R9928 n1_m1_172000_91200 n1_m4_172000_91200 15.000000
R9929 n1_m1_172000_96000 n1_m4_172000_96000 15.000000
R9930 n1_m1_172000_100800 n1_m4_172000_100800 15.000000
R9931 n1_m1_172000_105600 n1_m4_172000_105600 15.000000
R9932 n1_m1_172000_110400 n1_m4_172000_110400 15.000000
R9933 n1_m1_172000_115200 n1_m4_172000_115200 15.000000
R9934 n1_m1_172000_120000 n1_m4_172000_120000 15.000000
R9935 n1_m1_172000_124800 n1_m4_172000_124800 15.000000
R9936 n1_m1_172000_129600 n1_m4_172000_129600 15.000000
R9937 n1_m1_172000_134400 n1_m4_172000_134400 15.000000
R9938 n1_m1_172000_139200 n1_m4_172000_139200 15.000000
R9939 n1_m1_172000_144000 n1_m4_172000_144000 15.000000
R9940 n1_m1_172000_148800 n1_m4_172000_148800 15.000000
R9941 n1_m1_172000_153600 n1_m4_172000_153600 15.000000
R9942 n1_m1_172000_158400 n1_m4_172000_158400 15.000000
R9943 n1_m1_172000_163200 n1_m4_172000_163200 15.000000
R9944 n1_m1_172000_168000 n1_m4_172000_168000 15.000000
R9945 n1_m1_172000_172800 n1_m4_172000_172800 15.000000
R9946 n1_m1_172000_177600 n1_m4_172000_177600 15.000000
R9947 n1_m1_172000_182400 n1_m4_172000_182400 15.000000
R9948 n1_m1_172000_187200 n1_m4_172000_187200 15.000000
R9949 n1_m1_172000_192000 n1_m4_172000_192000 15.000000
R9950 n1_m1_172000_196800 n1_m4_172000_196800 15.000000
R9951 n1_m1_172000_201600 n1_m4_172000_201600 15.000000
R9952 n1_m1_172000_206400 n1_m4_172000_206400 15.000000
R9953 n1_m1_172000_211200 n1_m4_172000_211200 15.000000
R9954 n1_m1_172000_216000 n1_m4_172000_216000 15.000000
R9955 n1_m1_172000_220800 n1_m4_172000_220800 15.000000
R9956 n1_m1_172000_225600 n1_m4_172000_225600 15.000000
R9957 n1_m1_172000_230400 n1_m4_172000_230400 15.000000
R9958 n1_m1_172000_235200 n1_m4_172000_235200 15.000000
R9959 n1_m1_172000_240000 n1_m4_172000_240000 15.000000
R9960 n1_m1_172000_244800 n1_m4_172000_244800 15.000000
R9961 n1_m1_172000_249600 n1_m4_172000_249600 15.000000
R9962 n1_m1_172000_254400 n1_m4_172000_254400 15.000000
R9963 n1_m1_172000_259200 n1_m4_172000_259200 15.000000
R9964 n1_m1_172000_264000 n1_m4_172000_264000 15.000000
R9965 n1_m1_172000_268800 n1_m4_172000_268800 15.000000
R9966 n1_m1_172000_273600 n1_m4_172000_273600 15.000000
R9967 n1_m1_172000_278400 n1_m4_172000_278400 15.000000
R9968 n1_m1_172000_283200 n1_m4_172000_283200 15.000000
R9969 n1_m1_172000_288000 n1_m4_172000_288000 15.000000
R9970 n1_m1_172000_292800 n1_m4_172000_292800 15.000000
R9971 n1_m1_172000_297600 n1_m4_172000_297600 15.000000
R9972 n1_m1_172000_302400 n1_m4_172000_302400 15.000000
R9973 n1_m1_172000_307200 n1_m4_172000_307200 15.000000
R9974 n1_m1_172000_312000 n1_m4_172000_312000 15.000000
R9975 n1_m1_172000_316800 n1_m4_172000_316800 15.000000
R9976 n1_m1_172000_321600 n1_m4_172000_321600 15.000000
R9977 n1_m1_172000_326400 n1_m4_172000_326400 15.000000
R9978 n1_m1_172000_331200 n1_m4_172000_331200 15.000000
R9979 n1_m1_172000_336000 n1_m4_172000_336000 15.000000
R9980 n1_m1_172000_340800 n1_m4_172000_340800 15.000000
R9981 n1_m1_172000_345600 n1_m4_172000_345600 15.000000
R9982 n1_m1_172000_350400 n1_m4_172000_350400 15.000000
R9983 n1_m1_172000_355200 n1_m4_172000_355200 15.000000
R9984 n1_m1_172000_360000 n1_m4_172000_360000 15.000000
R9985 n1_m1_172000_364800 n1_m4_172000_364800 15.000000
R9986 n1_m1_172000_369600 n1_m4_172000_369600 15.000000
R9987 n1_m1_172000_374400 n1_m4_172000_374400 15.000000
R9988 n1_m1_172000_379200 n1_m4_172000_379200 15.000000
R9989 n1_m1_172000_384000 n1_m4_172000_384000 15.000000
R9990 n1_m1_172000_388800 n1_m4_172000_388800 15.000000
R9991 n1_m1_172000_393600 n1_m4_172000_393600 15.000000
R9992 n1_m1_172000_398400 n1_m4_172000_398400 15.000000
R9993 n1_m1_172000_403200 n1_m4_172000_403200 15.000000
R9994 n1_m1_200000_0 n1_m4_200000_0 15.000000
R9995 n1_m1_228000_0 n1_m4_228000_0 15.000000
R9996 n1_m1_256000_0 n1_m4_256000_0 15.000000
R9997 n1_m1_256000_4800 n1_m4_256000_4800 15.000000
R9998 n1_m1_256000_9600 n1_m4_256000_9600 15.000000
R9999 n1_m1_256000_14400 n1_m4_256000_14400 15.000000
R10000 n1_m1_256000_19200 n1_m4_256000_19200 15.000000
R10001 n1_m1_256000_24000 n1_m4_256000_24000 15.000000
R10002 n1_m1_256000_28800 n1_m4_256000_28800 15.000000
R10003 n1_m1_256000_33600 n1_m4_256000_33600 15.000000
R10004 n1_m1_256000_38400 n1_m4_256000_38400 15.000000
R10005 n1_m1_256000_43200 n1_m4_256000_43200 15.000000
R10006 n1_m1_256000_48000 n1_m4_256000_48000 15.000000
R10007 n1_m1_256000_52800 n1_m4_256000_52800 15.000000
R10008 n1_m1_256000_57600 n1_m4_256000_57600 15.000000
R10009 n1_m1_256000_62400 n1_m4_256000_62400 15.000000
R10010 n1_m1_256000_67200 n1_m4_256000_67200 15.000000
R10011 n1_m1_256000_72000 n1_m4_256000_72000 15.000000
R10012 n1_m1_256000_76800 n1_m4_256000_76800 15.000000
R10013 n1_m1_256000_81600 n1_m4_256000_81600 15.000000
R10014 n1_m1_256000_86400 n1_m4_256000_86400 15.000000
R10015 n1_m1_256000_91200 n1_m4_256000_91200 15.000000
R10016 n1_m1_256000_96000 n1_m4_256000_96000 15.000000
R10017 n1_m1_256000_100800 n1_m4_256000_100800 15.000000
R10018 n1_m1_256000_105600 n1_m4_256000_105600 15.000000
R10019 n1_m1_256000_110400 n1_m4_256000_110400 15.000000
R10020 n1_m1_256000_115200 n1_m4_256000_115200 15.000000
R10021 n1_m1_256000_120000 n1_m4_256000_120000 15.000000
R10022 n1_m1_256000_124800 n1_m4_256000_124800 15.000000
R10023 n1_m1_256000_129600 n1_m4_256000_129600 15.000000
R10024 n1_m1_256000_134400 n1_m4_256000_134400 15.000000
R10025 n1_m1_256000_139200 n1_m4_256000_139200 15.000000
R10026 n1_m1_256000_144000 n1_m4_256000_144000 15.000000
R10027 n1_m1_256000_148800 n1_m4_256000_148800 15.000000
R10028 n1_m1_256000_153600 n1_m4_256000_153600 15.000000
R10029 n1_m1_256000_158400 n1_m4_256000_158400 15.000000
R10030 n1_m1_256000_163200 n1_m4_256000_163200 15.000000
R10031 n1_m1_256000_168000 n1_m4_256000_168000 15.000000
R10032 n1_m1_256000_172800 n1_m4_256000_172800 15.000000
R10033 n1_m1_256000_177600 n1_m4_256000_177600 15.000000
R10034 n1_m1_256000_182400 n1_m4_256000_182400 15.000000
R10035 n1_m1_256000_187200 n1_m4_256000_187200 15.000000
R10036 n1_m1_256000_192000 n1_m4_256000_192000 15.000000
R10037 n1_m1_256000_196800 n1_m4_256000_196800 15.000000
R10038 n1_m1_256000_403200 n1_m4_256000_403200 15.000000
R10039 n1_m1_284000_0 n1_m4_284000_0 15.000000
R10040 n1_m1_312000_0 n1_m4_312000_0 15.000000
R10041 n1_m1_312000_4800 n1_m4_312000_4800 15.000000
R10042 n1_m1_312000_9600 n1_m4_312000_9600 15.000000
R10043 n1_m1_312000_14400 n1_m4_312000_14400 15.000000
R10044 n1_m1_312000_19200 n1_m4_312000_19200 15.000000
R10045 n1_m1_312000_24000 n1_m4_312000_24000 15.000000
R10046 n1_m1_312000_28800 n1_m4_312000_28800 15.000000
R10047 n1_m1_312000_33600 n1_m4_312000_33600 15.000000
R10048 n1_m1_312000_38400 n1_m4_312000_38400 15.000000
R10049 n1_m1_312000_43200 n1_m4_312000_43200 15.000000
R10050 n1_m1_312000_48000 n1_m4_312000_48000 15.000000
R10051 n1_m1_312000_52800 n1_m4_312000_52800 15.000000
R10052 n1_m1_312000_57600 n1_m4_312000_57600 15.000000
R10053 n1_m1_312000_62400 n1_m4_312000_62400 15.000000
R10054 n1_m1_312000_67200 n1_m4_312000_67200 15.000000
R10055 n1_m1_312000_72000 n1_m4_312000_72000 15.000000
R10056 n1_m1_312000_76800 n1_m4_312000_76800 15.000000
R10057 n1_m1_312000_81600 n1_m4_312000_81600 15.000000
R10058 n1_m1_312000_86400 n1_m4_312000_86400 15.000000
R10059 n1_m1_312000_91200 n1_m4_312000_91200 15.000000
R10060 n1_m1_312000_96000 n1_m4_312000_96000 15.000000
R10061 n1_m1_312000_100800 n1_m4_312000_100800 15.000000
R10062 n1_m1_312000_105600 n1_m4_312000_105600 15.000000
R10063 n1_m1_312000_110400 n1_m4_312000_110400 15.000000
R10064 n1_m1_312000_115200 n1_m4_312000_115200 15.000000
R10065 n1_m1_312000_120000 n1_m4_312000_120000 15.000000
R10066 n1_m1_312000_124800 n1_m4_312000_124800 15.000000
R10067 n1_m1_312000_129600 n1_m4_312000_129600 15.000000
R10068 n1_m1_312000_134400 n1_m4_312000_134400 15.000000
R10069 n1_m1_312000_139200 n1_m4_312000_139200 15.000000
R10070 n1_m1_312000_144000 n1_m4_312000_144000 15.000000
R10071 n1_m1_312000_148800 n1_m4_312000_148800 15.000000
R10072 n1_m1_312000_153600 n1_m4_312000_153600 15.000000
R10073 n1_m1_312000_158400 n1_m4_312000_158400 15.000000
R10074 n1_m1_312000_163200 n1_m4_312000_163200 15.000000
R10075 n1_m1_312000_168000 n1_m4_312000_168000 15.000000
R10076 n1_m1_312000_172800 n1_m4_312000_172800 15.000000
R10077 n1_m1_312000_177600 n1_m4_312000_177600 15.000000
R10078 n1_m1_312000_182400 n1_m4_312000_182400 15.000000
R10079 n1_m1_312000_187200 n1_m4_312000_187200 15.000000
R10080 n1_m1_312000_192000 n1_m4_312000_192000 15.000000
R10081 n1_m1_312000_196800 n1_m4_312000_196800 15.000000
R10082 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R10083 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R10084 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R10085 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R10086 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R10087 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R10088 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R10089 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R10090 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R10091 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R10092 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R10093 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R10094 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R10095 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R10096 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R10097 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R10098 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R10099 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R10100 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R10101 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R10102 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R10103 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R10104 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R10105 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R10106 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R10107 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R10108 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R10109 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R10110 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R10111 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R10112 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R10113 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R10114 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R10115 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R10116 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R10117 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R10118 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R10119 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R10120 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R10121 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R10122 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R10123 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R10124 n1_m1_312000_403200 n1_m4_312000_403200 15.000000
R10125 n1_m1_340000_0 n1_m4_340000_0 15.000000
R10126 n1_m1_368000_0 n1_m4_368000_0 15.000000
R10127 n1_m1_368000_4800 n1_m4_368000_4800 15.000000
R10128 n1_m1_368000_9600 n1_m4_368000_9600 15.000000
R10129 n1_m1_368000_14400 n1_m4_368000_14400 15.000000
R10130 n1_m1_368000_19200 n1_m4_368000_19200 15.000000
R10131 n1_m1_368000_24000 n1_m4_368000_24000 15.000000
R10132 n1_m1_368000_28800 n1_m4_368000_28800 15.000000
R10133 n1_m1_368000_33600 n1_m4_368000_33600 15.000000
R10134 n1_m1_368000_38400 n1_m4_368000_38400 15.000000
R10135 n1_m1_368000_43200 n1_m4_368000_43200 15.000000
R10136 n1_m1_368000_48000 n1_m4_368000_48000 15.000000
R10137 n1_m1_368000_52800 n1_m4_368000_52800 15.000000
R10138 n1_m1_368000_57600 n1_m4_368000_57600 15.000000
R10139 n1_m1_368000_62400 n1_m4_368000_62400 15.000000
R10140 n1_m1_368000_67200 n1_m4_368000_67200 15.000000
R10141 n1_m1_368000_72000 n1_m4_368000_72000 15.000000
R10142 n1_m1_368000_76800 n1_m4_368000_76800 15.000000
R10143 n1_m1_368000_81600 n1_m4_368000_81600 15.000000
R10144 n1_m1_368000_86400 n1_m4_368000_86400 15.000000
R10145 n1_m1_368000_91200 n1_m4_368000_91200 15.000000
R10146 n1_m1_368000_96000 n1_m4_368000_96000 15.000000
R10147 n1_m1_368000_100800 n1_m4_368000_100800 15.000000
R10148 n1_m1_368000_105600 n1_m4_368000_105600 15.000000
R10149 n1_m1_368000_110400 n1_m4_368000_110400 15.000000
R10150 n1_m1_368000_115200 n1_m4_368000_115200 15.000000
R10151 n1_m1_368000_120000 n1_m4_368000_120000 15.000000
R10152 n1_m1_368000_124800 n1_m4_368000_124800 15.000000
R10153 n1_m1_368000_129600 n1_m4_368000_129600 15.000000
R10154 n1_m1_368000_134400 n1_m4_368000_134400 15.000000
R10155 n1_m1_368000_139200 n1_m4_368000_139200 15.000000
R10156 n1_m1_368000_144000 n1_m4_368000_144000 15.000000
R10157 n1_m1_368000_148800 n1_m4_368000_148800 15.000000
R10158 n1_m1_368000_153600 n1_m4_368000_153600 15.000000
R10159 n1_m1_368000_158400 n1_m4_368000_158400 15.000000
R10160 n1_m1_368000_163200 n1_m4_368000_163200 15.000000
R10161 n1_m1_368000_168000 n1_m4_368000_168000 15.000000
R10162 n1_m1_368000_172800 n1_m4_368000_172800 15.000000
R10163 n1_m1_368000_177600 n1_m4_368000_177600 15.000000
R10164 n1_m1_368000_182400 n1_m4_368000_182400 15.000000
R10165 n1_m1_368000_187200 n1_m4_368000_187200 15.000000
R10166 n1_m1_368000_192000 n1_m4_368000_192000 15.000000
R10167 n1_m1_368000_196800 n1_m4_368000_196800 15.000000
R10168 n1_m1_368000_403200 n1_m4_368000_403200 15.000000
R10169 n1_m1_396000_0 n1_m4_396000_0 15.000000
R10170 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R10171 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R10172 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R10173 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R10174 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R10175 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R10176 n1_m4_60000_4000 n1_m7_60000_4000 9.000000
R10177 n1_m4_60000_84000 n1_m7_60000_84000 9.000000
R10178 n1_m4_60000_164000 n1_m7_60000_164000 9.000000
R10179 n1_m4_88000_244000 n1_m7_88000_244000 9.000000
R10180 n1_m4_88000_324000 n1_m7_88000_324000 9.000000
R10181 n1_m4_88000_404000 n1_m7_88000_404000 9.000000
R10182 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R10183 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R10184 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R10185 n1_m4_172000_4000 n1_m7_172000_4000 9.000000
R10186 n1_m4_172000_84000 n1_m7_172000_84000 9.000000
R10187 n1_m4_172000_164000 n1_m7_172000_164000 9.000000
R10188 n1_m4_172000_244000 n1_m7_172000_244000 9.000000
R10189 n1_m4_172000_324000 n1_m7_172000_324000 9.000000
R10190 n1_m4_172000_404000 n1_m7_172000_404000 9.000000
R10191 n1_m4_256000_4000 n1_m7_256000_4000 9.000000
R10192 n1_m4_256000_84000 n1_m7_256000_84000 9.000000
R10193 n1_m4_256000_164000 n1_m7_256000_164000 9.000000
R10194 n1_m4_256000_404000 n1_m7_256000_404000 9.000000
R10195 n1_m4_312000_4000 n1_m7_312000_4000 9.000000
R10196 n1_m4_312000_84000 n1_m7_312000_84000 9.000000
R10197 n1_m4_312000_164000 n1_m7_312000_164000 9.000000
R10198 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R10199 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R10200 n1_m4_312000_404000 n1_m7_312000_404000 9.000000
R10201 n1_m4_368000_4000 n1_m7_368000_4000 9.000000
R10202 n1_m4_368000_84000 n1_m7_368000_84000 9.000000
R10203 n1_m4_368000_164000 n1_m7_368000_164000 9.000000
R10204 n1_m4_368000_404000 n1_m7_368000_404000 9.000000
R10205 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R10206 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R10207 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R10208 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R10209 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R10210 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R10211 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R10212 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R10213 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R10214 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R10215 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R10216 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R10217 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R10218 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R10219 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R10220 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R10221 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R10222 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R10223 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R10224 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R10225 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R10226 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R10227 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R10228 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R10229 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R10230 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R10231 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R10232 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R10233 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R10234 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R10235 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R10236 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R10237 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R10238 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R10239 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R10240 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R10241 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R10242 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R10243 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R10244 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R10245 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R10246 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R10247 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R10248 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R10249 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R10250 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R10251 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R10252 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R10253 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R10254 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R10255 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R10256 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R10257 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R10258 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R10259 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R10260 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R10261 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R10262 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R10263 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R10264 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R10265 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R10266 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R10267 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R10268 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R10269 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R10270 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R10271 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R10272 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R10273 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R10274 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R10275 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R10276 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R10277 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R10278 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R10279 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R10280 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R10281 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R10282 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R10283 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R10284 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R10285 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R10286 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R10287 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R10288 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R10289 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R10290 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R10291 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R10292 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R10293 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R10294 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R10295 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R10296 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R10297 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R10298 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R10299 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R10300 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R10301 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R10302 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R10303 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R10304 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R10305 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R10306 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R10307 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R10308 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R10309 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R10310 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R10311 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R10312 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R10313 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R10314 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R10315 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R10316 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R10317 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R10318 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R10319 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R10320 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R10321 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R10322 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R10323 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R10324 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R10325 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R10326 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R10327 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R10328 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R10329 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R10330 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R10331 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R10332 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R10333 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R10334 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R10335 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R10336 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R10337 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R10338 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R10339 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R10340 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R10341 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R10342 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R10343 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R10344 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R10345 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R10346 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R10347 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R10348 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R10349 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R10350 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R10351 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R10352 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R10353 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R10354 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R10355 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R10356 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R10357 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R10358 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R10359 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R10360 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R10361 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R10362 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R10363 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R10364 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R10365 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R10366 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R10367 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R10368 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R10369 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R10370 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R10371 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R10372 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R10373 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R10374 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R10375 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R10376 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R10377 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R10378 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R10379 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R10380 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R10381 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R10382 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R10383 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R10384 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R10385 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R10386 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R10387 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R10388 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R10389 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R10390 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R10391 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R10392 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R10393 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R10394 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R10395 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R10396 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R10397 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R10398 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R10399 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R10400 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R10401 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R10402 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R10403 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R10404 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R10405 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R10406 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R10407 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R10408 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R10409 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R10410 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R10411 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R10412 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R10413 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R10414 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R10415 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R10416 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R10417 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R10418 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R10419 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R10420 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R10421 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R10422 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R10423 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R10424 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R10425 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R10426 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R10427 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R10428 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R10429 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R10430 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R10431 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R10432 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R10433 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R10434 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R10435 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R10436 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R10437 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R10438 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R10439 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R10440 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R10441 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R10442 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R10443 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R10444 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R10445 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R10446 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R10447 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R10448 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R10449 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R10450 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R10451 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R10452 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R10453 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R10454 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R10455 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R10456 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R10457 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R10458 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R10459 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R10460 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R10461 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R10462 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R10463 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R10464 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R10465 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R10466 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R10467 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R10468 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R10469 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R10470 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R10471 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R10472 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R10473 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R10474 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R10475 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R10476 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R10477 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R10478 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R10479 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R10480 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R10481 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R10482 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R10483 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R10484 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R10485 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R10486 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R10487 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R10488 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R10489 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R10490 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R10491 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R10492 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R10493 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R10494 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R10495 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R10496 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R10497 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R10498 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R10499 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R10500 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R10501 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R10502 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R10503 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R10504 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R10505 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R10506 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R10507 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R10508 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R10509 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R10510 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R10511 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R10512 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R10513 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R10514 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R10515 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R10516 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R10517 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R10518 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R10519 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R10520 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R10521 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R10522 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R10523 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R10524 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R10525 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R10526 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R10527 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R10528 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R10529 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R10530 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R10531 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R10532 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R10533 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R10534 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R10535 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R10536 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R10537 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R10538 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R10539 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R10540 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R10541 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R10542 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R10543 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R10544 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R10545 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R10546 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R10547 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R10548 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R10549 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R10550 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R10551 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R10552 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R10553 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R10554 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R10555 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R10556 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R10557 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R10558 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R10559 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R10560 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R10561 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R10562 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R10563 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R10564 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R10565 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R10566 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R10567 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R10568 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R10569 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R10570 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R10571 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R10572 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R10573 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R10574 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R10575 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R10576 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R10577 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R10578 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R10579 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R10580 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R10581 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R10582 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R10583 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R10584 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R10585 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R10586 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R10587 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R10588 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R10589 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R10590 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R10591 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R10592 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R10593 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R10594 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R10595 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R10596 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R10597 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R10598 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R10599 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R10600 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R10601 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R10602 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R10603 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R10604 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R10605 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R10606 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R10607 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R10608 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R10609 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R10610 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R10611 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R10612 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R10613 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R10614 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R10615 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R10616 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R10617 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R10618 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R10619 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R10620 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R10621 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R10622 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R10623 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R10624 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R10625 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R10626 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R10627 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R10628 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R10629 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R10630 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R10631 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R10632 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R10633 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R10634 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R10635 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R10636 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R10637 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R10638 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R10639 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R10640 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R10641 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R10642 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R10643 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R10644 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R10645 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R10646 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R10647 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R10648 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R10649 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R10650 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R10651 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R10652 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R10653 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R10654 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R10655 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R10656 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R10657 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R10658 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R10659 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R10660 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R10661 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R10662 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R10663 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R10664 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R10665 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R10666 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R10667 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R10668 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R10669 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R10670 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R10671 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R10672 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R10673 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R10674 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R10675 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R10676 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R10677 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R10678 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R10679 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
V0 n1_m9_160800_160800 0 1.100000
V1 n1_m9_340000_160800 0 1.100000
V2 n1_m9_160800_340000 0 1.100000
V3 n1_m9_340000_340000 0 1.100000
R10680 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R10681 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R10682 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R10683 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R10684 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R10685 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R10686 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R10687 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R10688 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R10689 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R10690 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R10691 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R10692 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R10693 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R10694 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R10695 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R10696 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R10697 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R10698 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R10699 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R10700 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R10701 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R10702 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R10703 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R10704 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R10705 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R10706 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R10707 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R10708 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R10709 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R10710 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R10711 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R10712 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R10713 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R10714 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R10715 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R10716 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R10717 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R10718 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R10719 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R10720 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R10721 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R10722 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R10723 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R10724 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R10725 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R10726 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R10727 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R10728 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R10729 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R10730 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R10731 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R10732 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R10733 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R10734 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R10735 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R10736 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R10737 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R10738 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R10739 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R10740 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R10741 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R10742 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R10743 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R10744 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R10745 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R10746 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R10747 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R10748 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R10749 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R10750 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R10751 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R10752 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R10753 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R10754 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R10755 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R10756 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R10757 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R10758 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R10759 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R10760 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R10761 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R10762 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R10763 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R10764 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R10765 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R10766 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R10767 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R10768 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R10769 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R10770 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R10771 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R10772 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R10773 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R10774 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R10775 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R10776 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R10777 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R10778 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R10779 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R10780 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R10781 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R10782 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R10783 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R10784 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R10785 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R10786 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R10787 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R10788 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R10789 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R10790 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R10791 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R10792 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R10793 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R10794 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R10795 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R10796 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R10797 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R10798 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R10799 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R10800 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R10801 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R10802 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R10803 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R10804 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R10805 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R10806 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R10807 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R10808 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R10809 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R10810 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R10811 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R10812 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R10813 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R10814 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R10815 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R10816 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R10817 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R10818 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R10819 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R10820 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R10821 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R10822 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R10823 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R10824 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R10825 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R10826 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R10827 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R10828 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R10829 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R10830 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R10831 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R10832 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R10833 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R10834 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R10835 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R10836 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R10837 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R10838 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R10839 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R10840 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R10841 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R10842 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R10843 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R10844 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R10845 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R10846 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R10847 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R10848 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R10849 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R10850 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R10851 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R10852 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R10853 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R10854 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R10855 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
R10856 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R10857 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R10858 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R10859 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
I0 n1_m1_9600_24000 0 7.866667e-08
I1 n1_m1_9600_28800 0 8.812500e-07
I2 n1_m1_9600_33600 0 6.376635e-07
I3 n1_m1_9600_38400 0 2.144615e-07
I4 n1_m1_9600_43200 0 5.630769e-08
I5 n1_m1_9600_48000 0 6.949687e-07
I6 n1_m1_9600_52800 0 4.385670e-07
I7 n1_m1_9600_57600 0 8.109446e-07
I8 n1_m1_9600_62400 0 7.095625e-07
I9 n1_m1_9600_67200 0 2.631429e-07
I10 n1_m1_9600_72000 0 2.973173e-07
I11 n1_m1_9600_76800 0 5.176559e-07
I12 n1_m1_9600_81600 0 9.821205e-07
I13 n1_m1_9600_86400 0 2.702337e-07
I14 n1_m1_9600_91200 0 8.813101e-07
I15 n1_m1_9600_96000 0 8.799866e-07
I16 n1_m1_9600_100800 0 6.786964e-07
I17 n1_m1_9600_105600 0 1.248936e-06
I18 n1_m1_9600_110400 0 9.459375e-07
I19 n1_m1_9600_115200 0 5.863893e-07
I20 n1_m1_9600_120000 0 9.316643e-07
I21 n1_m1_9600_124800 0 6.521250e-07
I22 n1_m1_9600_129600 0 7.705393e-07
I23 n1_m1_9600_134400 0 9.433701e-07
I24 n1_m1_9600_139200 0 5.937987e-07
I25 n1_m1_9600_144000 0 8.423595e-07
I26 n1_m1_9600_148800 0 6.723080e-07
I27 n1_m1_9600_153600 0 7.727545e-07
I28 n1_m1_9600_158400 0 8.188554e-07
I29 n1_m1_9600_163200 0 2.874511e-07
I30 n1_m1_9600_168000 0 8.037512e-07
I31 n1_m1_9600_172800 0 6.233181e-07
I32 n1_m1_9600_177600 0 1.125781e-06
I33 n1_m1_9600_182400 0 7.133474e-07
I34 n1_m1_9600_187200 0 3.453826e-07
I35 n1_m1_9600_192000 0 8.164900e-07
I36 n1_m1_9600_196800 0 7.283259e-07
I37 n1_m1_9600_201600 0 1.095042e-06
I38 n1_m1_9600_206400 0 5.057991e-07
I39 n1_m1_9600_211200 0 4.633125e-07
I40 n1_m1_9600_216000 0 1.015478e-06
I41 n1_m1_9600_220800 0 4.714286e-07
I42 n1_m1_9600_225600 0 8.975000e-07
I43 n1_m1_9600_230400 0 8.386875e-07
I44 n1_m1_9600_235200 0 7.925312e-07
I45 n1_m1_9600_240000 0 5.163973e-07
I46 n1_m1_9600_244800 0 6.815268e-07
I47 n1_m1_9600_249600 0 8.982545e-07
I48 n1_m1_9600_254400 0 5.515357e-07
I49 n1_m1_9600_259200 0 9.107143e-07
I50 n1_m1_9600_264000 0 9.246027e-07
I51 n1_m1_9600_268800 0 6.679391e-07
I52 n1_m1_9600_273600 0 1.006648e-06
I53 n1_m1_9600_278400 0 3.873333e-07
I54 n1_m1_9600_283200 0 7.748393e-07
I55 n1_m1_9600_288000 0 8.712946e-07
I56 n1_m1_9600_292800 0 7.206161e-07
I57 n1_m1_9600_297600 0 6.814250e-07
I58 n1_m1_9600_302400 0 4.975982e-07
I59 n1_m1_9600_307200 0 9.090402e-07
I60 n1_m1_9600_312000 0 8.217976e-07
I61 n1_m1_9600_316800 0 8.283214e-07
I62 n1_m1_9600_321600 0 7.622857e-07
I63 n1_m1_9600_326400 0 3.868312e-07
I64 n1_m1_9600_331200 0 8.780567e-07
I65 n1_m1_9600_336000 0 9.833393e-07
I66 n1_m1_9600_340800 0 1.047864e-06
I67 n1_m1_9600_345600 0 1.023661e-06
I68 n1_m1_9600_350400 0 5.228179e-07
I69 n1_m1_9600_355200 0 6.248714e-07
I70 n1_m1_9600_360000 0 4.390857e-07
I71 n1_m1_9600_364800 0 8.714107e-07
I72 n1_m1_9600_369600 0 4.628571e-07
I73 n1_m1_9600_374400 0 8.967321e-07
I74 n1_m1_9600_379200 0 3.025955e-07
I75 n1_m1_9600_384000 0 3.094607e-07
I76 n1_m1_14400_19200 0 6.533036e-08
I77 n1_m1_14400_24000 0 4.087967e-07
I78 n1_m1_14400_28800 0 3.707480e-07
I79 n1_m1_14400_33600 0 3.656672e-07
I80 n1_m1_14400_38400 0 3.246061e-07
I81 n1_m1_14400_43200 0 2.877795e-07
I82 n1_m1_14400_48000 0 6.770930e-07
I83 n1_m1_14400_52800 0 1.633122e-07
I84 n1_m1_14400_57600 0 3.714696e-07
I85 n1_m1_14400_62400 0 6.943768e-07
I86 n1_m1_14400_67200 0 4.268973e-07
I87 n1_m1_14400_72000 0 2.123269e-07
I88 n1_m1_14400_76800 0 6.083159e-07
I89 n1_m1_14400_81600 0 4.634509e-07
I90 n1_m1_14400_86400 0 3.788462e-07
I91 n1_m1_14400_91200 0 4.545288e-07
I92 n1_m1_14400_96000 0 3.789241e-07
I93 n1_m1_14400_100800 0 3.493581e-07
I94 n1_m1_14400_105600 0 6.391201e-07
I95 n1_m1_14400_110400 0 4.034781e-07
I96 n1_m1_14400_115200 0 4.101055e-07
I97 n1_m1_14400_120000 0 9.330390e-07
I98 n1_m1_14400_124800 0 4.148929e-07
I99 n1_m1_14400_129600 0 5.985464e-07
I100 n1_m1_14400_134400 0 7.777121e-07
I101 n1_m1_14400_139200 0 6.878788e-07
I102 n1_m1_14400_144000 0 7.186578e-07
I103 n1_m1_14400_148800 0 4.887231e-07
I104 n1_m1_14400_153600 0 8.059330e-07
I105 n1_m1_14400_158400 0 5.427589e-07
I106 n1_m1_14400_163200 0 2.878631e-07
I107 n1_m1_14400_168000 0 7.624428e-07
I108 n1_m1_14400_172800 0 6.610050e-07
I109 n1_m1_14400_177600 0 5.516080e-07
I110 n1_m1_14400_182400 0 5.568677e-07
I111 n1_m1_14400_187200 0 5.328685e-07
I112 n1_m1_14400_192000 0 4.721707e-07
I113 n1_m1_14400_196800 0 5.187455e-07
I114 n1_m1_14400_201600 0 6.591012e-07
I115 n1_m1_14400_206400 0 6.268616e-07
I116 n1_m1_14400_211200 0 3.592589e-07
I117 n1_m1_14400_216000 0 5.196527e-07
I118 n1_m1_14400_220800 0 1.787071e-07
I119 n1_m1_14400_225600 0 8.489739e-07
I120 n1_m1_14400_230400 0 3.782982e-07
I121 n1_m1_14400_235200 0 4.144120e-07
I122 n1_m1_14400_240000 0 4.137388e-07
I123 n1_m1_14400_244800 0 4.589821e-07
I124 n1_m1_14400_249600 0 6.449269e-07
I125 n1_m1_14400_254400 0 4.195082e-07
I126 n1_m1_14400_259200 0 4.207857e-07
I127 n1_m1_14400_264000 0 4.666897e-07
I128 n1_m1_14400_268800 0 6.014388e-07
I129 n1_m1_14400_273600 0 5.505901e-07
I130 n1_m1_14400_278400 0 2.743810e-07
I131 n1_m1_14400_283200 0 4.757795e-07
I132 n1_m1_14400_288000 0 5.419411e-07
I133 n1_m1_14400_292800 0 4.747411e-07
I134 n1_m1_14400_297600 0 4.320607e-07
I135 n1_m1_14400_302400 0 6.206411e-07
I136 n1_m1_14400_307200 0 3.736639e-07
I137 n1_m1_14400_312000 0 2.993798e-07
I138 n1_m1_14400_316800 0 4.826739e-07
I139 n1_m1_14400_321600 0 3.247807e-07
I140 n1_m1_14400_326400 0 4.763909e-07
I141 n1_m1_14400_331200 0 3.826896e-07
I142 n1_m1_14400_336000 0 9.374269e-07
I143 n1_m1_14400_340800 0 7.432500e-07
I144 n1_m1_14400_345600 0 7.370647e-07
I145 n1_m1_14400_350400 0 4.318529e-07
I146 n1_m1_14400_355200 0 3.481753e-07
I147 n1_m1_14400_360000 0 2.328494e-07
I148 n1_m1_14400_364800 0 3.571260e-07
I149 n1_m1_14400_369600 0 4.671247e-07
I150 n1_m1_14400_374400 0 4.400471e-07
I151 n1_m1_14400_379200 0 4.137045e-07
I152 n1_m1_14400_384000 0 2.841429e-07
I153 n1_m1_14400_388800 0 3.210268e-08
I154 n1_m1_14400_393600 0 2.233776e-07
I155 n1_m1_19200_9600 0 2.002500e-07
I156 n1_m1_19200_14400 0 3.870000e-08
I157 n1_m1_19200_19200 0 4.871357e-07
I158 n1_m1_19200_24000 0 7.860226e-07
I159 n1_m1_19200_28800 0 4.193332e-07
I160 n1_m1_19200_33600 0 7.360231e-07
I161 n1_m1_19200_38400 0 5.202786e-07
I162 n1_m1_19200_43200 0 5.771739e-07
I163 n1_m1_19200_48000 0 3.721123e-07
I164 n1_m1_19200_52800 0 2.156879e-07
I165 n1_m1_19200_57600 0 3.533286e-07
I166 n1_m1_19200_62400 0 6.640429e-07
I167 n1_m1_19200_67200 0 2.333036e-07
I168 n1_m1_19200_72000 0 3.729041e-07
I169 n1_m1_19200_76800 0 5.148416e-07
I170 n1_m1_19200_81600 0 7.013142e-07
I171 n1_m1_19200_86400 0 6.276723e-07
I172 n1_m1_19200_91200 0 5.349629e-07
I173 n1_m1_19200_96000 0 4.553805e-07
I174 n1_m1_19200_100800 0 2.252026e-07
I175 n1_m1_19200_105600 0 3.721156e-07
I176 n1_m1_19200_110400 0 3.902987e-07
I177 n1_m1_19200_115200 0 2.257100e-07
I178 n1_m1_19200_120000 0 4.753682e-07
I179 n1_m1_19200_124800 0 3.439821e-07
I180 n1_m1_19200_129600 0 1.184410e-06
I181 n1_m1_19200_134400 0 3.832749e-07
I182 n1_m1_19200_139200 0 2.071082e-07
I183 n1_m1_19200_144000 0 5.759177e-07
I184 n1_m1_19200_148800 0 2.709689e-07
I185 n1_m1_19200_153600 0 7.465982e-07
I186 n1_m1_19200_158400 0 3.705000e-07
I187 n1_m1_19200_163200 0 5.125238e-07
I188 n1_m1_19200_168000 0 4.268345e-07
I189 n1_m1_19200_172800 0 3.298591e-07
I190 n1_m1_19200_177600 0 7.612286e-07
I191 n1_m1_19200_182400 0 2.757420e-07
I192 n1_m1_19200_187200 0 4.806061e-07
I193 n1_m1_19200_192000 0 4.363393e-07
I194 n1_m1_19200_196800 0 6.292143e-07
I195 n1_m1_19200_201600 0 4.004286e-07
I196 n1_m1_19200_206400 0 2.982821e-07
I197 n1_m1_19200_211200 0 4.154286e-07
I198 n1_m1_19200_216000 0 7.836071e-07
I199 n1_m1_19200_220800 0 3.464643e-07
I200 n1_m1_19200_225600 0 5.427673e-07
I201 n1_m1_19200_230400 0 2.831476e-07
I202 n1_m1_19200_235200 0 1.368886e-07
I203 n1_m1_19200_240000 0 5.189432e-07
I204 n1_m1_19200_244800 0 7.255357e-07
I205 n1_m1_19200_249600 0 5.321044e-07
I206 n1_m1_19200_254400 0 6.525230e-07
I207 n1_m1_19200_259200 0 5.561875e-07
I208 n1_m1_19200_264000 0 7.385077e-07
I209 n1_m1_19200_268800 0 4.193792e-07
I210 n1_m1_19200_273600 0 7.155622e-07
I211 n1_m1_19200_278400 0 2.397857e-07
I212 n1_m1_19200_283200 0 6.072857e-07
I213 n1_m1_19200_288000 0 6.709821e-07
I214 n1_m1_19200_292800 0 4.357589e-07
I215 n1_m1_19200_297600 0 4.884143e-07
I216 n1_m1_19200_302400 0 4.257452e-07
I217 n1_m1_19200_307200 0 5.501307e-07
I218 n1_m1_19200_312000 0 3.888018e-07
I219 n1_m1_19200_316800 0 6.751209e-07
I220 n1_m1_19200_321600 0 4.869124e-07
I221 n1_m1_19200_326400 0 2.638636e-07
I222 n1_m1_19200_331200 0 3.782557e-07
I223 n1_m1_19200_336000 0 5.116234e-07
I224 n1_m1_19200_340800 0 1.621714e-07
I225 n1_m1_19200_345600 0 4.257175e-07
I226 n1_m1_19200_350400 0 3.602578e-07
I227 n1_m1_19200_355200 0 2.237104e-07
I228 n1_m1_19200_360000 0 5.498292e-07
I229 n1_m1_19200_364800 0 3.197919e-07
I230 n1_m1_19200_369600 0 3.567896e-07
I231 n1_m1_19200_374400 0 3.298208e-07
I232 n1_m1_19200_379200 0 2.430000e-07
I233 n1_m1_19200_384000 0 3.933571e-07
I234 n1_m1_19200_388800 0 2.640179e-07
I235 n1_m1_19200_393600 0 6.267315e-07
I236 n1_m1_24000_4800 0 1.140000e-07
I237 n1_m1_24000_9600 0 1.259394e-06
I238 n1_m1_24000_14400 0 2.778857e-07
I239 n1_m1_24000_19200 0 4.224875e-07
I240 n1_m1_24000_24000 0 3.530333e-06
I241 n1_m1_24000_28800 0 6.203831e-07
I242 n1_m1_24000_33600 0 6.513243e-07
I243 n1_m1_24000_38400 0 2.316803e-07
I244 n1_m1_24000_43200 0 5.784549e-07
I245 n1_m1_24000_48000 0 5.497386e-07
I246 n1_m1_24000_52800 0 7.038098e-07
I247 n1_m1_24000_57600 0 6.830266e-07
I248 n1_m1_24000_62400 0 6.861888e-07
I249 n1_m1_24000_67200 0 6.190536e-07
I250 n1_m1_24000_72000 0 2.519815e-07
I251 n1_m1_24000_76800 0 7.694555e-07
I252 n1_m1_24000_81600 0 8.377974e-07
I253 n1_m1_24000_86400 0 3.140248e-07
I254 n1_m1_24000_91200 0 6.550292e-07
I255 n1_m1_24000_96000 0 5.366198e-07
I256 n1_m1_24000_100800 0 4.998357e-07
I257 n1_m1_24000_105600 0 6.795143e-07
I258 n1_m1_24000_110400 0 3.862143e-07
I259 n1_m1_24000_115200 0 7.788069e-07
I260 n1_m1_24000_120000 0 2.117857e-07
I261 n1_m1_24000_124800 0 2.280714e-07
I262 n1_m1_24000_129600 0 9.510762e-07
I263 n1_m1_24000_134400 0 4.477857e-07
I264 n1_m1_24000_139200 0 9.111147e-07
I265 n1_m1_24000_144000 0 8.637394e-07
I266 n1_m1_24000_148800 0 4.876214e-07
I267 n1_m1_24000_153600 0 1.041554e-06
I268 n1_m1_24000_158400 0 8.983571e-07
I269 n1_m1_24000_163200 0 7.671472e-07
I270 n1_m1_24000_168000 0 1.182487e-06
I271 n1_m1_24000_172800 0 7.862464e-07
I272 n1_m1_24000_177600 0 1.437266e-06
I273 n1_m1_24000_182400 0 7.554759e-07
I274 n1_m1_24000_187200 0 6.290508e-07
I275 n1_m1_24000_192000 0 1.024560e-06
I276 n1_m1_24000_196800 0 7.900738e-07
I277 n1_m1_24000_201600 0 6.337115e-07
I278 n1_m1_24000_206400 0 7.230848e-07
I279 n1_m1_24000_211200 0 4.041429e-07
I280 n1_m1_24000_216000 0 9.806875e-07
I281 n1_m1_24000_220800 0 6.870759e-07
I282 n1_m1_24000_225600 0 1.304649e-06
I283 n1_m1_24000_230400 0 6.600009e-07
I284 n1_m1_24000_235200 0 5.245116e-07
I285 n1_m1_24000_240000 0 2.133261e-06
I286 n1_m1_24000_244800 0 6.444541e-07
I287 n1_m1_24000_249600 0 1.253393e-06
I288 n1_m1_24000_254400 0 7.295841e-07
I289 n1_m1_24000_259200 0 4.897901e-07
I290 n1_m1_24000_264000 0 1.227932e-06
I291 n1_m1_24000_268800 0 4.660714e-07
I292 n1_m1_24000_273600 0 1.143561e-06
I293 n1_m1_24000_278400 0 7.028571e-07
I294 n1_m1_24000_283200 0 5.677812e-07
I295 n1_m1_24000_288000 0 9.460893e-07
I296 n1_m1_24000_292800 0 8.828125e-07
I297 n1_m1_24000_297600 0 2.269807e-06
I298 n1_m1_24000_302400 0 6.777271e-07
I299 n1_m1_24000_307200 0 6.782270e-07
I300 n1_m1_24000_312000 0 2.881009e-07
I301 n1_m1_24000_316800 0 4.520817e-07
I302 n1_m1_24000_321600 0 7.865766e-07
I303 n1_m1_24000_326400 0 4.460000e-07
I304 n1_m1_24000_331200 0 3.718573e-07
I305 n1_m1_24000_336000 0 9.277293e-07
I306 n1_m1_24000_340800 0 9.391429e-07
I307 n1_m1_24000_345600 0 3.311359e-07
I308 n1_m1_24000_350400 0 5.097589e-07
I309 n1_m1_24000_355200 0 3.568926e-07
I310 n1_m1_24000_360000 0 1.310148e-07
I311 n1_m1_24000_364800 0 5.959848e-07
I312 n1_m1_24000_369600 0 2.963429e-07
I313 n1_m1_24000_374400 0 2.047143e-07
I314 n1_m1_24000_379200 0 5.399732e-07
I315 n1_m1_24000_384000 0 4.687212e-07
I316 n1_m1_24000_388800 0 8.865080e-07
I317 n1_m1_24000_393600 0 9.732255e-07
I318 n1_m1_24000_398400 0 1.045714e-07
I319 n1_m1_28800_4800 0 3.590769e-08
I320 n1_m1_28800_9600 0 3.412484e-07
I321 n1_m1_28800_14400 0 3.396429e-07
I322 n1_m1_28800_19200 0 4.815357e-07
I323 n1_m1_28800_24000 0 2.138413e-06
I324 n1_m1_28800_28800 0 4.598306e-07
I325 n1_m1_28800_33600 0 1.095177e-07
I326 n1_m1_28800_38400 0 5.262981e-07
I327 n1_m1_28800_43200 0 4.788734e-07
I328 n1_m1_28800_48000 0 2.869178e-07
I329 n1_m1_28800_52800 0 5.396179e-07
I330 n1_m1_28800_57600 0 4.980774e-06
I331 n1_m1_28800_62400 0 3.647041e-07
I332 n1_m1_28800_67200 0 5.843304e-07
I333 n1_m1_28800_72000 0 3.170266e-07
I334 n1_m1_28800_76800 0 3.395223e-07
I335 n1_m1_28800_81600 0 4.493170e-07
I336 n1_m1_28800_86400 0 1.565723e-07
I337 n1_m1_28800_91200 0 5.834876e-07
I338 n1_m1_28800_96000 0 3.633747e-07
I339 n1_m1_28800_100800 0 5.958571e-07
I340 n1_m1_28800_105600 0 5.365714e-07
I341 n1_m1_28800_110400 0 6.135714e-08
I342 n1_m1_28800_115200 0 5.244766e-07
I343 n1_m1_28800_120000 0 1.328905e-07
I344 n1_m1_28800_124800 0 1.974405e-07
I345 n1_m1_28800_129600 0 7.001357e-07
I346 n1_m1_28800_134400 0 1.068857e-07
I347 n1_m1_28800_139200 0 4.375541e-07
I348 n1_m1_28800_144000 0 3.248431e-07
I349 n1_m1_28800_148800 0 1.624859e-07
I350 n1_m1_28800_153600 0 8.080802e-06
I351 n1_m1_28800_158400 0 4.430690e-07
I352 n1_m1_28800_163200 0 6.281986e-07
I353 n1_m1_28800_168000 0 1.338555e-06
I354 n1_m1_28800_172800 0 2.930719e-07
I355 n1_m1_28800_177600 0 5.904604e-07
I356 n1_m1_28800_182400 0 5.704988e-07
I357 n1_m1_28800_187200 0 1.778468e-06
I358 n1_m1_28800_192000 0 9.104650e-07
I359 n1_m1_28800_196800 0 3.784427e-07
I360 n1_m1_28800_201600 0 2.231676e-07
I361 n1_m1_28800_206400 0 6.034018e-07
I362 n1_m1_28800_211200 0 1.810000e-07
I363 n1_m1_28800_216000 0 7.110244e-07
I364 n1_m1_28800_220800 0 6.697683e-07
I365 n1_m1_28800_225600 0 5.674722e-07
I366 n1_m1_28800_230400 0 4.404407e-07
I367 n1_m1_28800_235200 0 5.408644e-07
I368 n1_m1_28800_240000 0 6.992392e-06
I369 n1_m1_28800_244800 0 6.554935e-07
I370 n1_m1_28800_249600 0 5.947500e-07
I371 n1_m1_28800_254400 0 5.471418e-07
I372 n1_m1_28800_259200 0 4.702884e-07
I373 n1_m1_28800_264000 0 7.578522e-07
I374 n1_m1_28800_268800 0 4.548510e-07
I375 n1_m1_28800_273600 0 3.551839e-06
I376 n1_m1_28800_278400 0 5.984821e-07
I377 n1_m1_28800_283200 0 3.672390e-07
I378 n1_m1_28800_288000 0 4.973264e-07
I379 n1_m1_28800_292800 0 4.083022e-07
I380 n1_m1_28800_297600 0 2.503964e-07
I381 n1_m1_28800_302400 0 6.439482e-07
I382 n1_m1_28800_307200 0 4.254217e-07
I383 n1_m1_28800_312000 0 4.639407e-07
I384 n1_m1_28800_316800 0 5.853998e-07
I385 n1_m1_28800_321600 0 6.912266e-07
I386 n1_m1_28800_326400 0 6.356786e-07
I387 n1_m1_28800_331200 0 1.011621e-07
I388 n1_m1_28800_336000 0 5.515097e-07
I389 n1_m1_28800_340800 0 4.066571e-07
I390 n1_m1_28800_345600 0 6.768463e-07
I391 n1_m1_28800_350400 0 6.773839e-07
I392 n1_m1_28800_355200 0 9.786360e-07
I393 n1_m1_28800_360000 0 1.182637e-07
I394 n1_m1_28800_364800 0 6.922321e-07
I395 n1_m1_28800_369600 0 3.727214e-07
I396 n1_m1_28800_374400 0 5.588571e-08
I397 n1_m1_28800_379200 0 5.677411e-07
I398 n1_m1_28800_384000 0 3.231298e-07
I399 n1_m1_28800_388800 0 1.240000e-07
I400 n1_m1_28800_393600 0 3.414939e-07
I401 n1_m1_33600_14400 0 3.336459e-07
I402 n1_m1_33600_19200 0 1.905969e-07
I403 n1_m1_33600_24000 0 4.595857e-07
I404 n1_m1_33600_28800 0 6.810062e-07
I405 n1_m1_33600_33600 0 8.777740e-07
I406 n1_m1_33600_38400 0 5.628472e-07
I407 n1_m1_33600_43200 0 5.804386e-07
I408 n1_m1_33600_48000 0 4.098795e-07
I409 n1_m1_33600_52800 0 5.277829e-07
I410 n1_m1_33600_57600 0 5.916518e-07
I411 n1_m1_33600_62400 0 4.623929e-07
I412 n1_m1_33600_67200 0 6.524440e-07
I413 n1_m1_33600_72000 0 1.728055e-06
I414 n1_m1_33600_76800 0 6.945879e-07
I415 n1_m1_33600_81600 0 6.355166e-06
I416 n1_m1_33600_86400 0 2.770069e-06
I417 n1_m1_33600_91200 0 4.819464e-07
I418 n1_m1_33600_96000 0 9.839364e-07
I419 n1_m1_33600_100800 0 6.573270e-07
I420 n1_m1_33600_105600 0 5.219520e-07
I421 n1_m1_33600_110400 0 2.920000e-07
I422 n1_m1_33600_115200 0 6.662942e-07
I423 n1_m1_33600_120000 0 4.603780e-07
I424 n1_m1_33600_124800 0 2.412816e-07
I425 n1_m1_33600_129600 0 4.460061e-07
I426 n1_m1_33600_134400 0 2.912241e-07
I427 n1_m1_33600_139200 0 6.128815e-07
I428 n1_m1_33600_144000 0 1.313301e-06
I429 n1_m1_33600_148800 0 6.113356e-07
I430 n1_m1_33600_153600 0 4.657071e-07
I431 n1_m1_33600_158400 0 1.105947e-07
I432 n1_m1_33600_163200 0 4.573394e-07
I433 n1_m1_33600_168000 0 5.672514e-07
I434 n1_m1_33600_172800 0 4.792727e-07
I435 n1_m1_33600_177600 0 4.449656e-07
I436 n1_m1_33600_182400 0 8.149936e-07
I437 n1_m1_33600_187200 0 9.539482e-07
I438 n1_m1_33600_192000 0 3.812231e-07
I439 n1_m1_33600_196800 0 7.208036e-07
I440 n1_m1_33600_201600 0 4.698857e-07
I441 n1_m1_33600_206400 0 1.905440e-07
I442 n1_m1_33600_211200 0 5.351091e-07
I443 n1_m1_33600_216000 0 4.920220e-07
I444 n1_m1_33600_220800 0 3.670325e-07
I445 n1_m1_33600_225600 0 6.510802e-07
I446 n1_m1_33600_230400 0 3.204770e-07
I447 n1_m1_33600_235200 0 5.391218e-07
I448 n1_m1_33600_240000 0 4.609099e-07
I449 n1_m1_33600_244800 0 6.330000e-07
I450 n1_m1_33600_249600 0 8.770962e-07
I451 n1_m1_33600_254400 0 3.700875e-07
I452 n1_m1_33600_259200 0 4.134497e-07
I453 n1_m1_33600_264000 0 7.592954e-07
I454 n1_m1_33600_268800 0 3.931320e-07
I455 n1_m1_33600_273600 0 7.283576e-07
I456 n1_m1_33600_278400 0 7.335357e-07
I457 n1_m1_33600_283200 0 4.908845e-07
I458 n1_m1_33600_288000 0 2.338837e-07
I459 n1_m1_33600_292800 0 5.107120e-07
I460 n1_m1_33600_297600 0 2.929534e-07
I461 n1_m1_33600_302400 0 5.234140e-07
I462 n1_m1_33600_307200 0 3.837413e-07
I463 n1_m1_33600_312000 0 3.037686e-07
I464 n1_m1_33600_316800 0 4.024093e-07
I465 n1_m1_33600_321600 0 3.138029e-07
I466 n1_m1_33600_326400 0 1.185286e-07
I467 n1_m1_33600_331200 0 2.722560e-07
I468 n1_m1_33600_336000 0 2.673255e-07
I469 n1_m1_33600_340800 0 3.980178e-07
I470 n1_m1_33600_345600 0 2.839125e-06
I471 n1_m1_33600_350400 0 4.427226e-07
I472 n1_m1_33600_355200 0 6.764675e-07
I473 n1_m1_33600_360000 0 3.239124e-07
I474 n1_m1_33600_364800 0 4.429974e-07
I475 n1_m1_33600_369600 0 8.200780e-07
I476 n1_m1_33600_374400 0 1.807114e-07
I477 n1_m1_33600_379200 0 3.064250e-07
I478 n1_m1_33600_384000 0 8.501669e-07
I479 n1_m1_33600_388800 0 7.222747e-08
I480 n1_m1_33600_393600 0 5.364808e-07
I481 n1_m1_33600_398400 0 9.600000e-08
I482 n1_m1_38400_14400 0 2.900740e-07
I483 n1_m1_38400_19200 0 6.765011e-07
I484 n1_m1_38400_24000 0 3.040805e-07
I485 n1_m1_38400_28800 0 3.804336e-07
I486 n1_m1_38400_33600 0 2.533794e-07
I487 n1_m1_38400_38400 0 2.352572e-07
I488 n1_m1_38400_43200 0 2.380901e-07
I489 n1_m1_38400_48000 0 4.379246e-07
I490 n1_m1_38400_52800 0 5.316367e-07
I491 n1_m1_38400_57600 0 4.879836e-07
I492 n1_m1_38400_62400 0 2.725852e-07
I493 n1_m1_38400_67200 0 5.218857e-07
I494 n1_m1_38400_72000 0 2.667610e-07
I495 n1_m1_38400_76800 0 3.884734e-07
I496 n1_m1_38400_81600 0 1.015628e-06
I497 n1_m1_38400_86400 0 3.941147e-07
I498 n1_m1_38400_91200 0 2.949433e-07
I499 n1_m1_38400_96000 0 3.109645e-07
I500 n1_m1_38400_100800 0 6.282659e-07
I501 n1_m1_38400_105600 0 5.259700e-07
I502 n1_m1_38400_110400 0 3.228571e-08
I503 n1_m1_38400_115200 0 2.286571e-07
I504 n1_m1_38400_120000 0 4.404743e-07
I505 n1_m1_38400_124800 0 3.422457e-07
I506 n1_m1_38400_129600 0 3.384526e-07
I507 n1_m1_38400_134400 0 5.973636e-07
I508 n1_m1_38400_139200 0 4.169286e-07
I509 n1_m1_38400_144000 0 5.423541e-07
I510 n1_m1_38400_148800 0 3.742509e-07
I511 n1_m1_38400_153600 0 3.964177e-07
I512 n1_m1_38400_158400 0 3.708747e-07
I513 n1_m1_38400_163200 0 6.463575e-07
I514 n1_m1_38400_168000 0 1.449536e-06
I515 n1_m1_38400_172800 0 2.356327e-07
I516 n1_m1_38400_177600 0 5.866271e-07
I517 n1_m1_38400_182400 0 3.351558e-07
I518 n1_m1_38400_187200 0 6.432035e-07
I519 n1_m1_38400_192000 0 2.280821e-07
I520 n1_m1_38400_196800 0 4.850548e-07
I521 n1_m1_38400_201600 0 4.036031e-07
I522 n1_m1_38400_206400 0 5.047071e-07
I523 n1_m1_38400_211200 0 4.437139e-07
I524 n1_m1_38400_216000 0 3.152667e-07
I525 n1_m1_38400_220800 0 2.923673e-07
I526 n1_m1_38400_225600 0 3.510938e-07
I527 n1_m1_38400_230400 0 2.817857e-07
I528 n1_m1_38400_235200 0 5.884330e-07
I529 n1_m1_38400_240000 0 3.174728e-07
I530 n1_m1_38400_244800 0 9.564714e-07
I531 n1_m1_38400_249600 0 9.659696e-07
I532 n1_m1_38400_254400 0 3.012854e-07
I533 n1_m1_38400_259200 0 4.313239e-07
I534 n1_m1_38400_264000 0 3.476700e-07
I535 n1_m1_38400_268800 0 5.932761e-07
I536 n1_m1_38400_273600 0 7.258292e-07
I537 n1_m1_38400_278400 0 3.387782e-07
I538 n1_m1_38400_283200 0 4.818437e-07
I539 n1_m1_38400_288000 0 1.464174e-06
I540 n1_m1_38400_292800 0 4.732511e-07
I541 n1_m1_38400_297600 0 3.027701e-07
I542 n1_m1_38400_302400 0 5.666378e-07
I543 n1_m1_38400_307200 0 9.619025e-07
I544 n1_m1_38400_312000 0 6.989511e-06
I545 n1_m1_38400_316800 0 1.698626e-06
I546 n1_m1_38400_321600 0 5.352827e-07
I547 n1_m1_38400_326400 0 1.200743e-06
I548 n1_m1_38400_331200 0 8.337036e-07
I549 n1_m1_38400_336000 0 8.945467e-07
I550 n1_m1_38400_340800 0 4.661618e-07
I551 n1_m1_38400_345600 0 8.111831e-07
I552 n1_m1_38400_350400 0 4.604881e-07
I553 n1_m1_38400_355200 0 5.436753e-07
I554 n1_m1_38400_360000 0 5.926120e-07
I555 n1_m1_38400_364800 0 1.558292e-07
I556 n1_m1_38400_369600 0 5.787782e-07
I557 n1_m1_38400_374400 0 7.868288e-06
I558 n1_m1_38400_379200 0 5.843829e-07
I559 n1_m1_38400_384000 0 2.711772e-07
I560 n1_m1_38400_388800 0 4.750000e-07
I561 n1_m1_38400_393600 0 5.460692e-07
I562 n1_m1_43200_14400 0 1.549974e-07
I563 n1_m1_43200_19200 0 4.965918e-07
I564 n1_m1_43200_24000 0 4.116016e-07
I565 n1_m1_43200_28800 0 6.669513e-07
I566 n1_m1_43200_33600 0 5.601658e-07
I567 n1_m1_43200_38400 0 7.298223e-07
I568 n1_m1_43200_43200 0 1.650220e-07
I569 n1_m1_43200_48000 0 6.768661e-07
I570 n1_m1_43200_52800 0 3.933984e-07
I571 n1_m1_43200_57600 0 4.701701e-07
I572 n1_m1_43200_62400 0 1.894863e-07
I573 n1_m1_43200_67200 0 1.033846e-07
I574 n1_m1_43200_72000 0 6.319105e-07
I575 n1_m1_43200_76800 0 3.931238e-07
I576 n1_m1_43200_81600 0 5.588464e-07
I577 n1_m1_43200_86400 0 1.501259e-07
I578 n1_m1_43200_91200 0 6.548407e-07
I579 n1_m1_43200_96000 0 7.020561e-07
I580 n1_m1_43200_100800 0 1.150374e-07
I581 n1_m1_43200_105600 0 6.727803e-07
I582 n1_m1_43200_110400 0 2.254176e-06
I583 n1_m1_43200_115200 0 1.061704e-06
I584 n1_m1_43200_120000 0 3.315395e-07
I585 n1_m1_43200_124800 0 5.920071e-07
I586 n1_m1_43200_129600 0 4.707238e-07
I587 n1_m1_43200_134400 0 4.642867e-07
I588 n1_m1_43200_139200 0 3.634592e-07
I589 n1_m1_43200_144000 0 2.826615e-07
I590 n1_m1_43200_148800 0 6.682555e-07
I591 n1_m1_43200_153600 0 1.168124e-06
I592 n1_m1_43200_158400 0 1.108571e-07
I593 n1_m1_43200_163200 0 2.329513e-07
I594 n1_m1_43200_168000 0 3.926098e-07
I595 n1_m1_43200_172800 0 1.194245e-07
I596 n1_m1_43200_177600 0 6.349132e-07
I597 n1_m1_43200_182400 0 2.309375e-07
I598 n1_m1_43200_187200 0 1.277775e-07
I599 n1_m1_43200_192000 0 8.714505e-08
I600 n1_m1_43200_196800 0 6.423431e-07
I601 n1_m1_43200_201600 0 3.810565e-07
I602 n1_m1_43200_206400 0 2.801250e-07
I603 n1_m1_43200_211200 0 8.282463e-07
I604 n1_m1_43200_216000 0 8.261661e-07
I605 n1_m1_43200_220800 0 2.641827e-07
I606 n1_m1_43200_225600 0 5.004158e-07
I607 n1_m1_43200_230400 0 2.317449e-07
I608 n1_m1_43200_235200 0 6.547500e-07
I609 n1_m1_43200_240000 0 3.695762e-07
I610 n1_m1_43200_244800 0 8.883408e-07
I611 n1_m1_43200_249600 0 8.025101e-07
I612 n1_m1_43200_254400 0 5.749896e-07
I613 n1_m1_43200_259200 0 4.073333e-07
I614 n1_m1_43200_264000 0 3.720135e-07
I615 n1_m1_43200_268800 0 1.206497e-06
I616 n1_m1_43200_273600 0 6.447543e-07
I617 n1_m1_43200_278400 0 4.736265e-07
I618 n1_m1_43200_283200 0 7.464623e-07
I619 n1_m1_43200_288000 0 1.156479e-06
I620 n1_m1_43200_292800 0 6.778490e-07
I621 n1_m1_43200_297600 0 4.573479e-07
I622 n1_m1_43200_302400 0 1.025179e-07
I623 n1_m1_43200_307200 0 3.523125e-07
I624 n1_m1_43200_312000 0 1.719643e-07
I625 n1_m1_43200_316800 0 4.155446e-07
I626 n1_m1_43200_321600 0 3.296989e-07
I627 n1_m1_43200_326400 0 1.021881e-06
I628 n1_m1_43200_331200 0 4.201041e-07
I629 n1_m1_43200_336000 0 5.120256e-07
I630 n1_m1_43200_340800 0 1.437229e-08
I631 n1_m1_43200_345600 0 8.669821e-07
I632 n1_m1_43200_350400 0 1.697768e-07
I633 n1_m1_43200_355200 0 2.300893e-07
I634 n1_m1_43200_360000 0 4.925714e-07
I635 n1_m1_43200_364800 0 3.481171e-07
I636 n1_m1_43200_369600 0 5.910472e-07
I637 n1_m1_43200_374400 0 5.952158e-07
I638 n1_m1_43200_379200 0 3.620805e-07
I639 n1_m1_43200_384000 0 2.096692e-07
I640 n1_m1_43200_388800 0 3.912714e-07
I641 n1_m1_43200_393600 0 7.289643e-07
I642 n1_m1_43200_398400 0 3.428571e-08
I643 n1_m1_48000_4800 0 3.001420e-07
I644 n1_m1_48000_9600 0 3.597618e-07
I645 n1_m1_48000_14400 0 3.068518e-07
I646 n1_m1_48000_19200 0 7.733768e-07
I647 n1_m1_48000_24000 0 3.578021e-07
I648 n1_m1_48000_28800 0 6.891295e-07
I649 n1_m1_48000_33600 0 3.168066e-07
I650 n1_m1_48000_38400 0 6.606297e-07
I651 n1_m1_48000_43200 0 2.664857e-07
I652 n1_m1_48000_48000 0 1.095394e-06
I653 n1_m1_48000_52800 0 4.943427e-07
I654 n1_m1_48000_57600 0 5.705326e-07
I655 n1_m1_48000_62400 0 1.057393e-06
I656 n1_m1_48000_67200 0 9.032946e-07
I657 n1_m1_48000_72000 0 6.697668e-07
I658 n1_m1_48000_76800 0 6.711533e-07
I659 n1_m1_48000_81600 0 7.820392e-07
I660 n1_m1_48000_86400 0 4.123000e-07
I661 n1_m1_48000_91200 0 6.639299e-07
I662 n1_m1_48000_96000 0 9.009394e-07
I663 n1_m1_48000_100800 0 2.348907e-07
I664 n1_m1_48000_105600 0 1.270570e-06
I665 n1_m1_48000_110400 0 3.174359e-07
I666 n1_m1_48000_115200 0 8.817326e-07
I667 n1_m1_48000_120000 0 4.968777e-07
I668 n1_m1_48000_124800 0 9.567411e-07
I669 n1_m1_48000_129600 0 6.266250e-07
I670 n1_m1_48000_134400 0 5.663476e-07
I671 n1_m1_48000_139200 0 9.944576e-07
I672 n1_m1_48000_144000 0 4.601023e-07
I673 n1_m1_48000_148800 0 4.471429e-07
I674 n1_m1_48000_153600 0 1.080989e-06
I675 n1_m1_48000_158400 0 1.425429e-07
I676 n1_m1_48000_163200 0 9.447961e-07
I677 n1_m1_48000_168000 0 8.382562e-07
I678 n1_m1_48000_172800 0 7.262411e-07
I679 n1_m1_48000_177600 0 5.508811e-07
I680 n1_m1_48000_182400 0 9.740625e-07
I681 n1_m1_48000_187200 0 6.543940e-07
I682 n1_m1_48000_192000 0 8.355623e-07
I683 n1_m1_48000_196800 0 1.220860e-06
I684 n1_m1_48000_201600 0 8.653105e-07
I685 n1_m1_48000_206400 0 1.858143e-07
I686 n1_m1_48000_211200 0 9.966989e-07
I687 n1_m1_48000_216000 0 8.241729e-07
I688 n1_m1_48000_220800 0 4.161577e-07
I689 n1_m1_48000_225600 0 2.979635e-06
I690 n1_m1_48000_230400 0 6.064694e-07
I691 n1_m1_48000_235200 0 4.874598e-07
I692 n1_m1_48000_240000 0 2.490935e-07
I693 n1_m1_48000_244800 0 1.024278e-06
I694 n1_m1_48000_249600 0 5.269147e-07
I695 n1_m1_48000_254400 0 6.482230e-07
I696 n1_m1_48000_259200 0 5.645023e-07
I697 n1_m1_48000_264000 0 3.080679e-07
I698 n1_m1_48000_268800 0 7.410848e-07
I699 n1_m1_48000_273600 0 1.190217e-06
I700 n1_m1_48000_278400 0 4.005506e-07
I701 n1_m1_48000_283200 0 3.304133e-07
I702 n1_m1_48000_288000 0 6.869245e-07
I703 n1_m1_48000_292800 0 2.921652e-07
I704 n1_m1_48000_297600 0 7.047991e-07
I705 n1_m1_48000_302400 0 8.145982e-07
I706 n1_m1_48000_307200 0 9.082589e-07
I707 n1_m1_48000_312000 0 3.196786e-07
I708 n1_m1_48000_316800 0 8.269982e-07
I709 n1_m1_48000_321600 0 8.167170e-07
I710 n1_m1_48000_326400 0 4.988452e-07
I711 n1_m1_48000_331200 0 6.018530e-07
I712 n1_m1_48000_336000 0 7.052070e-07
I713 n1_m1_48000_340800 0 1.018446e-06
I714 n1_m1_48000_345600 0 1.134879e-06
I715 n1_m1_48000_350400 0 4.623661e-07
I716 n1_m1_48000_355200 0 1.074482e-06
I717 n1_m1_48000_360000 0 4.749554e-07
I718 n1_m1_48000_364800 0 8.454809e-07
I719 n1_m1_48000_369600 0 7.082702e-07
I720 n1_m1_48000_374400 0 4.152249e-07
I721 n1_m1_48000_379200 0 7.715575e-07
I722 n1_m1_48000_384000 0 1.208219e-06
I723 n1_m1_48000_388800 0 3.968571e-07
I724 n1_m1_48000_393600 0 1.070987e-06
I725 n1_m1_48000_398400 0 2.828571e-07
I726 n1_m1_52800_4800 0 6.262722e-08
I727 n1_m1_52800_9600 0 4.944689e-07
I728 n1_m1_52800_14400 0 2.367857e-07
I729 n1_m1_52800_19200 0 3.943304e-07
I730 n1_m1_52800_24000 0 5.617643e-07
I731 n1_m1_52800_28800 0 4.598383e-07
I732 n1_m1_52800_33600 0 6.083516e-07
I733 n1_m1_52800_38400 0 7.030577e-07
I734 n1_m1_52800_43200 0 1.728769e-07
I735 n1_m1_52800_48000 0 4.595880e-07
I736 n1_m1_52800_52800 0 3.464237e-07
I737 n1_m1_52800_57600 0 1.557721e-07
I738 n1_m1_52800_62400 0 2.974286e-07
I739 n1_m1_52800_67200 0 7.203212e-07
I740 n1_m1_52800_72000 0 5.424952e-07
I741 n1_m1_52800_76800 0 4.627338e-07
I742 n1_m1_52800_81600 0 6.791135e-07
I743 n1_m1_52800_86400 0 5.372475e-07
I744 n1_m1_52800_91200 0 1.739473e-07
I745 n1_m1_52800_96000 0 8.669833e-07
I746 n1_m1_52800_100800 0 2.110892e-07
I747 n1_m1_52800_105600 0 9.494703e-07
I748 n1_m1_52800_110400 0 2.077930e-07
I749 n1_m1_52800_115200 0 6.264935e-08
I750 n1_m1_52800_120000 0 3.007643e-07
I751 n1_m1_52800_124800 0 3.627988e-06
I752 n1_m1_52800_129600 0 1.945897e-06
I753 n1_m1_52800_134400 0 6.400402e-07
I754 n1_m1_52800_139200 0 4.187567e-07
I755 n1_m1_52800_144000 0 4.181599e-07
I756 n1_m1_52800_148800 0 1.219018e-07
I757 n1_m1_52800_153600 0 7.315134e-07
I758 n1_m1_52800_158400 0 9.438393e-08
I759 n1_m1_52800_163200 0 1.808410e-07
I760 n1_m1_52800_168000 0 2.370386e-07
I761 n1_m1_52800_172800 0 5.307354e-07
I762 n1_m1_52800_177600 0 1.729977e-07
I763 n1_m1_52800_182400 0 3.715502e-07
I764 n1_m1_52800_187200 0 3.061096e-07
I765 n1_m1_52800_192000 0 4.757758e-07
I766 n1_m1_52800_196800 0 4.359812e-07
I767 n1_m1_52800_201600 0 4.365600e-07
I768 n1_m1_52800_206400 0 5.831429e-07
I769 n1_m1_52800_211200 0 1.175721e-06
I770 n1_m1_52800_216000 0 4.512857e-07
I771 n1_m1_52800_220800 0 2.028352e-07
I772 n1_m1_52800_225600 0 6.410186e-06
I773 n1_m1_52800_230400 0 6.975000e-07
I774 n1_m1_52800_235200 0 3.367143e-07
I775 n1_m1_52800_240000 0 3.525065e-07
I776 n1_m1_52800_244800 0 5.162495e-07
I777 n1_m1_52800_249600 0 3.095092e-07
I778 n1_m1_52800_254400 0 4.696497e-07
I779 n1_m1_52800_259200 0 3.854120e-07
I780 n1_m1_52800_264000 0 4.745969e-07
I781 n1_m1_52800_268800 0 6.337187e-07
I782 n1_m1_52800_273600 0 5.435173e-07
I783 n1_m1_52800_278400 0 4.574107e-07
I784 n1_m1_52800_283200 0 7.759984e-07
I785 n1_m1_52800_288000 0 1.018883e-06
I786 n1_m1_52800_292800 0 5.500000e-08
I787 n1_m1_52800_297600 0 5.021369e-07
I788 n1_m1_52800_302400 0 3.217855e-07
I789 n1_m1_52800_307200 0 2.450055e-07
I790 n1_m1_52800_312000 0 5.735444e-07
I791 n1_m1_52800_316800 0 3.352993e-07
I792 n1_m1_52800_321600 0 9.058631e-07
I793 n1_m1_52800_326400 0 8.135984e-07
I794 n1_m1_52800_331200 0 5.438036e-07
I795 n1_m1_52800_336000 0 4.475138e-07
I796 n1_m1_52800_340800 0 4.984029e-07
I797 n1_m1_52800_345600 0 5.071526e-07
I798 n1_m1_52800_350400 0 1.483112e-07
I799 n1_m1_52800_355200 0 5.183673e-07
I800 n1_m1_52800_360000 0 4.855690e-07
I801 n1_m1_52800_364800 0 6.347009e-07
I802 n1_m1_52800_369600 0 3.898929e-07
I803 n1_m1_52800_374400 0 3.096190e-08
I804 n1_m1_52800_379200 0 5.385065e-07
I805 n1_m1_52800_384000 0 5.061932e-07
I806 n1_m1_52800_388800 0 5.363839e-08
I807 n1_m1_52800_393600 0 3.359688e-07
I808 n1_m1_57600_4800 0 1.204260e-07
I809 n1_m1_57600_9600 0 3.118355e-07
I810 n1_m1_57600_14400 0 4.422500e-07
I811 n1_m1_57600_19200 0 3.107143e-07
I812 n1_m1_57600_24000 0 6.585051e-07
I813 n1_m1_57600_28800 0 5.998984e-07
I814 n1_m1_57600_33600 0 5.450055e-07
I815 n1_m1_57600_38400 0 5.683798e-07
I816 n1_m1_57600_43200 0 1.121800e-06
I817 n1_m1_57600_48000 0 7.410221e-07
I818 n1_m1_57600_52800 0 1.278442e-06
I819 n1_m1_57600_57600 0 1.769920e-07
I820 n1_m1_57600_62400 0 4.178701e-07
I821 n1_m1_57600_67200 0 8.043080e-07
I822 n1_m1_57600_72000 0 2.895096e-07
I823 n1_m1_57600_76800 0 2.375511e-07
I824 n1_m1_57600_81600 0 5.543487e-07
I825 n1_m1_57600_86400 0 2.195706e-07
I826 n1_m1_57600_91200 0 1.594560e-07
I827 n1_m1_57600_96000 0 6.271747e-07
I828 n1_m1_57600_100800 0 1.359817e-07
I829 n1_m1_57600_105600 0 6.355660e-07
I830 n1_m1_57600_110400 0 5.175271e-07
I831 n1_m1_57600_115200 0 2.564059e-07
I832 n1_m1_57600_120000 0 5.692298e-07
I833 n1_m1_57600_124800 0 3.011872e-06
I834 n1_m1_57600_129600 0 1.485332e-06
I835 n1_m1_57600_134400 0 3.512857e-08
I836 n1_m1_57600_139200 0 2.881122e-07
I837 n1_m1_57600_144000 0 3.798226e-07
I838 n1_m1_57600_148800 0 3.003531e-07
I839 n1_m1_57600_153600 0 7.307514e-07
I840 n1_m1_57600_158400 0 5.911071e-07
I841 n1_m1_57600_163200 0 6.590536e-07
I842 n1_m1_57600_168000 0 1.433061e-07
I843 n1_m1_57600_172800 0 2.358450e-07
I844 n1_m1_57600_177600 0 2.782225e-07
I845 n1_m1_57600_182400 0 7.859172e-07
I846 n1_m1_57600_187200 0 3.809725e-07
I847 n1_m1_57600_192000 0 4.518168e-07
I848 n1_m1_57600_196800 0 1.048733e-06
I849 n1_m1_57600_201600 0 8.244057e-07
I850 n1_m1_57600_206400 0 6.128214e-07
I851 n1_m1_57600_211200 0 6.400730e-07
I852 n1_m1_57600_216000 0 4.195286e-07
I853 n1_m1_57600_220800 0 7.458929e-07
I854 n1_m1_57600_225600 0 6.155084e-07
I855 n1_m1_57600_230400 0 4.817571e-07
I856 n1_m1_57600_235200 0 3.768714e-07
I857 n1_m1_57600_240000 0 2.809554e-07
I858 n1_m1_57600_244800 0 6.291964e-07
I859 n1_m1_57600_249600 0 3.783125e-07
I860 n1_m1_57600_254400 0 2.888943e-07
I861 n1_m1_57600_259200 0 5.064899e-07
I862 n1_m1_57600_264000 0 3.223429e-07
I863 n1_m1_57600_268800 0 3.331404e-07
I864 n1_m1_57600_273600 0 5.550102e-07
I865 n1_m1_57600_278400 0 1.854911e-07
I866 n1_m1_57600_283200 0 4.906972e-07
I867 n1_m1_57600_288000 0 3.966442e-07
I868 n1_m1_57600_292800 0 1.671374e-07
I869 n1_m1_57600_297600 0 8.464042e-07
I870 n1_m1_57600_302400 0 3.709358e-07
I871 n1_m1_57600_307200 0 2.147836e-07
I872 n1_m1_57600_312000 0 9.279995e-07
I873 n1_m1_57600_316800 0 2.238482e-07
I874 n1_m1_57600_321600 0 4.024959e-07
I875 n1_m1_57600_326400 0 2.331612e-07
I876 n1_m1_57600_331200 0 2.023821e-07
I877 n1_m1_57600_336000 0 1.999661e-07
I878 n1_m1_57600_340800 0 5.551636e-07
I879 n1_m1_57600_345600 0 7.998571e-07
I880 n1_m1_57600_350400 0 2.672997e-07
I881 n1_m1_57600_355200 0 7.359520e-07
I882 n1_m1_57600_360000 0 5.972294e-07
I883 n1_m1_57600_364800 0 2.075179e-07
I884 n1_m1_57600_369600 0 3.762596e-07
I885 n1_m1_57600_374400 0 5.158164e-07
I886 n1_m1_57600_379200 0 8.295335e-08
I887 n1_m1_57600_384000 0 6.460558e-07
I888 n1_m1_57600_388800 0 3.225536e-07
I889 n1_m1_62400_4800 0 1.679053e-07
I890 n1_m1_62400_9600 0 4.492421e-07
I891 n1_m1_62400_14400 0 3.160196e-07
I892 n1_m1_62400_19200 0 3.453291e-07
I893 n1_m1_62400_24000 0 3.264718e-07
I894 n1_m1_62400_28800 0 4.699666e-07
I895 n1_m1_62400_33600 0 2.509534e-06
I896 n1_m1_62400_38400 0 7.173197e-07
I897 n1_m1_62400_43200 0 4.067974e-07
I898 n1_m1_62400_48000 0 9.093775e-07
I899 n1_m1_62400_52800 0 6.128571e-08
I900 n1_m1_62400_57600 0 1.134100e-06
I901 n1_m1_62400_62400 0 6.270046e-07
I902 n1_m1_62400_67200 0 3.787274e-07
I903 n1_m1_62400_72000 0 5.062404e-07
I904 n1_m1_62400_76800 0 4.028826e-07
I905 n1_m1_62400_81600 0 7.469733e-07
I906 n1_m1_62400_86400 0 3.362022e-07
I907 n1_m1_62400_91200 0 3.829418e-07
I908 n1_m1_62400_96000 0 9.155701e-07
I909 n1_m1_62400_100800 0 2.726387e-07
I910 n1_m1_62400_105600 0 9.238497e-07
I911 n1_m1_62400_110400 0 4.433837e-07
I912 n1_m1_62400_115200 0 2.559004e-07
I913 n1_m1_62400_120000 0 8.357893e-07
I914 n1_m1_62400_124800 0 3.735204e-07
I915 n1_m1_62400_129600 0 6.771964e-07
I916 n1_m1_62400_134400 0 7.012679e-07
I917 n1_m1_62400_139200 0 5.641964e-07
I918 n1_m1_62400_144000 0 3.762703e-07
I919 n1_m1_62400_148800 0 4.691955e-07
I920 n1_m1_62400_153600 0 1.420703e-07
I921 n1_m1_62400_158400 0 3.281018e-07
I922 n1_m1_62400_163200 0 6.057604e-07
I923 n1_m1_62400_168000 0 8.268095e-07
I924 n1_m1_62400_172800 0 8.718393e-07
I925 n1_m1_62400_177600 0 6.886106e-07
I926 n1_m1_62400_182400 0 2.321964e-07
I927 n1_m1_62400_187200 0 3.684242e-07
I928 n1_m1_62400_192000 0 4.366882e-07
I929 n1_m1_62400_196800 0 1.905357e-07
I930 n1_m1_62400_201600 0 8.845818e-07
I931 n1_m1_62400_206400 0 2.252643e-07
I932 n1_m1_62400_211200 0 1.152132e-06
I933 n1_m1_62400_216000 0 1.016014e-06
I934 n1_m1_62400_220800 0 2.418438e-07
I935 n1_m1_62400_225600 0 8.338417e-07
I936 n1_m1_62400_230400 0 3.175758e-07
I937 n1_m1_62400_235200 0 7.575758e-07
I938 n1_m1_62400_240000 0 6.983339e-07
I939 n1_m1_62400_244800 0 5.275357e-07
I940 n1_m1_62400_249600 0 1.294411e-07
I941 n1_m1_62400_254400 0 4.724140e-07
I942 n1_m1_62400_259200 0 4.586309e-07
I943 n1_m1_62400_264000 0 5.866186e-07
I944 n1_m1_62400_268800 0 3.088972e-07
I945 n1_m1_62400_273600 0 7.069571e-07
I946 n1_m1_62400_278400 0 2.553400e-06
I947 n1_m1_62400_283200 0 1.677553e-06
I948 n1_m1_62400_288000 0 6.179533e-07
I949 n1_m1_62400_292800 0 3.041243e-07
I950 n1_m1_62400_297600 0 6.242417e-07
I951 n1_m1_62400_302400 0 2.012158e-07
I952 n1_m1_62400_307200 0 2.500433e-07
I953 n1_m1_62400_312000 0 1.407636e-07
I954 n1_m1_62400_316800 0 6.412500e-07
I955 n1_m1_62400_321600 0 4.840481e-07
I956 n1_m1_62400_326400 0 4.414286e-07
I957 n1_m1_62400_331200 0 6.859464e-07
I958 n1_m1_62400_336000 0 3.221154e-07
I959 n1_m1_62400_340800 0 8.752941e-07
I960 n1_m1_62400_345600 0 7.655832e-07
I961 n1_m1_62400_350400 0 3.014688e-07
I962 n1_m1_62400_355200 0 3.229451e-07
I963 n1_m1_62400_360000 0 6.093033e-07
I964 n1_m1_62400_364800 0 5.909732e-07
I965 n1_m1_62400_369600 0 4.773803e-07
I966 n1_m1_62400_374400 0 4.496898e-07
I967 n1_m1_62400_379200 0 5.233821e-07
I968 n1_m1_62400_384000 0 6.789262e-07
I969 n1_m1_62400_388800 0 2.907136e-07
I970 n1_m1_62400_393600 0 6.147939e-07
I971 n1_m1_67200_4800 0 1.332308e-07
I972 n1_m1_67200_9600 0 1.891072e-07
I973 n1_m1_67200_14400 0 3.207091e-07
I974 n1_m1_67200_19200 0 3.006705e-07
I975 n1_m1_67200_24000 0 6.160159e-07
I976 n1_m1_67200_28800 0 5.127805e-07
I977 n1_m1_67200_33600 0 3.051016e-07
I978 n1_m1_67200_38400 0 4.366517e-07
I979 n1_m1_67200_43200 0 3.434603e-07
I980 n1_m1_67200_48000 0 6.716932e-07
I981 n1_m1_67200_52800 0 1.050214e-07
I982 n1_m1_67200_57600 0 4.745919e-07
I983 n1_m1_67200_62400 0 4.221980e-07
I984 n1_m1_67200_67200 0 3.069173e-07
I985 n1_m1_67200_72000 0 1.373250e-07
I986 n1_m1_67200_76800 0 1.716000e-07
I987 n1_m1_67200_81600 0 1.185231e-06
I988 n1_m1_67200_86400 0 5.012995e-07
I989 n1_m1_67200_91200 0 2.371172e-07
I990 n1_m1_67200_96000 0 8.825268e-07
I991 n1_m1_67200_100800 0 1.358229e-07
I992 n1_m1_67200_105600 0 9.359330e-07
I993 n1_m1_67200_110400 0 4.675624e-07
I994 n1_m1_67200_115200 0 3.193524e-07
I995 n1_m1_67200_120000 0 4.864655e-07
I996 n1_m1_67200_124800 0 2.250000e-07
I997 n1_m1_67200_129600 0 9.511250e-07
I998 n1_m1_67200_134400 0 2.963066e-07
I999 n1_m1_67200_139200 0 3.136030e-07
I1000 n1_m1_67200_144000 0 6.874714e-07
I1001 n1_m1_67200_148800 0 3.907143e-07
I1002 n1_m1_67200_153600 0 5.252406e-07
I1003 n1_m1_67200_158400 0 4.703571e-07
I1004 n1_m1_67200_163200 0 6.343984e-07
I1005 n1_m1_67200_168000 0 9.626374e-08
I1006 n1_m1_67200_172800 0 2.203500e-07
I1007 n1_m1_67200_177600 0 3.408462e-07
I1008 n1_m1_67200_182400 0 1.230325e-07
I1009 n1_m1_67200_187200 0 6.701645e-07
I1010 n1_m1_67200_192000 0 6.521591e-07
I1011 n1_m1_67200_196800 0 4.180476e-07
I1012 n1_m1_67200_201600 0 6.635473e-07
I1013 n1_m1_67200_206400 0 1.858571e-07
I1014 n1_m1_67200_211200 0 3.593377e-07
I1015 n1_m1_67200_216000 0 8.796645e-07
I1016 n1_m1_67200_220800 0 2.842857e-07
I1017 n1_m1_67200_225600 0 9.516893e-07
I1018 n1_m1_67200_230400 0 5.740736e-07
I1019 n1_m1_67200_235200 0 6.422639e-07
I1020 n1_m1_67200_240000 0 6.343616e-07
I1021 n1_m1_67200_244800 0 3.829500e-07
I1022 n1_m1_67200_249600 0 9.466078e-08
I1023 n1_m1_67200_254400 0 5.246198e-07
I1024 n1_m1_67200_259200 0 5.440536e-07
I1025 n1_m1_67200_264000 0 3.486546e-07
I1026 n1_m1_67200_268800 0 1.260723e-07
I1027 n1_m1_67200_273600 0 5.246948e-07
I1028 n1_m1_67200_278400 0 7.283196e-07
I1029 n1_m1_67200_283200 0 4.941874e-07
I1030 n1_m1_67200_288000 0 4.767527e-07
I1031 n1_m1_67200_292800 0 3.337328e-07
I1032 n1_m1_67200_297600 0 6.967246e-07
I1033 n1_m1_67200_302400 0 1.546494e-07
I1034 n1_m1_67200_307200 0 7.047619e-07
I1035 n1_m1_67200_312000 0 3.654554e-07
I1036 n1_m1_67200_316800 0 4.337000e-07
I1037 n1_m1_67200_321600 0 4.957736e-07
I1038 n1_m1_67200_326400 0 2.898571e-07
I1039 n1_m1_67200_331200 0 3.028529e-07
I1040 n1_m1_67200_336000 0 2.982036e-07
I1041 n1_m1_67200_340800 0 3.432857e-07
I1042 n1_m1_67200_345600 0 6.587991e-07
I1043 n1_m1_67200_350400 0 5.481250e-07
I1044 n1_m1_67200_355200 0 6.448352e-08
I1045 n1_m1_67200_360000 0 7.474348e-07
I1046 n1_m1_67200_364800 0 5.262911e-07
I1047 n1_m1_67200_369600 0 5.069254e-07
I1048 n1_m1_67200_374400 0 3.444116e-07
I1049 n1_m1_67200_379200 0 9.872857e-07
I1050 n1_m1_67200_384000 0 1.208900e-06
I1051 n1_m1_67200_388800 0 4.681786e-07
I1052 n1_m1_67200_393600 0 7.219719e-07
I1053 n1_m1_67200_398400 0 3.428571e-08
I1054 n1_m1_72000_4800 0 6.692308e-07
I1055 n1_m1_72000_9600 0 9.677646e-07
I1056 n1_m1_72000_14400 0 7.194927e-07
I1057 n1_m1_72000_19200 0 7.397974e-07
I1058 n1_m1_72000_24000 0 7.812576e-07
I1059 n1_m1_72000_28800 0 7.324514e-07
I1060 n1_m1_72000_33600 0 5.505533e-07
I1061 n1_m1_72000_38400 0 9.643579e-07
I1062 n1_m1_72000_43200 0 1.300000e-07
I1063 n1_m1_72000_48000 0 8.536696e-07
I1064 n1_m1_72000_52800 0 8.182089e-07
I1065 n1_m1_72000_57600 0 2.144093e-08
I1066 n1_m1_72000_62400 0 5.949625e-07
I1067 n1_m1_72000_67200 0 8.865127e-07
I1068 n1_m1_72000_72000 0 1.649596e-06
I1069 n1_m1_72000_76800 0 1.679824e-07
I1070 n1_m1_72000_81600 0 9.199618e-07
I1071 n1_m1_72000_86400 0 7.834476e-07
I1072 n1_m1_72000_91200 0 2.254591e-06
I1073 n1_m1_72000_96000 0 3.438482e-06
I1074 n1_m1_72000_100800 0 8.426819e-07
I1075 n1_m1_72000_105600 0 5.609842e-07
I1076 n1_m1_72000_110400 0 6.674459e-06
I1077 n1_m1_72000_115200 0 3.326885e-06
I1078 n1_m1_72000_120000 0 1.237921e-06
I1079 n1_m1_72000_124800 0 2.469143e-07
I1080 n1_m1_72000_129600 0 8.841925e-07
I1081 n1_m1_72000_134400 0 1.012545e-06
I1082 n1_m1_72000_139200 0 2.372601e-07
I1083 n1_m1_72000_144000 0 1.065000e-06
I1084 n1_m1_72000_148800 0 6.375708e-07
I1085 n1_m1_72000_153600 0 1.250854e-06
I1086 n1_m1_72000_158400 0 2.418679e-07
I1087 n1_m1_72000_163200 0 6.090302e-07
I1088 n1_m1_72000_168000 0 1.279839e-06
I1089 n1_m1_72000_172800 0 4.137357e-07
I1090 n1_m1_72000_177600 0 1.552485e-06
I1091 n1_m1_72000_182400 0 6.150532e-07
I1092 n1_m1_72000_187200 0 7.875065e-07
I1093 n1_m1_72000_192000 0 7.119448e-07
I1094 n1_m1_72000_196800 0 9.184857e-07
I1095 n1_m1_72000_201600 0 1.181756e-06
I1096 n1_m1_72000_206400 0 1.069875e-06
I1097 n1_m1_72000_211200 0 5.228182e-07
I1098 n1_m1_72000_216000 0 7.459064e-07
I1099 n1_m1_72000_220800 0 1.074054e-06
I1100 n1_m1_72000_225600 0 4.672138e-07
I1101 n1_m1_72000_230400 0 7.236087e-07
I1102 n1_m1_72000_235200 0 6.301291e-07
I1103 n1_m1_72000_240000 0 6.098241e-07
I1104 n1_m1_72000_244800 0 5.160710e-07
I1105 n1_m1_72000_249600 0 1.356202e-06
I1106 n1_m1_72000_254400 0 5.262250e-07
I1107 n1_m1_72000_259200 0 4.518857e-07
I1108 n1_m1_72000_264000 0 1.314437e-06
I1109 n1_m1_72000_268800 0 4.590390e-07
I1110 n1_m1_72000_273600 0 1.334546e-06
I1111 n1_m1_72000_278400 0 6.876264e-06
I1112 n1_m1_72000_283200 0 3.555383e-06
I1113 n1_m1_72000_288000 0 8.417294e-07
I1114 n1_m1_72000_292800 0 3.617321e-07
I1115 n1_m1_72000_297600 0 8.239190e-07
I1116 n1_m1_72000_302400 0 1.614295e-07
I1117 n1_m1_72000_307200 0 8.386201e-07
I1118 n1_m1_72000_312000 0 5.131494e-07
I1119 n1_m1_72000_316800 0 6.931250e-07
I1120 n1_m1_72000_321600 0 6.614130e-07
I1121 n1_m1_72000_326400 0 2.572000e-07
I1122 n1_m1_72000_331200 0 7.898935e-07
I1123 n1_m1_72000_336000 0 7.213357e-07
I1124 n1_m1_72000_340800 0 9.308077e-07
I1125 n1_m1_72000_345600 0 4.923060e-07
I1126 n1_m1_72000_350400 0 9.171205e-07
I1127 n1_m1_72000_355200 0 5.506401e-07
I1128 n1_m1_72000_360000 0 3.714341e-07
I1129 n1_m1_72000_364800 0 9.064661e-07
I1130 n1_m1_72000_369600 0 7.048517e-07
I1131 n1_m1_72000_374400 0 6.632838e-07
I1132 n1_m1_72000_379200 0 3.801143e-07
I1133 n1_m1_72000_384000 0 4.084912e-07
I1134 n1_m1_72000_388800 0 7.749777e-07
I1135 n1_m1_72000_393600 0 7.977429e-07
I1136 n1_m1_72000_398400 0 1.298571e-07
I1137 n1_m1_76800_4800 0 2.278892e-07
I1138 n1_m1_76800_9600 0 3.907765e-07
I1139 n1_m1_76800_14400 0 3.266875e-07
I1140 n1_m1_76800_19200 0 6.340179e-08
I1141 n1_m1_76800_24000 0 3.442747e-07
I1142 n1_m1_76800_28800 0 4.969427e-07
I1143 n1_m1_76800_33600 0 6.228530e-07
I1144 n1_m1_76800_38400 0 3.276961e-07
I1145 n1_m1_76800_43200 0 2.133985e-07
I1146 n1_m1_76800_48000 0 9.530687e-07
I1147 n1_m1_76800_52800 0 6.730804e-07
I1148 n1_m1_76800_57600 0 2.624451e-07
I1149 n1_m1_76800_62400 0 2.873447e-07
I1150 n1_m1_76800_67200 0 5.317077e-07
I1151 n1_m1_76800_72000 0 3.203435e-07
I1152 n1_m1_76800_76800 0 3.990015e-07
I1153 n1_m1_76800_81600 0 1.098386e-06
I1154 n1_m1_76800_86400 0 3.913182e-07
I1155 n1_m1_76800_91200 0 2.576459e-06
I1156 n1_m1_76800_96000 0 3.160159e-06
I1157 n1_m1_76800_100800 0 9.027115e-07
I1158 n1_m1_76800_105600 0 3.839935e-07
I1159 n1_m1_76800_110400 0 8.724705e-07
I1160 n1_m1_76800_115200 0 5.706527e-07
I1161 n1_m1_76800_120000 0 2.653423e-07
I1162 n1_m1_76800_124800 0 3.066571e-07
I1163 n1_m1_76800_129600 0 5.590607e-07
I1164 n1_m1_76800_134400 0 2.807921e-07
I1165 n1_m1_76800_139200 0 1.639558e-07
I1166 n1_m1_76800_144000 0 4.545857e-07
I1167 n1_m1_76800_148800 0 2.180935e-07
I1168 n1_m1_76800_153600 0 2.493766e-07
I1169 n1_m1_76800_158400 0 1.854857e-07
I1170 n1_m1_76800_163200 0 4.953329e-07
I1171 n1_m1_76800_168000 0 1.089582e-06
I1172 n1_m1_76800_172800 0 3.400000e-07
I1173 n1_m1_76800_177600 0 6.029906e-06
I1174 n1_m1_76800_182400 0 7.020571e-07
I1175 n1_m1_76800_187200 0 1.175584e-06
I1176 n1_m1_76800_192000 0 6.213790e-07
I1177 n1_m1_76800_196800 0 2.899948e-07
I1178 n1_m1_76800_201600 0 7.031665e-07
I1179 n1_m1_76800_206400 0 3.111250e-07
I1180 n1_m1_76800_211200 0 3.823747e-07
I1181 n1_m1_76800_216000 0 6.375619e-07
I1182 n1_m1_76800_220800 0 7.809821e-07
I1183 n1_m1_76800_225600 0 2.880719e-07
I1184 n1_m1_76800_230400 0 6.311342e-07
I1185 n1_m1_76800_235200 0 3.291698e-07
I1186 n1_m1_76800_240000 0 4.422749e-07
I1187 n1_m1_76800_244800 0 4.131657e-07
I1188 n1_m1_76800_249600 0 2.527586e-07
I1189 n1_m1_76800_254400 0 2.849677e-07
I1190 n1_m1_76800_259200 0 4.921429e-07
I1191 n1_m1_76800_264000 0 4.000670e-07
I1192 n1_m1_76800_268800 0 2.420982e-07
I1193 n1_m1_76800_273600 0 2.391161e-07
I1194 n1_m1_76800_283200 0 7.812393e-07
I1195 n1_m1_76800_288000 0 7.369038e-07
I1196 n1_m1_76800_292800 0 5.566964e-07
I1197 n1_m1_76800_297600 0 7.370472e-07
I1198 n1_m1_76800_302400 0 3.301621e-07
I1199 n1_m1_76800_307200 0 6.516640e-07
I1200 n1_m1_76800_312000 0 4.998442e-07
I1201 n1_m1_76800_316800 0 5.385227e-07
I1202 n1_m1_76800_321600 0 4.780509e-07
I1203 n1_m1_76800_326400 0 1.611305e-07
I1204 n1_m1_76800_331200 0 5.194609e-07
I1205 n1_m1_76800_336000 0 2.713231e-07
I1206 n1_m1_76800_340800 0 3.344183e-07
I1207 n1_m1_76800_345600 0 7.301725e-07
I1208 n1_m1_76800_350400 0 5.528857e-07
I1209 n1_m1_76800_355200 0 3.322170e-07
I1210 n1_m1_76800_360000 0 5.753906e-07
I1211 n1_m1_76800_364800 0 9.104000e-07
I1212 n1_m1_76800_369600 0 8.479376e-07
I1213 n1_m1_76800_374400 0 3.628869e-07
I1214 n1_m1_76800_379200 0 1.427957e-06
I1215 n1_m1_76800_384000 0 7.021963e-07
I1216 n1_m1_76800_388800 0 4.935278e-07
I1217 n1_m1_76800_393600 0 7.051250e-07
I1218 n1_m1_81600_4800 0 4.207569e-07
I1219 n1_m1_81600_9600 0 1.094590e-06
I1220 n1_m1_81600_14400 0 1.727714e-07
I1221 n1_m1_81600_19200 0 6.259125e-07
I1222 n1_m1_81600_24000 0 9.301254e-07
I1223 n1_m1_81600_28800 0 4.758527e-07
I1224 n1_m1_81600_33600 0 9.708420e-07
I1225 n1_m1_81600_38400 0 6.211554e-07
I1226 n1_m1_81600_43200 0 8.236775e-07
I1227 n1_m1_81600_48000 0 7.837500e-07
I1228 n1_m1_81600_52800 0 1.211140e-06
I1229 n1_m1_81600_57600 0 5.898592e-07
I1230 n1_m1_81600_62400 0 6.126161e-07
I1231 n1_m1_81600_67200 0 6.231633e-07
I1232 n1_m1_81600_72000 0 8.957585e-07
I1233 n1_m1_81600_76800 0 6.652891e-07
I1234 n1_m1_81600_81600 0 9.014054e-07
I1235 n1_m1_81600_86400 0 9.250882e-07
I1236 n1_m1_81600_91200 0 1.802726e-07
I1237 n1_m1_81600_96000 0 1.397269e-06
I1238 n1_m1_81600_100800 0 1.623772e-06
I1239 n1_m1_81600_105600 0 1.188465e-06
I1240 n1_m1_81600_110400 0 7.103622e-07
I1241 n1_m1_81600_115200 0 3.332596e-07
I1242 n1_m1_81600_120000 0 6.522857e-07
I1243 n1_m1_81600_124800 0 6.092857e-07
I1244 n1_m1_81600_129600 0 7.092753e-07
I1245 n1_m1_81600_134400 0 6.977522e-07
I1246 n1_m1_81600_139200 0 6.445918e-07
I1247 n1_m1_81600_144000 0 8.977929e-07
I1248 n1_m1_81600_148800 0 4.103607e-07
I1249 n1_m1_81600_153600 0 1.090875e-06
I1250 n1_m1_81600_158400 0 2.879143e-07
I1251 n1_m1_81600_163200 0 8.965761e-07
I1252 n1_m1_81600_168000 0 9.043955e-07
I1253 n1_m1_81600_172800 0 4.914500e-07
I1254 n1_m1_81600_177600 0 3.645930e-06
I1255 n1_m1_81600_182400 0 6.910000e-07
I1256 n1_m1_81600_187200 0 5.014632e-07
I1257 n1_m1_81600_192000 0 1.142942e-06
I1258 n1_m1_81600_196800 0 4.042637e-07
I1259 n1_m1_81600_201600 0 1.021963e-06
I1260 n1_m1_81600_206400 0 6.140214e-07
I1261 n1_m1_81600_211200 0 6.965110e-07
I1262 n1_m1_81600_216000 0 6.614048e-07
I1263 n1_m1_81600_220800 0 4.807321e-07
I1264 n1_m1_81600_225600 0 4.159529e-07
I1265 n1_m1_81600_230400 0 3.715054e-07
I1266 n1_m1_81600_235200 0 7.418902e-07
I1267 n1_m1_81600_240000 0 1.231920e-06
I1268 n1_m1_81600_244800 0 7.008418e-07
I1269 n1_m1_81600_249600 0 5.599868e-07
I1270 n1_m1_81600_254400 0 7.429537e-07
I1271 n1_m1_81600_259200 0 1.173100e-06
I1272 n1_m1_81600_264000 0 8.725335e-07
I1273 n1_m1_81600_268800 0 1.004667e-06
I1274 n1_m1_81600_273600 0 1.124149e-06
I1275 n1_m1_81600_278400 0 7.437662e-07
I1276 n1_m1_81600_283200 0 1.366518e-07
I1277 n1_m1_81600_288000 0 5.509464e-07
I1278 n1_m1_81600_292800 0 4.172768e-07
I1279 n1_m1_81600_297600 0 3.639135e-07
I1280 n1_m1_81600_302400 0 7.453214e-07
I1281 n1_m1_81600_307200 0 6.020344e-06
I1282 n1_m1_81600_312000 0 2.810120e-06
I1283 n1_m1_81600_316800 0 8.921898e-07
I1284 n1_m1_81600_321600 0 1.266440e-06
I1285 n1_m1_81600_326400 0 6.645618e-07
I1286 n1_m1_81600_331200 0 6.446974e-07
I1287 n1_m1_81600_336000 0 1.350379e-06
I1288 n1_m1_81600_340800 0 5.579221e-07
I1289 n1_m1_81600_345600 0 4.442056e-07
I1290 n1_m1_81600_350400 0 7.145786e-07
I1291 n1_m1_81600_355200 0 1.603429e-07
I1292 n1_m1_81600_360000 0 1.402963e-06
I1293 n1_m1_81600_364800 0 2.795758e-07
I1294 n1_m1_81600_369600 0 6.730294e-07
I1295 n1_m1_81600_374400 0 9.697593e-07
I1296 n1_m1_81600_379200 0 1.094548e-06
I1297 n1_m1_81600_384000 0 2.067360e-06
I1298 n1_m1_81600_388800 0 4.534606e-07
I1299 n1_m1_81600_393600 0 6.804750e-07
I1300 n1_m1_81600_398400 0 2.280000e-07
I1301 n1_m1_86400_4800 0 7.144615e-08
I1302 n1_m1_86400_9600 0 5.318913e-07
I1303 n1_m1_86400_19200 0 1.011429e-07
I1304 n1_m1_86400_24000 0 1.890291e-07
I1305 n1_m1_86400_28800 0 1.004063e-07
I1306 n1_m1_86400_33600 0 2.802139e-07
I1307 n1_m1_86400_38400 0 1.434375e-07
I1308 n1_m1_86400_43200 0 3.036635e-07
I1309 n1_m1_86400_48000 0 1.021802e-07
I1310 n1_m1_86400_52800 0 6.337743e-07
I1311 n1_m1_86400_57600 0 4.419162e-07
I1312 n1_m1_86400_62400 0 3.351964e-07
I1313 n1_m1_86400_67200 0 3.325344e-07
I1314 n1_m1_86400_72000 0 2.322547e-07
I1315 n1_m1_86400_76800 0 4.649822e-07
I1316 n1_m1_86400_81600 0 4.034670e-07
I1317 n1_m1_86400_86400 0 2.974796e-07
I1318 n1_m1_86400_91200 0 1.553329e-07
I1319 n1_m1_86400_96000 0 5.020357e-07
I1320 n1_m1_86400_100800 0 3.989778e-07
I1321 n1_m1_86400_105600 0 8.590476e-08
I1322 n1_m1_86400_110400 0 2.277619e-07
I1323 n1_m1_86400_115200 0 6.904762e-08
I1324 n1_m1_86400_120000 0 1.084286e-07
I1325 n1_m1_86400_124800 0 3.014286e-07
I1326 n1_m1_86400_129600 0 3.211039e-07
I1327 n1_m1_86400_134400 0 3.092635e-07
I1328 n1_m1_86400_139200 0 9.438776e-08
I1329 n1_m1_86400_144000 0 5.473929e-07
I1330 n1_m1_86400_148800 0 1.459107e-07
I1331 n1_m1_86400_153600 0 4.311179e-07
I1332 n1_m1_86400_158400 0 2.274667e-07
I1333 n1_m1_86400_163200 0 3.618786e-07
I1334 n1_m1_86400_168000 0 3.543304e-07
I1335 n1_m1_86400_172800 0 2.537786e-07
I1336 n1_m1_86400_177600 0 9.137119e-07
I1337 n1_m1_86400_182400 0 2.292857e-07
I1338 n1_m1_86400_187200 0 2.238095e-08
I1339 n1_m1_86400_192000 0 1.926827e-07
I1340 n1_m1_86400_196800 0 4.751855e-08
I1341 n1_m1_86400_201600 0 2.525509e-07
I1342 n1_m1_86400_206400 0 3.511804e-07
I1343 n1_m1_86400_211200 0 2.683571e-07
I1344 n1_m1_86400_216000 0 5.130206e-07
I1345 n1_m1_86400_220800 0 1.907589e-07
I1346 n1_m1_86400_225600 0 3.822449e-07
I1347 n1_m1_86400_230400 0 3.899107e-07
I1348 n1_m1_86400_235200 0 3.880804e-07
I1349 n1_m1_86400_240000 0 2.904231e-07
I1350 n1_m1_86400_244800 0 6.377679e-07
I1351 n1_m1_86400_249600 0 5.461137e-07
I1352 n1_m1_86400_254400 0 4.650536e-07
I1353 n1_m1_86400_259200 0 6.540714e-07
I1354 n1_m1_86400_264000 0 1.482236e-07
I1355 n1_m1_86400_268800 0 2.840680e-07
I1356 n1_m1_86400_273600 0 2.208754e-07
I1357 n1_m1_86400_278400 0 1.229920e-07
I1358 n1_m1_86400_283200 0 2.355357e-07
I1359 n1_m1_86400_288000 0 4.003819e-07
I1360 n1_m1_86400_292800 0 3.772321e-07
I1361 n1_m1_86400_297600 0 2.346126e-07
I1362 n1_m1_86400_302400 0 3.800549e-07
I1363 n1_m1_86400_307200 0 2.174235e-07
I1364 n1_m1_86400_312000 0 1.071644e-07
I1365 n1_m1_86400_316800 0 1.898339e-07
I1366 n1_m1_86400_321600 0 3.247918e-07
I1367 n1_m1_86400_326400 0 1.700500e-07
I1368 n1_m1_86400_331200 0 5.230298e-08
I1369 n1_m1_86400_336000 0 4.759984e-07
I1370 n1_m1_86400_340800 0 2.441645e-07
I1371 n1_m1_86400_345600 0 3.526013e-07
I1372 n1_m1_86400_350400 0 1.880192e-07
I1373 n1_m1_86400_355200 0 1.534066e-07
I1374 n1_m1_86400_360000 0 4.363823e-07
I1375 n1_m1_86400_364800 0 8.760989e-08
I1376 n1_m1_86400_369600 0 1.316623e-07
I1377 n1_m1_86400_374400 0 1.765541e-07
I1378 n1_m1_86400_379200 0 2.565152e-06
I1379 n1_m1_86400_384000 0 3.573733e-06
I1380 n1_m1_86400_388800 0 1.102991e-07
I1381 n1_m1_86400_393600 0 8.120000e-08
I1382 n1_m1_91200_4800 0 3.101538e-07
I1383 n1_m1_91200_9600 0 6.210399e-07
I1384 n1_m1_91200_14400 0 1.702465e-07
I1385 n1_m1_91200_19200 0 4.528112e-07
I1386 n1_m1_91200_24000 0 6.640821e-07
I1387 n1_m1_91200_28800 0 2.369063e-07
I1388 n1_m1_91200_33600 0 5.090138e-06
I1389 n1_m1_91200_38400 0 3.256973e-06
I1390 n1_m1_91200_43200 0 5.611892e-07
I1391 n1_m1_91200_48000 0 6.434403e-07
I1392 n1_m1_91200_52800 0 6.881307e-07
I1393 n1_m1_91200_57600 0 4.331880e-07
I1394 n1_m1_91200_62400 0 6.352105e-07
I1395 n1_m1_91200_67200 0 9.093162e-07
I1396 n1_m1_91200_72000 0 4.083860e-07
I1397 n1_m1_91200_76800 0 4.017497e-07
I1398 n1_m1_91200_81600 0 5.777177e-07
I1399 n1_m1_91200_86400 0 6.473791e-07
I1400 n1_m1_91200_91200 0 3.233641e-07
I1401 n1_m1_91200_96000 0 7.236071e-07
I1402 n1_m1_91200_100800 0 1.919317e-07
I1403 n1_m1_91200_105600 0 2.217143e-07
I1404 n1_m1_91200_110400 0 5.156548e-07
I1405 n1_m1_91200_115200 0 5.848374e-07
I1406 n1_m1_91200_120000 0 2.943101e-07
I1407 n1_m1_91200_124800 0 2.027991e-07
I1408 n1_m1_91200_129600 0 8.689970e-07
I1409 n1_m1_91200_134400 0 2.890352e-07
I1410 n1_m1_91200_139200 0 3.560989e-08
I1411 n1_m1_91200_144000 0 6.153483e-07
I1412 n1_m1_91200_148800 0 7.419805e-08
I1413 n1_m1_91200_153600 0 1.790000e-07
I1414 n1_m1_91200_158400 0 1.857143e-08
I1415 n1_m1_91200_163200 0 3.280698e-07
I1416 n1_m1_91200_168000 0 4.079694e-07
I1417 n1_m1_91200_172800 0 3.577143e-08
I1418 n1_m1_91200_177600 0 3.249038e-07
I1419 n1_m1_91200_182400 0 3.338220e-07
I1420 n1_m1_91200_187200 0 5.362637e-09
I1421 n1_m1_91200_192000 0 7.788750e-07
I1422 n1_m1_91200_196800 0 4.452468e-07
I1423 n1_m1_91200_201600 0 7.402695e-07
I1424 n1_m1_91200_206400 0 4.434554e-07
I1425 n1_m1_91200_211200 0 6.929473e-07
I1426 n1_m1_91200_216000 0 1.139813e-06
I1427 n1_m1_91200_220800 0 7.920551e-06
I1428 n1_m1_91200_225600 0 2.466067e-07
I1429 n1_m1_91200_230400 0 4.922864e-07
I1430 n1_m1_91200_235200 0 4.886205e-07
I1431 n1_m1_91200_240000 0 3.795338e-07
I1432 n1_m1_91200_244800 0 3.329471e-07
I1433 n1_m1_91200_249600 0 1.583077e-07
I1434 n1_m1_91200_254400 0 2.931567e-07
I1435 n1_m1_91200_259200 0 4.392857e-07
I1436 n1_m1_91200_264000 0 2.954822e-07
I1437 n1_m1_91200_268800 0 2.178724e-07
I1438 n1_m1_91200_273600 0 9.915179e-07
I1439 n1_m1_91200_278400 0 7.928571e-08
I1440 n1_m1_91200_283200 0 4.527079e-07
I1441 n1_m1_91200_288000 0 4.393189e-07
I1442 n1_m1_91200_292800 0 2.889732e-07
I1443 n1_m1_91200_297600 0 9.448250e-07
I1444 n1_m1_91200_302400 0 4.658636e-07
I1445 n1_m1_91200_307200 0 3.459740e-07
I1446 n1_m1_91200_312000 0 8.895671e-07
I1447 n1_m1_91200_316800 0 2.640165e-07
I1448 n1_m1_91200_321600 0 3.905313e-07
I1449 n1_m1_91200_326400 0 4.566321e-07
I1450 n1_m1_91200_331200 0 7.490714e-08
I1451 n1_m1_91200_336000 0 4.694363e-07
I1452 n1_m1_91200_340800 0 2.103842e-07
I1453 n1_m1_91200_345600 0 1.132013e-06
I1454 n1_m1_91200_350400 0 6.165907e-07
I1455 n1_m1_91200_355200 0 4.748160e-06
I1456 n1_m1_91200_360000 0 1.652406e-06
I1457 n1_m1_91200_369600 0 3.884904e-07
I1458 n1_m1_91200_374400 0 6.725541e-07
I1459 n1_m1_91200_379200 0 5.828571e-09
I1460 n1_m1_91200_384000 0 7.195663e-07
I1461 n1_m1_91200_388800 0 2.949241e-07
I1462 n1_m1_91200_393600 0 5.335846e-07
I1463 n1_m1_96000_4800 0 1.192923e-07
I1464 n1_m1_96000_9600 0 1.251772e-06
I1465 n1_m1_96000_14400 0 5.785392e-07
I1466 n1_m1_96000_19200 0 6.296673e-07
I1467 n1_m1_96000_24000 0 2.560967e-06
I1468 n1_m1_96000_28800 0 2.866250e-07
I1469 n1_m1_96000_33600 0 1.183393e-06
I1470 n1_m1_96000_38400 0 6.173958e-07
I1471 n1_m1_96000_43200 0 1.194463e-06
I1472 n1_m1_96000_48000 0 8.095423e-07
I1473 n1_m1_96000_52800 0 6.084625e-07
I1474 n1_m1_96000_57600 0 3.237108e-07
I1475 n1_m1_96000_62400 0 6.976842e-07
I1476 n1_m1_96000_67200 0 9.160555e-07
I1477 n1_m1_96000_72000 0 1.164164e-06
I1478 n1_m1_96000_76800 0 3.387051e-07
I1479 n1_m1_96000_81600 0 7.315747e-07
I1480 n1_m1_96000_86400 0 8.901510e-07
I1481 n1_m1_96000_91200 0 1.492271e-07
I1482 n1_m1_96000_96000 0 4.967929e-07
I1483 n1_m1_96000_100800 0 8.462524e-07
I1484 n1_m1_96000_105600 0 2.939286e-07
I1485 n1_m1_96000_110400 0 4.998626e-07
I1486 n1_m1_96000_115200 0 6.291410e-07
I1487 n1_m1_96000_120000 0 3.820185e-07
I1488 n1_m1_96000_124800 0 7.360580e-07
I1489 n1_m1_96000_129600 0 1.370795e-06
I1490 n1_m1_96000_134400 0 7.544029e-07
I1491 n1_m1_96000_139200 0 2.345840e-07
I1492 n1_m1_96000_144000 0 1.179069e-06
I1493 n1_m1_96000_148800 0 2.834519e-07
I1494 n1_m1_96000_153600 0 1.146045e-06
I1495 n1_m1_96000_158400 0 6.811662e-07
I1496 n1_m1_96000_163200 0 8.958835e-07
I1497 n1_m1_96000_168000 0 8.569663e-07
I1498 n1_m1_96000_172800 0 9.238869e-07
I1499 n1_m1_96000_177600 0 1.059071e-06
I1500 n1_m1_96000_182400 0 6.540495e-07
I1501 n1_m1_96000_187200 0 2.788088e-07
I1502 n1_m1_96000_192000 0 1.606649e-06
I1503 n1_m1_96000_196800 0 4.429981e-07
I1504 n1_m1_96000_201600 0 7.676799e-07
I1505 n1_m1_96000_206400 0 9.775786e-07
I1506 n1_m1_96000_211200 0 2.155000e-07
I1507 n1_m1_96000_216000 0 8.934897e-07
I1508 n1_m1_96000_220800 0 5.686588e-07
I1509 n1_m1_96000_225600 0 7.774739e-07
I1510 n1_m1_96000_230400 0 7.075797e-07
I1511 n1_m1_96000_235200 0 5.590089e-07
I1512 n1_m1_96000_240000 0 9.101805e-07
I1513 n1_m1_96000_244800 0 6.475101e-07
I1514 n1_m1_96000_249600 0 1.234303e-06
I1515 n1_m1_96000_254400 0 4.960637e-07
I1516 n1_m1_96000_259200 0 9.145918e-07
I1517 n1_m1_96000_264000 0 8.646848e-06
I1518 n1_m1_96000_268800 0 8.819766e-07
I1519 n1_m1_96000_273600 0 8.475893e-07
I1520 n1_m1_96000_278400 0 4.782366e-07
I1521 n1_m1_96000_283200 0 9.323838e-07
I1522 n1_m1_96000_288000 0 3.642045e-07
I1523 n1_m1_96000_292800 0 7.270536e-07
I1524 n1_m1_96000_297600 0 1.185088e-06
I1525 n1_m1_96000_302400 0 7.773650e-07
I1526 n1_m1_96000_307200 0 5.733593e-07
I1527 n1_m1_96000_312000 0 6.587215e-07
I1528 n1_m1_96000_316800 0 9.383766e-08
I1529 n1_m1_96000_321600 0 1.256071e-06
I1530 n1_m1_96000_326400 0 6.070000e-07
I1531 n1_m1_96000_331200 0 5.273260e-08
I1532 n1_m1_96000_336000 0 9.202802e-07
I1533 n1_m1_96000_340800 0 6.837391e-07
I1534 n1_m1_96000_345600 0 8.543271e-07
I1535 n1_m1_96000_350400 0 6.078901e-07
I1536 n1_m1_96000_355200 0 4.221368e-07
I1537 n1_m1_96000_360000 0 1.627385e-06
I1538 n1_m1_96000_364800 0 8.515293e-07
I1539 n1_m1_96000_369600 0 7.253463e-07
I1540 n1_m1_96000_374400 0 9.044982e-07
I1541 n1_m1_96000_379200 0 2.523000e-07
I1542 n1_m1_96000_384000 0 8.365281e-07
I1543 n1_m1_96000_388800 0 4.327143e-07
I1544 n1_m1_96000_393600 0 8.796529e-07
I1545 n1_m1_96000_398400 0 2.280000e-07
I1546 n1_m1_100800_4800 0 1.237143e-07
I1547 n1_m1_100800_9600 0 7.229908e-07
I1548 n1_m1_100800_14400 0 2.242286e-07
I1549 n1_m1_100800_19200 0 5.134357e-07
I1550 n1_m1_100800_24000 0 6.117329e-07
I1551 n1_m1_100800_28800 0 3.470000e-07
I1552 n1_m1_100800_33600 0 7.818003e-07
I1553 n1_m1_100800_38400 0 6.147221e-07
I1554 n1_m1_100800_43200 0 5.368750e-07
I1555 n1_m1_100800_48000 0 8.579464e-07
I1556 n1_m1_100800_52800 0 5.197266e-07
I1557 n1_m1_100800_57600 0 5.011798e-07
I1558 n1_m1_100800_62400 0 7.535357e-07
I1559 n1_m1_100800_67200 0 5.584283e-06
I1560 n1_m1_100800_72000 0 8.639327e-07
I1561 n1_m1_100800_76800 0 3.520495e-07
I1562 n1_m1_100800_81600 0 7.454727e-07
I1563 n1_m1_100800_86400 0 5.627484e-07
I1564 n1_m1_100800_91200 0 9.501099e-08
I1565 n1_m1_100800_96000 0 7.317143e-07
I1566 n1_m1_100800_100800 0 5.263381e-07
I1567 n1_m1_100800_105600 0 5.877143e-07
I1568 n1_m1_100800_110400 0 6.200595e-07
I1569 n1_m1_100800_115200 0 2.421238e-07
I1570 n1_m1_100800_120000 0 9.184286e-07
I1571 n1_m1_100800_124800 0 7.001429e-07
I1572 n1_m1_100800_129600 0 4.661857e-07
I1573 n1_m1_100800_134400 0 4.239082e-07
I1574 n1_m1_100800_139200 0 5.248776e-07
I1575 n1_m1_100800_144000 0 6.669110e-07
I1576 n1_m1_100800_148800 0 6.039857e-07
I1577 n1_m1_100800_153600 0 4.085982e-07
I1578 n1_m1_100800_158400 0 3.927459e-07
I1579 n1_m1_100800_163200 0 3.489011e-07
I1580 n1_m1_100800_168000 0 5.546378e-07
I1581 n1_m1_100800_172800 0 5.117144e-07
I1582 n1_m1_100800_177600 0 5.391639e-07
I1583 n1_m1_100800_182400 0 1.046000e-07
I1584 n1_m1_100800_187200 0 1.694667e-07
I1585 n1_m1_100800_192000 0 6.672080e-07
I1586 n1_m1_100800_196800 0 2.112500e-07
I1587 n1_m1_100800_201600 0 6.744110e-07
I1588 n1_m1_100800_206400 0 6.736643e-07
I1589 n1_m1_100800_211200 0 1.634000e-07
I1590 n1_m1_100800_216000 0 5.781957e-07
I1591 n1_m1_100800_220800 0 2.985470e-07
I1592 n1_m1_100800_225600 0 1.109375e-06
I1593 n1_m1_100800_230400 0 2.818929e-07
I1594 n1_m1_100800_235200 0 7.289196e-07
I1595 n1_m1_100800_240000 0 2.225762e-07
I1596 n1_m1_100800_244800 0 3.582857e-07
I1597 n1_m1_100800_249600 0 6.099325e-07
I1598 n1_m1_100800_254400 0 2.941651e-07
I1599 n1_m1_100800_259200 0 3.191855e-07
I1600 n1_m1_100800_264000 0 5.560816e-07
I1601 n1_m1_100800_268800 0 4.516787e-07
I1602 n1_m1_100800_273600 0 2.163143e-07
I1603 n1_m1_100800_278400 0 2.139063e-07
I1604 n1_m1_100800_283200 0 7.670244e-07
I1605 n1_m1_100800_288000 0 3.040731e-07
I1606 n1_m1_100800_292800 0 5.906250e-07
I1607 n1_m1_100800_297600 0 1.331123e-06
I1608 n1_m1_100800_302400 0 5.577902e-07
I1609 n1_m1_100800_307200 0 1.014286e-07
I1610 n1_m1_100800_312000 0 9.630114e-07
I1611 n1_m1_100800_316800 0 2.109394e-07
I1612 n1_m1_100800_321600 0 3.094903e-07
I1613 n1_m1_100800_326400 0 3.761031e-07
I1614 n1_m1_100800_331200 0 1.157225e-07
I1615 n1_m1_100800_336000 0 6.021538e-07
I1616 n1_m1_100800_340800 0 5.810458e-07
I1617 n1_m1_100800_345600 0 8.240804e-07
I1618 n1_m1_100800_350400 0 2.246846e-07
I1619 n1_m1_100800_355200 0 3.102500e-07
I1620 n1_m1_100800_360000 0 4.760288e-07
I1621 n1_m1_100800_364800 0 2.311308e-07
I1622 n1_m1_100800_369600 0 3.229564e-07
I1623 n1_m1_100800_374400 0 4.222437e-07
I1624 n1_m1_100800_379200 0 1.432121e-07
I1625 n1_m1_100800_384000 0 1.147413e-07
I1626 n1_m1_100800_388800 0 5.343486e-07
I1627 n1_m1_100800_393600 0 6.488393e-07
I1628 n1_m1_100800_398400 0 2.577857e-07
I1629 n1_m1_105600_4800 0 2.227780e-07
I1630 n1_m1_105600_9600 0 1.230034e-06
I1631 n1_m1_105600_14400 0 5.630179e-07
I1632 n1_m1_105600_19200 0 6.383482e-07
I1633 n1_m1_105600_24000 0 1.471641e-06
I1634 n1_m1_105600_28800 0 1.413260e-07
I1635 n1_m1_105600_33600 0 7.159756e-07
I1636 n1_m1_105600_38400 0 4.961255e-07
I1637 n1_m1_105600_43200 0 1.057032e-06
I1638 n1_m1_105600_48000 0 3.858330e-07
I1639 n1_m1_105600_52800 0 6.265873e-07
I1640 n1_m1_105600_57600 0 3.523018e-07
I1641 n1_m1_105600_62400 0 3.285196e-07
I1642 n1_m1_105600_67200 0 2.758443e-06
I1643 n1_m1_105600_72000 0 1.032780e-06
I1644 n1_m1_105600_76800 0 2.708209e-07
I1645 n1_m1_105600_81600 0 9.811515e-07
I1646 n1_m1_105600_86400 0 2.308222e-07
I1647 n1_m1_105600_91200 0 4.136009e-07
I1648 n1_m1_105600_96000 0 7.322964e-07
I1649 n1_m1_105600_100800 0 2.001660e-07
I1650 n1_m1_105600_105600 0 4.605197e-07
I1651 n1_m1_105600_110400 0 4.657024e-07
I1652 n1_m1_105600_115200 0 5.696405e-07
I1653 n1_m1_105600_120000 0 3.065170e-07
I1654 n1_m1_105600_124800 0 7.458878e-07
I1655 n1_m1_105600_129600 0 5.979195e-07
I1656 n1_m1_105600_134400 0 3.461913e-07
I1657 n1_m1_105600_139200 0 7.052778e-07
I1658 n1_m1_105600_144000 0 6.100244e-07
I1659 n1_m1_105600_148800 0 4.346514e-07
I1660 n1_m1_105600_153600 0 1.085271e-06
I1661 n1_m1_105600_158400 0 1.018774e-06
I1662 n1_m1_105600_163200 0 4.330353e-07
I1663 n1_m1_105600_168000 0 9.342789e-07
I1664 n1_m1_105600_172800 0 3.780686e-07
I1665 n1_m1_105600_177600 0 4.912923e-07
I1666 n1_m1_105600_182400 0 4.873857e-07
I1667 n1_m1_105600_187200 0 7.118381e-07
I1668 n1_m1_105600_192000 0 2.385843e-06
I1669 n1_m1_105600_196800 0 5.168861e-07
I1670 n1_m1_105600_201600 0 1.209458e-06
I1671 n1_m1_105600_206400 0 9.231893e-07
I1672 n1_m1_105600_211200 0 6.908095e-08
I1673 n1_m1_105600_216000 0 1.090794e-06
I1674 n1_m1_105600_220800 0 4.724004e-07
I1675 n1_m1_105600_225600 0 6.352266e-07
I1676 n1_m1_105600_230400 0 5.842597e-07
I1677 n1_m1_105600_235200 0 5.463681e-07
I1678 n1_m1_105600_240000 0 1.557381e-07
I1679 n1_m1_105600_244800 0 8.292857e-07
I1680 n1_m1_105600_249600 0 4.554286e-07
I1681 n1_m1_105600_254400 0 9.130860e-07
I1682 n1_m1_105600_259200 0 7.622226e-07
I1683 n1_m1_105600_264000 0 4.486378e-07
I1684 n1_m1_105600_268800 0 6.818187e-07
I1685 n1_m1_105600_273600 0 6.383143e-07
I1686 n1_m1_105600_278400 0 8.022143e-07
I1687 n1_m1_105600_283200 0 6.411714e-07
I1688 n1_m1_105600_288000 0 4.714866e-07
I1689 n1_m1_105600_292800 0 4.149948e-07
I1690 n1_m1_105600_297600 0 1.705427e-06
I1691 n1_m1_105600_302400 0 8.604509e-07
I1692 n1_m1_105600_307200 0 3.038571e-07
I1693 n1_m1_105600_312000 0 6.483610e-07
I1694 n1_m1_105600_316800 0 8.442286e-07
I1695 n1_m1_105600_321600 0 1.763376e-06
I1696 n1_m1_105600_326400 0 1.036530e-06
I1697 n1_m1_105600_331200 0 4.099480e-07
I1698 n1_m1_105600_336000 0 6.974755e-07
I1699 n1_m1_105600_340800 0 5.648324e-07
I1700 n1_m1_105600_345600 0 5.633795e-07
I1701 n1_m1_105600_350400 0 3.438750e-07
I1702 n1_m1_105600_355200 0 1.024571e-06
I1703 n1_m1_105600_360000 0 4.602170e-07
I1704 n1_m1_105600_364800 0 3.732216e-07
I1705 n1_m1_105600_369600 0 1.117129e-06
I1706 n1_m1_105600_374400 0 3.434095e-07
I1707 n1_m1_105600_379200 0 9.953636e-07
I1708 n1_m1_105600_384000 0 7.223045e-07
I1709 n1_m1_105600_388800 0 5.895580e-07
I1710 n1_m1_105600_393600 0 1.321188e-06
I1711 n1_m1_105600_398400 0 1.965000e-07
I1712 n1_m1_110400_4800 0 1.713758e-07
I1713 n1_m1_110400_9600 0 7.723438e-07
I1714 n1_m1_110400_14400 0 3.161250e-07
I1715 n1_m1_110400_19200 0 4.910357e-07
I1716 n1_m1_110400_24000 0 7.436819e-07
I1717 n1_m1_110400_28800 0 2.142258e-07
I1718 n1_m1_110400_33600 0 6.778212e-07
I1719 n1_m1_110400_38400 0 5.091407e-07
I1720 n1_m1_110400_43200 0 2.637713e-07
I1721 n1_m1_110400_48000 0 6.965456e-07
I1722 n1_m1_110400_52800 0 4.699174e-07
I1723 n1_m1_110400_57600 0 1.184643e-06
I1724 n1_m1_110400_62400 0 5.408214e-07
I1725 n1_m1_110400_67200 0 6.075357e-07
I1726 n1_m1_110400_72000 0 6.122368e-07
I1727 n1_m1_110400_76800 0 2.272855e-07
I1728 n1_m1_110400_81600 0 3.584743e-07
I1729 n1_m1_110400_86400 0 4.914110e-07
I1730 n1_m1_110400_91200 0 4.927441e-07
I1731 n1_m1_110400_96000 0 4.620751e-07
I1732 n1_m1_110400_100800 0 3.927594e-07
I1733 n1_m1_110400_105600 0 6.479898e-07
I1734 n1_m1_110400_110400 0 2.090833e-07
I1735 n1_m1_110400_115200 0 2.763040e-07
I1736 n1_m1_110400_120000 0 3.460012e-07
I1737 n1_m1_110400_124800 0 3.059740e-07
I1738 n1_m1_110400_129600 0 3.367213e-07
I1739 n1_m1_110400_134400 0 8.256634e-07
I1740 n1_m1_110400_139200 0 3.250794e-07
I1741 n1_m1_110400_144000 0 6.405784e-07
I1742 n1_m1_110400_148800 0 4.860514e-07
I1743 n1_m1_110400_153600 0 5.662857e-07
I1744 n1_m1_110400_158400 0 9.079000e-07
I1745 n1_m1_110400_163200 0 7.899002e-06
I1746 n1_m1_110400_168000 0 4.736571e-07
I1747 n1_m1_110400_172800 0 4.611973e-07
I1748 n1_m1_110400_177600 0 4.768281e-07
I1749 n1_m1_110400_182400 0 3.039429e-07
I1750 n1_m1_110400_187200 0 1.864381e-07
I1751 n1_m1_110400_192000 0 6.564857e-07
I1752 n1_m1_110400_196800 0 2.611155e-07
I1753 n1_m1_110400_201600 0 5.197490e-07
I1754 n1_m1_110400_206400 0 4.674107e-07
I1755 n1_m1_110400_211200 0 2.985476e-07
I1756 n1_m1_110400_216000 0 4.761762e-07
I1757 n1_m1_110400_220800 0 6.995429e-07
I1758 n1_m1_110400_225600 0 5.093662e-07
I1759 n1_m1_110400_230400 0 7.740260e-07
I1760 n1_m1_110400_235200 0 4.197033e-07
I1761 n1_m1_110400_240000 0 1.784156e-07
I1762 n1_m1_110400_244800 0 5.677506e-07
I1763 n1_m1_110400_249600 0 6.196286e-07
I1764 n1_m1_110400_254400 0 9.595286e-07
I1765 n1_m1_110400_259200 0 2.579714e-07
I1766 n1_m1_110400_264000 0 1.644357e-07
I1767 n1_m1_110400_268800 0 2.894429e-07
I1768 n1_m1_110400_273600 0 4.300381e-07
I1769 n1_m1_110400_278400 0 3.275952e-07
I1770 n1_m1_110400_283200 0 1.598143e-07
I1771 n1_m1_110400_288000 0 8.996607e-07
I1772 n1_m1_110400_292800 0 5.264492e-07
I1773 n1_m1_110400_297600 0 6.598297e-07
I1774 n1_m1_110400_302400 0 5.519398e-07
I1775 n1_m1_110400_307200 0 2.016758e-07
I1776 n1_m1_110400_312000 0 8.478571e-07
I1777 n1_m1_110400_316800 0 5.933455e-07
I1778 n1_m1_110400_321600 0 3.416518e-07
I1779 n1_m1_110400_326400 0 3.013564e-07
I1780 n1_m1_110400_331200 0 3.605653e-07
I1781 n1_m1_110400_336000 0 7.698214e-07
I1782 n1_m1_110400_340800 0 4.001429e-07
I1783 n1_m1_110400_345600 0 1.126661e-06
I1784 n1_m1_110400_350400 0 1.818393e-07
I1785 n1_m1_110400_355200 0 2.856964e-07
I1786 n1_m1_110400_360000 0 3.491383e-07
I1787 n1_m1_110400_364800 0 1.275610e-07
I1788 n1_m1_110400_369600 0 3.817635e-07
I1789 n1_m1_110400_374400 0 5.944762e-07
I1790 n1_m1_110400_379200 0 2.585671e-07
I1791 n1_m1_110400_384000 0 2.050971e-07
I1792 n1_m1_110400_388800 0 1.673077e-07
I1793 n1_m1_110400_393600 0 6.847500e-07
I1794 n1_m1_110400_398400 0 1.020000e-07
I1795 n1_m1_115200_4800 0 3.908571e-08
I1796 n1_m1_115200_9600 0 4.221946e-07
I1797 n1_m1_115200_14400 0 1.796714e-07
I1798 n1_m1_115200_19200 0 2.338839e-07
I1799 n1_m1_115200_24000 0 3.352723e-07
I1800 n1_m1_115200_28800 0 1.664875e-07
I1801 n1_m1_115200_33600 0 4.256672e-07
I1802 n1_m1_115200_38400 0 3.876166e-07
I1803 n1_m1_115200_43200 0 5.152196e-07
I1804 n1_m1_115200_48000 0 4.581303e-07
I1805 n1_m1_115200_52800 0 1.336813e-07
I1806 n1_m1_115200_57600 0 5.617768e-07
I1807 n1_m1_115200_62400 0 2.637411e-07
I1808 n1_m1_115200_67200 0 2.886696e-07
I1809 n1_m1_115200_72000 0 4.649286e-07
I1810 n1_m1_115200_76800 0 1.649143e-08
I1811 n1_m1_115200_81600 0 3.642436e-07
I1812 n1_m1_115200_86400 0 1.299577e-07
I1813 n1_m1_115200_91200 0 1.521923e-07
I1814 n1_m1_115200_96000 0 1.867857e-07
I1815 n1_m1_115200_100800 0 6.036508e-08
I1816 n1_m1_115200_105600 0 3.103333e-07
I1817 n1_m1_115200_110400 0 2.414286e-07
I1818 n1_m1_115200_115200 0 1.882698e-07
I1819 n1_m1_115200_120000 0 2.930390e-07
I1820 n1_m1_115200_124800 0 8.749536e-08
I1821 n1_m1_115200_129600 0 6.816327e-09
I1822 n1_m1_115200_134400 0 2.065000e-07
I1823 n1_m1_115200_139200 0 1.158009e-07
I1824 n1_m1_115200_144000 0 9.807463e-08
I1825 n1_m1_115200_148800 0 2.561257e-07
I1826 n1_m1_115200_153600 0 2.159071e-07
I1827 n1_m1_115200_158400 0 8.610000e-08
I1828 n1_m1_115200_163200 0 4.653157e-07
I1829 n1_m1_115200_168000 0 4.018190e-07
I1830 n1_m1_115200_172800 0 1.211043e-07
I1831 n1_m1_115200_177600 0 1.211397e-07
I1832 n1_m1_115200_182400 0 5.035714e-08
I1833 n1_m1_115200_187200 0 1.927755e-07
I1834 n1_m1_115200_192000 0 2.151888e-07
I1835 n1_m1_115200_196800 0 1.389270e-07
I1836 n1_m1_115200_201600 0 1.476179e-07
I1837 n1_m1_115200_206400 0 1.025357e-07
I1838 n1_m1_115200_211200 0 1.314500e-07
I1839 n1_m1_115200_216000 0 2.530429e-07
I1840 n1_m1_115200_220800 0 2.613381e-07
I1841 n1_m1_115200_225600 0 8.104286e-08
I1842 n1_m1_115200_230400 0 1.798571e-07
I1843 n1_m1_115200_235200 0 9.375000e-08
I1844 n1_m1_115200_240000 0 1.801024e-07
I1845 n1_m1_115200_244800 0 2.428734e-07
I1846 n1_m1_115200_249600 0 1.111607e-08
I1847 n1_m1_115200_254400 0 3.120905e-07
I1848 n1_m1_115200_259200 0 1.421429e-07
I1849 n1_m1_115200_264000 0 1.444000e-07
I1850 n1_m1_115200_268800 0 1.748571e-07
I1851 n1_m1_115200_273600 0 3.515238e-07
I1852 n1_m1_115200_278400 0 2.291667e-07
I1853 n1_m1_115200_283200 0 7.150000e-08
I1854 n1_m1_115200_288000 0 3.641527e-07
I1855 n1_m1_115200_292800 0 1.470203e-07
I1856 n1_m1_115200_297600 0 2.201063e-07
I1857 n1_m1_115200_302400 0 3.192109e-07
I1858 n1_m1_115200_307200 0 1.029670e-07
I1859 n1_m1_115200_312000 0 2.328721e-07
I1860 n1_m1_115200_316800 0 1.349297e-07
I1861 n1_m1_115200_321600 0 3.314911e-07
I1862 n1_m1_115200_326400 0 1.158681e-07
I1863 n1_m1_115200_331200 0 2.807370e-07
I1864 n1_m1_115200_336000 0 2.807875e-07
I1865 n1_m1_115200_340800 0 1.997500e-07
I1866 n1_m1_115200_345600 0 3.375409e-07
I1867 n1_m1_115200_350400 0 1.551571e-07
I1868 n1_m1_115200_355200 0 2.913679e-07
I1869 n1_m1_115200_360000 0 4.179808e-07
I1870 n1_m1_115200_364800 0 1.627768e-07
I1871 n1_m1_115200_369600 0 4.440472e-07
I1872 n1_m1_115200_374400 0 7.808673e-08
I1873 n1_m1_115200_379200 0 3.501786e-07
I1874 n1_m1_115200_384000 0 2.014429e-07
I1875 n1_m1_115200_393600 0 1.218095e-07
I1876 n1_m1_115200_398400 0 1.128571e-07
I1877 n1_m1_120000_4800 0 2.848047e-07
I1878 n1_m1_120000_9600 0 7.957962e-07
I1879 n1_m1_120000_14400 0 4.581753e-07
I1880 n1_m1_120000_19200 0 3.611861e-07
I1881 n1_m1_120000_24000 0 7.651604e-07
I1882 n1_m1_120000_28800 0 2.295462e-07
I1883 n1_m1_120000_33600 0 1.779392e-07
I1884 n1_m1_120000_38400 0 3.283936e-07
I1885 n1_m1_120000_43200 0 2.734375e-08
I1886 n1_m1_120000_48000 0 3.671955e-07
I1887 n1_m1_120000_52800 0 2.066330e-07
I1888 n1_m1_120000_57600 0 7.280625e-07
I1889 n1_m1_120000_62400 0 4.860791e-07
I1890 n1_m1_120000_67200 0 1.407245e-07
I1891 n1_m1_120000_72000 0 1.068693e-06
I1892 n1_m1_120000_76800 0 1.405451e-07
I1893 n1_m1_120000_81600 0 4.814619e-07
I1894 n1_m1_120000_86400 0 1.705995e-07
I1895 n1_m1_120000_91200 0 1.242363e-07
I1896 n1_m1_120000_96000 0 3.757071e-07
I1897 n1_m1_120000_100800 0 5.135107e-07
I1898 n1_m1_120000_105600 0 5.557238e-07
I1899 n1_m1_120000_110400 0 1.654762e-07
I1900 n1_m1_120000_115200 0 1.855161e-07
I1901 n1_m1_120000_120000 0 5.589587e-07
I1902 n1_m1_120000_124800 0 9.659683e-07
I1903 n1_m1_120000_129600 0 4.406286e-07
I1904 n1_m1_120000_134400 0 5.863071e-07
I1905 n1_m1_120000_139200 0 3.889064e-07
I1906 n1_m1_120000_144000 0 2.905173e-07
I1907 n1_m1_120000_148800 0 2.103690e-07
I1908 n1_m1_120000_153600 0 5.860434e-07
I1909 n1_m1_120000_158400 0 2.615162e-07
I1910 n1_m1_120000_163200 0 2.644732e-07
I1911 n1_m1_120000_168000 0 1.037143e-07
I1912 n1_m1_120000_172800 0 4.569714e-07
I1913 n1_m1_120000_177600 0 2.291143e-07
I1914 n1_m1_120000_182400 0 3.001718e-07
I1915 n1_m1_120000_187200 0 1.408299e-06
I1916 n1_m1_120000_192000 0 8.725190e-07
I1917 n1_m1_120000_196800 0 5.578736e-07
I1918 n1_m1_120000_201600 0 7.554830e-07
I1919 n1_m1_120000_206400 0 6.316161e-07
I1920 n1_m1_120000_211200 0 2.661429e-07
I1921 n1_m1_120000_216000 0 7.245238e-07
I1922 n1_m1_120000_220800 0 4.495000e-07
I1923 n1_m1_120000_225600 0 1.368138e-06
I1924 n1_m1_120000_230400 0 8.273143e-07
I1925 n1_m1_120000_235200 0 3.412143e-07
I1926 n1_m1_120000_240000 0 7.396425e-07
I1927 n1_m1_120000_244800 0 3.429533e-07
I1928 n1_m1_120000_249600 0 3.120288e-07
I1929 n1_m1_120000_254400 0 4.129679e-07
I1930 n1_m1_120000_259200 0 4.551071e-07
I1931 n1_m1_120000_264000 0 6.382286e-07
I1932 n1_m1_120000_268800 0 7.535714e-08
I1933 n1_m1_120000_273600 0 8.153810e-07
I1934 n1_m1_120000_278400 0 5.314286e-07
I1935 n1_m1_120000_283200 0 3.205190e-07
I1936 n1_m1_120000_288000 0 7.117440e-07
I1937 n1_m1_120000_292800 0 4.768956e-07
I1938 n1_m1_120000_297600 0 1.204338e-06
I1939 n1_m1_120000_302400 0 3.292630e-07
I1940 n1_m1_120000_307200 0 3.897024e-07
I1941 n1_m1_120000_312000 0 8.573872e-07
I1942 n1_m1_120000_316800 0 3.680939e-07
I1943 n1_m1_120000_321600 0 5.965349e-07
I1944 n1_m1_120000_326400 0 5.842092e-07
I1945 n1_m1_120000_331200 0 7.879643e-06
I1946 n1_m1_120000_336000 0 7.477253e-07
I1947 n1_m1_120000_340800 0 4.716218e-07
I1948 n1_m1_120000_345600 0 6.067857e-07
I1949 n1_m1_120000_350400 0 2.113542e-07
I1950 n1_m1_120000_355200 0 3.906786e-07
I1951 n1_m1_120000_360000 0 5.158714e-07
I1952 n1_m1_120000_364800 0 2.145536e-08
I1953 n1_m1_120000_369600 0 3.019654e-07
I1954 n1_m1_120000_374400 0 1.490330e-08
I1955 n1_m1_120000_379200 0 2.325020e-07
I1956 n1_m1_120000_384000 0 4.928539e-07
I1957 n1_m1_120000_388800 0 2.741839e-07
I1958 n1_m1_120000_393600 0 7.584128e-07
I1959 n1_m1_120000_398400 0 7.803956e-08
I1960 n1_m1_124800_4800 0 1.591953e-07
I1961 n1_m1_124800_9600 0 9.582038e-07
I1962 n1_m1_124800_14400 0 1.627066e-07
I1963 n1_m1_124800_19200 0 2.219952e-07
I1964 n1_m1_124800_24000 0 8.283934e-07
I1965 n1_m1_124800_28800 0 4.170735e-07
I1966 n1_m1_124800_33600 0 9.042375e-07
I1967 n1_m1_124800_38400 0 5.586955e-07
I1968 n1_m1_124800_43200 0 7.713673e-07
I1969 n1_m1_124800_48000 0 1.116626e-06
I1970 n1_m1_124800_52800 0 1.177807e-06
I1971 n1_m1_124800_57600 0 6.426565e-07
I1972 n1_m1_124800_62400 0 4.448066e-07
I1973 n1_m1_124800_67200 0 2.377041e-07
I1974 n1_m1_124800_72000 0 6.274829e-07
I1975 n1_m1_124800_76800 0 1.252308e-07
I1976 n1_m1_124800_81600 0 6.704762e-07
I1977 n1_m1_124800_86400 0 3.863456e-07
I1978 n1_m1_124800_91200 0 1.365044e-07
I1979 n1_m1_124800_96000 0 3.607434e-06
I1980 n1_m1_124800_100800 0 1.573125e-06
I1981 n1_m1_124800_105600 0 4.010333e-07
I1982 n1_m1_124800_110400 0 5.012381e-07
I1983 n1_m1_124800_115200 0 3.669839e-07
I1984 n1_m1_124800_120000 0 1.904857e-07
I1985 n1_m1_124800_124800 0 3.567857e-07
I1986 n1_m1_124800_129600 0 1.863857e-07
I1987 n1_m1_124800_134400 0 5.032214e-07
I1988 n1_m1_124800_139200 0 1.524464e-07
I1989 n1_m1_124800_144000 0 1.639143e-07
I1990 n1_m1_124800_148800 0 9.491667e-08
I1991 n1_m1_124800_153600 0 4.282679e-07
I1992 n1_m1_124800_158400 0 6.750714e-07
I1993 n1_m1_124800_163200 0 7.614643e-07
I1994 n1_m1_124800_168000 0 1.311476e-06
I1995 n1_m1_124800_172800 0 1.988571e-07
I1996 n1_m1_124800_177600 0 1.844286e-07
I1997 n1_m1_124800_182400 0 1.365238e-06
I1998 n1_m1_124800_187200 0 1.065952e-06
I1999 n1_m1_124800_192000 0 7.542651e-07
I2000 n1_m1_124800_196800 0 6.996429e-07
I2001 n1_m1_124800_201600 0 1.312899e-06
I2002 n1_m1_124800_206400 0 6.597393e-07
I2003 n1_m1_124800_211200 0 7.817143e-08
I2004 n1_m1_124800_216000 0 8.165905e-07
I2005 n1_m1_124800_220800 0 4.668147e-07
I2006 n1_m1_124800_225600 0 1.025419e-06
I2007 n1_m1_124800_230400 0 2.431000e-07
I2008 n1_m1_124800_235200 0 1.157893e-07
I2009 n1_m1_124800_240000 0 5.124679e-07
I2010 n1_m1_124800_244800 0 2.034143e-07
I2011 n1_m1_124800_249600 0 9.083623e-07
I2012 n1_m1_124800_254400 0 3.552607e-07
I2013 n1_m1_124800_259200 0 3.546429e-08
I2014 n1_m1_124800_264000 0 3.481571e-07
I2015 n1_m1_124800_268800 0 4.805000e-07
I2016 n1_m1_124800_273600 0 8.050190e-07
I2017 n1_m1_124800_278400 0 3.225000e-07
I2018 n1_m1_124800_283200 0 3.575429e-07
I2019 n1_m1_124800_288000 0 2.222971e-06
I2020 n1_m1_124800_292800 0 4.013571e-06
I2021 n1_m1_124800_297600 0 7.245232e-07
I2022 n1_m1_124800_302400 0 8.174160e-08
I2023 n1_m1_124800_307200 0 2.568750e-07
I2024 n1_m1_124800_312000 0 8.615487e-07
I2025 n1_m1_124800_316800 0 6.558788e-08
I2026 n1_m1_124800_321600 0 1.013970e-06
I2027 n1_m1_124800_326400 0 3.077867e-07
I2028 n1_m1_124800_331200 0 2.243955e-07
I2029 n1_m1_124800_336000 0 8.402462e-07
I2030 n1_m1_124800_340800 0 4.908163e-07
I2031 n1_m1_124800_345600 0 8.050714e-07
I2032 n1_m1_124800_350400 0 1.093384e-06
I2033 n1_m1_124800_355200 0 3.710357e-07
I2034 n1_m1_124800_360000 0 1.064732e-06
I2035 n1_m1_124800_364800 0 3.701048e-07
I2036 n1_m1_124800_369600 0 8.102857e-07
I2037 n1_m1_124800_374400 0 1.649121e-07
I2038 n1_m1_124800_379200 0 6.852029e-07
I2039 n1_m1_124800_384000 0 5.842587e-07
I2040 n1_m1_124800_388800 0 3.491875e-07
I2041 n1_m1_124800_393600 0 5.518528e-07
I2042 n1_m1_124800_398400 0 7.469388e-08
I2043 n1_m1_129600_4800 0 2.612876e-07
I2044 n1_m1_129600_9600 0 1.247649e-06
I2045 n1_m1_129600_14400 0 3.955012e-07
I2046 n1_m1_129600_19200 0 4.580056e-07
I2047 n1_m1_129600_24000 0 2.116168e-06
I2048 n1_m1_129600_28800 0 6.652232e-07
I2049 n1_m1_129600_33600 0 9.158071e-07
I2050 n1_m1_129600_38400 0 8.011532e-06
I2051 n1_m1_129600_43200 0 6.145197e-07
I2052 n1_m1_129600_48000 0 7.444568e-07
I2053 n1_m1_129600_52800 0 1.026821e-06
I2054 n1_m1_129600_57600 0 1.230462e-06
I2055 n1_m1_129600_62400 0 4.031429e-07
I2056 n1_m1_129600_67200 0 1.808286e-07
I2057 n1_m1_129600_72000 0 1.655349e-06
I2058 n1_m1_129600_76800 0 3.995833e-07
I2059 n1_m1_129600_81600 0 6.512952e-07
I2060 n1_m1_129600_86400 0 4.956231e-07
I2061 n1_m1_129600_91200 0 9.064198e-07
I2062 n1_m1_129600_96000 0 2.864224e-06
I2063 n1_m1_129600_100800 0 1.365529e-06
I2064 n1_m1_129600_105600 0 6.419857e-07
I2065 n1_m1_129600_110400 0 8.054286e-07
I2066 n1_m1_129600_115200 0 4.063143e-07
I2067 n1_m1_129600_120000 0 5.818143e-07
I2068 n1_m1_129600_124800 0 5.208214e-07
I2069 n1_m1_129600_129600 0 4.359429e-07
I2070 n1_m1_129600_134400 0 1.719286e-07
I2071 n1_m1_129600_139200 0 3.581429e-07
I2072 n1_m1_129600_144000 0 4.751714e-07
I2073 n1_m1_129600_148800 0 1.643714e-07
I2074 n1_m1_129600_153600 0 5.143214e-07
I2075 n1_m1_129600_158400 0 7.881607e-07
I2076 n1_m1_129600_163200 0 6.481125e-07
I2077 n1_m1_129600_168000 0 7.794830e-07
I2078 n1_m1_129600_172800 0 6.491837e-07
I2079 n1_m1_129600_177600 0 1.934429e-06
I2080 n1_m1_129600_182400 0 1.683271e-06
I2081 n1_m1_129600_187200 0 1.097429e-06
I2082 n1_m1_129600_192000 0 9.693778e-07
I2083 n1_m1_129600_196800 0 1.401390e-06
I2084 n1_m1_129600_201600 0 1.175455e-06
I2085 n1_m1_129600_206400 0 7.933036e-07
I2086 n1_m1_129600_211200 0 1.390000e-07
I2087 n1_m1_129600_216000 0 8.061333e-07
I2088 n1_m1_129600_220800 0 8.563568e-07
I2089 n1_m1_129600_225600 0 8.990714e-07
I2090 n1_m1_129600_230400 0 6.719286e-07
I2091 n1_m1_129600_235200 0 4.499250e-07
I2092 n1_m1_129600_240000 0 8.531143e-07
I2093 n1_m1_129600_244800 0 3.085143e-07
I2094 n1_m1_129600_249600 0 1.920089e-06
I2095 n1_m1_129600_254400 0 6.853214e-07
I2096 n1_m1_129600_259200 0 2.659429e-07
I2097 n1_m1_129600_264000 0 9.555762e-07
I2098 n1_m1_129600_268800 0 4.757333e-07
I2099 n1_m1_129600_273600 0 7.088494e-07
I2100 n1_m1_129600_278400 0 7.616234e-07
I2101 n1_m1_129600_283200 0 1.966944e-07
I2102 n1_m1_129600_288000 0 1.924879e-06
I2103 n1_m1_129600_292800 0 1.761467e-06
I2104 n1_m1_129600_297600 0 8.803349e-07
I2105 n1_m1_129600_302400 0 9.049318e-07
I2106 n1_m1_129600_307200 0 1.353125e-06
I2107 n1_m1_129600_312000 0 9.584304e-07
I2108 n1_m1_129600_316800 0 3.768160e-07
I2109 n1_m1_129600_321600 0 1.920403e-06
I2110 n1_m1_129600_326400 0 8.295905e-07
I2111 n1_m1_129600_331200 0 6.042616e-07
I2112 n1_m1_129600_336000 0 1.521988e-06
I2113 n1_m1_129600_340800 0 3.215838e-07
I2114 n1_m1_129600_345600 0 5.631027e-07
I2115 n1_m1_129600_350400 0 9.558971e-07
I2116 n1_m1_129600_355200 0 1.374571e-06
I2117 n1_m1_129600_360000 0 1.056292e-06
I2118 n1_m1_129600_364800 0 3.888220e-07
I2119 n1_m1_129600_369600 0 7.472002e-07
I2120 n1_m1_129600_374400 0 7.864232e-06
I2121 n1_m1_129600_379200 0 5.440179e-07
I2122 n1_m1_129600_384000 0 6.065086e-07
I2123 n1_m1_129600_388800 0 7.319698e-07
I2124 n1_m1_129600_393600 0 1.055247e-06
I2125 n1_m1_129600_398400 0 2.343451e-07
I2126 n1_m1_134400_4800 0 2.143432e-07
I2127 n1_m1_134400_9600 0 7.682597e-07
I2128 n1_m1_134400_14400 0 4.861857e-07
I2129 n1_m1_134400_19200 0 5.672238e-07
I2130 n1_m1_134400_24000 0 6.457773e-07
I2131 n1_m1_134400_28800 0 4.714286e-08
I2132 n1_m1_134400_33600 0 8.011216e-07
I2133 n1_m1_134400_38400 0 2.712308e-07
I2134 n1_m1_134400_43200 0 7.117637e-07
I2135 n1_m1_134400_48000 0 7.614202e-07
I2136 n1_m1_134400_52800 0 1.051571e-07
I2137 n1_m1_134400_57600 0 1.403217e-06
I2138 n1_m1_134400_62400 0 3.298800e-07
I2139 n1_m1_134400_67200 0 1.829357e-07
I2140 n1_m1_134400_72000 0 5.509420e-07
I2141 n1_m1_134400_76800 0 1.692959e-07
I2142 n1_m1_134400_81600 0 2.810583e-07
I2143 n1_m1_134400_86400 0 3.746667e-07
I2144 n1_m1_134400_91200 0 1.372000e-07
I2145 n1_m1_134400_96000 0 5.579635e-07
I2146 n1_m1_134400_100800 0 4.620357e-07
I2147 n1_m1_134400_105600 0 2.531000e-07
I2148 n1_m1_134400_110400 0 3.261270e-07
I2149 n1_m1_134400_115200 0 2.143794e-07
I2150 n1_m1_134400_120000 0 3.206286e-07
I2151 n1_m1_134400_124800 0 2.346339e-07
I2152 n1_m1_134400_129600 0 1.109482e-07
I2153 n1_m1_134400_134400 0 1.307690e-07
I2154 n1_m1_134400_139200 0 8.357143e-08
I2155 n1_m1_134400_144000 0 4.840381e-07
I2156 n1_m1_134400_148800 0 1.888135e-07
I2157 n1_m1_134400_153600 0 5.387179e-07
I2158 n1_m1_134400_158400 0 4.916571e-07
I2159 n1_m1_134400_163200 0 5.780214e-07
I2160 n1_m1_134400_168000 0 6.800837e-07
I2161 n1_m1_134400_172800 0 2.774449e-07
I2162 n1_m1_134400_177600 0 8.209286e-07
I2163 n1_m1_134400_182400 0 4.168714e-07
I2164 n1_m1_134400_187200 0 1.581619e-07
I2165 n1_m1_134400_192000 0 1.025744e-06
I2166 n1_m1_134400_196800 0 3.370675e-07
I2167 n1_m1_134400_201600 0 3.744424e-07
I2168 n1_m1_134400_206400 0 5.792393e-07
I2169 n1_m1_134400_211200 0 2.894444e-07
I2170 n1_m1_134400_216000 0 2.709524e-07
I2171 n1_m1_134400_220800 0 6.278961e-07
I2172 n1_m1_134400_225600 0 5.086000e-07
I2173 n1_m1_134400_230400 0 3.265143e-07
I2174 n1_m1_134400_235200 0 1.884857e-07
I2175 n1_m1_134400_240000 0 7.169357e-07
I2176 n1_m1_134400_244800 0 1.634455e-07
I2177 n1_m1_134400_249600 0 8.827458e-07
I2178 n1_m1_134400_254400 0 4.417704e-07
I2179 n1_m1_134400_259200 0 7.875238e-08
I2180 n1_m1_134400_264000 0 3.900881e-07
I2181 n1_m1_134400_268800 0 2.978143e-07
I2182 n1_m1_134400_273600 0 4.590649e-07
I2183 n1_m1_134400_278400 0 4.625195e-07
I2184 n1_m1_134400_283200 0 3.381948e-07
I2185 n1_m1_134400_288000 0 1.241476e-06
I2186 n1_m1_134400_292800 0 1.963187e-07
I2187 n1_m1_134400_297600 0 1.093652e-06
I2188 n1_m1_134400_302400 0 5.845087e-07
I2189 n1_m1_134400_307200 0 2.129375e-07
I2190 n1_m1_134400_312000 0 6.318393e-07
I2191 n1_m1_134400_316800 0 5.149947e-07
I2192 n1_m1_134400_321600 0 5.640832e-07
I2193 n1_m1_134400_326400 0 4.425010e-07
I2194 n1_m1_134400_331200 0 5.941637e-07
I2195 n1_m1_134400_336000 0 6.874039e-07
I2196 n1_m1_134400_340800 0 6.057198e-07
I2197 n1_m1_134400_345600 0 7.956607e-07
I2198 n1_m1_134400_350400 0 3.336071e-07
I2199 n1_m1_134400_355200 0 5.423929e-07
I2200 n1_m1_134400_360000 0 2.181655e-07
I2201 n1_m1_134400_364800 0 5.056071e-07
I2202 n1_m1_134400_369600 0 8.543593e-07
I2203 n1_m1_134400_374400 0 2.009187e-07
I2204 n1_m1_134400_379200 0 6.955682e-07
I2205 n1_m1_134400_384000 0 4.867482e-07
I2206 n1_m1_134400_388800 0 5.274180e-07
I2207 n1_m1_134400_393600 0 9.171096e-07
I2208 n1_m1_134400_398400 0 1.716204e-07
I2209 n1_m1_139200_4800 0 2.046154e-07
I2210 n1_m1_139200_9600 0 9.727558e-07
I2211 n1_m1_139200_14400 0 3.710824e-07
I2212 n1_m1_139200_19200 0 4.634048e-07
I2213 n1_m1_139200_24000 0 9.292236e-07
I2214 n1_m1_139200_28800 0 1.019121e-07
I2215 n1_m1_139200_33600 0 6.497466e-07
I2216 n1_m1_139200_38400 0 2.485487e-07
I2217 n1_m1_139200_43200 0 3.457747e-07
I2218 n1_m1_139200_48000 0 8.583929e-07
I2219 n1_m1_139200_52800 0 2.547723e-07
I2220 n1_m1_139200_57600 0 9.922415e-07
I2221 n1_m1_139200_62400 0 4.236057e-07
I2222 n1_m1_139200_67200 0 1.102500e-07
I2223 n1_m1_139200_72000 0 1.116394e-06
I2224 n1_m1_139200_76800 0 1.487143e-07
I2225 n1_m1_139200_81600 0 5.768631e-07
I2226 n1_m1_139200_86400 0 2.468989e-07
I2227 n1_m1_139200_91200 0 2.379678e-07
I2228 n1_m1_139200_96000 0 4.431357e-07
I2229 n1_m1_139200_100800 0 2.064429e-07
I2230 n1_m1_139200_105600 0 5.586571e-07
I2231 n1_m1_139200_110400 0 8.221746e-07
I2232 n1_m1_139200_115200 0 3.505127e-07
I2233 n1_m1_139200_120000 0 7.525944e-07
I2234 n1_m1_139200_124800 0 9.738393e-08
I2235 n1_m1_139200_129600 0 5.565881e-07
I2236 n1_m1_139200_134400 0 9.758197e-08
I2237 n1_m1_139200_139200 0 6.571429e-09
I2238 n1_m1_139200_144000 0 4.962585e-07
I2239 n1_m1_139200_148800 0 1.962079e-07
I2240 n1_m1_139200_153600 0 3.753202e-07
I2241 n1_m1_139200_158400 0 3.264429e-07
I2242 n1_m1_139200_163200 0 2.005143e-07
I2243 n1_m1_139200_168000 0 7.740357e-07
I2244 n1_m1_139200_172800 0 2.114286e-07
I2245 n1_m1_139200_177600 0 3.756500e-07
I2246 n1_m1_139200_182400 0 4.587143e-07
I2247 n1_m1_139200_187200 0 4.232857e-07
I2248 n1_m1_139200_192000 0 1.010656e-06
I2249 n1_m1_139200_196800 0 7.216245e-07
I2250 n1_m1_139200_201600 0 4.671565e-07
I2251 n1_m1_139200_206400 0 1.997143e-06
I2252 n1_m1_139200_211200 0 1.022675e-06
I2253 n1_m1_139200_216000 0 4.246294e-07
I2254 n1_m1_139200_220800 0 5.600420e-07
I2255 n1_m1_139200_225600 0 7.831693e-06
I2256 n1_m1_139200_230400 0 1.947571e-07
I2257 n1_m1_139200_235200 0 6.700000e-08
I2258 n1_m1_139200_240000 0 3.217857e-07
I2259 n1_m1_139200_244800 0 2.037208e-07
I2260 n1_m1_139200_249600 0 6.626467e-07
I2261 n1_m1_139200_254400 0 9.764388e-08
I2262 n1_m1_139200_259200 0 6.422619e-07
I2263 n1_m1_139200_264000 0 8.496071e-07
I2264 n1_m1_139200_268800 0 5.337381e-07
I2265 n1_m1_139200_273600 0 5.857857e-07
I2266 n1_m1_139200_278400 0 6.531548e-07
I2267 n1_m1_139200_283200 0 5.761088e-07
I2268 n1_m1_139200_288000 0 4.570046e-07
I2269 n1_m1_139200_292800 0 1.609286e-07
I2270 n1_m1_139200_297600 0 4.301549e-07
I2271 n1_m1_139200_302400 0 2.674810e-07
I2272 n1_m1_139200_307200 0 2.462768e-07
I2273 n1_m1_139200_312000 0 1.010546e-06
I2274 n1_m1_139200_316800 0 1.376006e-07
I2275 n1_m1_139200_321600 0 1.457369e-07
I2276 n1_m1_139200_326400 0 1.750239e-07
I2277 n1_m1_139200_331200 0 7.770397e-08
I2278 n1_m1_139200_336000 0 9.615324e-07
I2279 n1_m1_139200_340800 0 4.572107e-07
I2280 n1_m1_139200_345600 0 4.709992e-07
I2281 n1_m1_139200_350400 0 2.142857e-07
I2282 n1_m1_139200_355200 0 7.094643e-07
I2283 n1_m1_139200_360000 0 3.381536e-07
I2284 n1_m1_139200_364800 0 2.438063e-07
I2285 n1_m1_139200_369600 0 9.667185e-07
I2286 n1_m1_139200_374400 0 5.016513e-07
I2287 n1_m1_139200_379200 0 3.796273e-07
I2288 n1_m1_139200_384000 0 1.791467e-06
I2289 n1_m1_139200_388800 0 4.128951e-07
I2290 n1_m1_139200_393600 0 7.310397e-07
I2291 n1_m1_139200_398400 0 1.771366e-07
I2292 n1_m1_144000_4800 0 2.601420e-07
I2293 n1_m1_144000_9600 0 1.012188e-06
I2294 n1_m1_144000_14400 0 6.099946e-07
I2295 n1_m1_144000_19200 0 5.328449e-07
I2296 n1_m1_144000_24000 0 9.848178e-07
I2297 n1_m1_144000_28800 0 2.627736e-07
I2298 n1_m1_144000_33600 0 1.066985e-06
I2299 n1_m1_144000_38400 0 4.992791e-07
I2300 n1_m1_144000_43200 0 4.438192e-07
I2301 n1_m1_144000_48000 0 1.353432e-06
I2302 n1_m1_144000_52800 0 6.258991e-07
I2303 n1_m1_144000_57600 0 1.197834e-06
I2304 n1_m1_144000_62400 0 7.449500e-07
I2305 n1_m1_144000_67200 0 2.228286e-07
I2306 n1_m1_144000_72000 0 7.733855e-07
I2307 n1_m1_144000_76800 0 3.634760e-07
I2308 n1_m1_144000_81600 0 6.680786e-07
I2309 n1_m1_144000_86400 0 5.796048e-07
I2310 n1_m1_144000_91200 0 2.704533e-07
I2311 n1_m1_144000_96000 0 5.551744e-07
I2312 n1_m1_144000_100800 0 6.246562e-07
I2313 n1_m1_144000_105600 0 5.217270e-07
I2314 n1_m1_144000_110400 0 5.845714e-07
I2315 n1_m1_144000_115200 0 1.915559e-07
I2316 n1_m1_144000_120000 0 9.006932e-07
I2317 n1_m1_144000_124800 0 4.008750e-07
I2318 n1_m1_144000_129600 0 1.835356e-06
I2319 n1_m1_144000_134400 0 4.452486e-07
I2320 n1_m1_144000_139200 0 7.755551e-07
I2321 n1_m1_144000_144000 0 9.116376e-07
I2322 n1_m1_144000_148800 0 4.266214e-07
I2323 n1_m1_144000_153600 0 8.520416e-07
I2324 n1_m1_144000_158400 0 7.092629e-07
I2325 n1_m1_144000_163200 0 1.089438e-06
I2326 n1_m1_144000_168000 0 1.093764e-06
I2327 n1_m1_144000_172800 0 6.538000e-07
I2328 n1_m1_144000_177600 0 8.003071e-07
I2329 n1_m1_144000_182400 0 1.678100e-06
I2330 n1_m1_144000_187200 0 9.080000e-08
I2331 n1_m1_144000_192000 0 1.208757e-06
I2332 n1_m1_144000_196800 0 1.649084e-06
I2333 n1_m1_144000_201600 0 1.527470e-06
I2334 n1_m1_144000_206400 0 7.937728e-07
I2335 n1_m1_144000_211200 0 9.557218e-07
I2336 n1_m1_144000_216000 0 4.004870e-07
I2337 n1_m1_144000_220800 0 3.067476e-07
I2338 n1_m1_144000_225600 0 1.014200e-06
I2339 n1_m1_144000_230400 0 3.015735e-07
I2340 n1_m1_144000_235200 0 4.390000e-07
I2341 n1_m1_144000_240000 0 1.170351e-06
I2342 n1_m1_144000_244800 0 5.980566e-07
I2343 n1_m1_144000_249600 0 8.592325e-07
I2344 n1_m1_144000_254400 0 4.411786e-07
I2345 n1_m1_144000_259200 0 3.278473e-07
I2346 n1_m1_144000_264000 0 6.085176e-07
I2347 n1_m1_144000_268800 0 6.377111e-07
I2348 n1_m1_144000_273600 0 1.231357e-06
I2349 n1_m1_144000_278400 0 9.014881e-07
I2350 n1_m1_144000_283200 0 4.679787e-07
I2351 n1_m1_144000_288000 0 5.416686e-07
I2352 n1_m1_144000_292800 0 5.428929e-07
I2353 n1_m1_144000_297600 0 1.363462e-06
I2354 n1_m1_144000_302400 0 9.609911e-07
I2355 n1_m1_144000_307200 0 6.186786e-07
I2356 n1_m1_144000_312000 0 6.452202e-06
I2357 n1_m1_144000_316800 0 1.339009e-06
I2358 n1_m1_144000_321600 0 2.111089e-07
I2359 n1_m1_144000_326400 0 2.539795e-07
I2360 n1_m1_144000_331200 0 3.516138e-07
I2361 n1_m1_144000_336000 0 1.337700e-06
I2362 n1_m1_144000_340800 0 3.853333e-07
I2363 n1_m1_144000_345600 0 1.329825e-06
I2364 n1_m1_144000_350400 0 2.973013e-07
I2365 n1_m1_144000_355200 0 7.136970e-07
I2366 n1_m1_144000_360000 0 4.742857e-07
I2367 n1_m1_144000_364800 0 4.397144e-07
I2368 n1_m1_144000_369600 0 1.142959e-06
I2369 n1_m1_144000_374400 0 3.779793e-07
I2370 n1_m1_144000_379200 0 9.327030e-07
I2371 n1_m1_144000_384000 0 1.356042e-06
I2372 n1_m1_144000_388800 0 7.618435e-07
I2373 n1_m1_144000_393600 0 1.013630e-06
I2374 n1_m1_144000_398400 0 2.062041e-07
I2375 n1_m1_148800_4800 0 2.140118e-07
I2376 n1_m1_148800_9600 0 7.560307e-07
I2377 n1_m1_148800_14400 0 4.464230e-07
I2378 n1_m1_148800_19200 0 3.197551e-07
I2379 n1_m1_148800_24000 0 1.291836e-06
I2380 n1_m1_148800_28800 0 4.777204e-06
I2381 n1_m1_148800_33600 0 6.798556e-07
I2382 n1_m1_148800_38400 0 8.761041e-07
I2383 n1_m1_148800_43200 0 1.923423e-07
I2384 n1_m1_148800_48000 0 1.785837e-06
I2385 n1_m1_148800_52800 0 6.716786e-07
I2386 n1_m1_148800_57600 0 4.369884e-07
I2387 n1_m1_148800_62400 0 4.283346e-07
I2388 n1_m1_148800_67200 0 1.498531e-07
I2389 n1_m1_148800_72000 0 7.868269e-07
I2390 n1_m1_148800_76800 0 4.764852e-07
I2391 n1_m1_148800_81600 0 2.661857e-07
I2392 n1_m1_148800_86400 0 4.611304e-07
I2393 n1_m1_148800_91200 0 1.553877e-07
I2394 n1_m1_148800_96000 0 6.901614e-07
I2395 n1_m1_148800_100800 0 6.676014e-07
I2396 n1_m1_148800_105600 0 2.474984e-07
I2397 n1_m1_148800_110400 0 3.000476e-07
I2398 n1_m1_148800_115200 0 3.289092e-07
I2399 n1_m1_148800_120000 0 8.896298e-07
I2400 n1_m1_148800_124800 0 1.050000e-07
I2401 n1_m1_148800_129600 0 3.766794e-07
I2402 n1_m1_148800_134400 0 2.049718e-07
I2403 n1_m1_148800_139200 0 1.355878e-07
I2404 n1_m1_148800_144000 0 1.721943e-07
I2405 n1_m1_148800_148800 0 2.219714e-07
I2406 n1_m1_148800_153600 0 2.039108e-07
I2407 n1_m1_148800_158400 0 2.778371e-07
I2408 n1_m1_148800_163200 0 2.074082e-08
I2409 n1_m1_148800_168000 0 2.807714e-07
I2410 n1_m1_148800_172800 0 2.644571e-07
I2411 n1_m1_148800_177600 0 9.377048e-07
I2412 n1_m1_148800_182400 0 4.653143e-07
I2413 n1_m1_148800_187200 0 5.131429e-08
I2414 n1_m1_148800_192000 0 2.436143e-07
I2415 n1_m1_148800_196800 0 6.741200e-07
I2416 n1_m1_148800_201600 0 7.902304e-07
I2417 n1_m1_148800_206400 0 3.679558e-07
I2418 n1_m1_148800_211200 0 3.311639e-07
I2419 n1_m1_148800_216000 0 1.087133e-06
I2420 n1_m1_148800_220800 0 8.210857e-07
I2421 n1_m1_148800_225600 0 1.256555e-06
I2422 n1_m1_148800_230400 0 5.291161e-07
I2423 n1_m1_148800_235200 0 1.367143e-07
I2424 n1_m1_148800_240000 0 5.547043e-07
I2425 n1_m1_148800_244800 0 1.071771e-07
I2426 n1_m1_148800_249600 0 1.855000e-07
I2427 n1_m1_148800_254400 0 2.922107e-07
I2428 n1_m1_148800_259200 0 2.576313e-07
I2429 n1_m1_148800_264000 0 1.155392e-06
I2430 n1_m1_148800_268800 0 1.185128e-06
I2431 n1_m1_148800_273600 0 3.999500e-07
I2432 n1_m1_148800_278400 0 1.302857e-07
I2433 n1_m1_148800_283200 0 7.406143e-07
I2434 n1_m1_148800_288000 0 1.052143e-07
I2435 n1_m1_148800_292800 0 2.666071e-07
I2436 n1_m1_148800_297600 0 2.870913e-07
I2437 n1_m1_148800_302400 0 2.602946e-07
I2438 n1_m1_148800_307200 0 2.991071e-07
I2439 n1_m1_148800_312000 0 1.468984e-06
I2440 n1_m1_148800_316800 0 3.668726e-07
I2441 n1_m1_148800_321600 0 8.556639e-07
I2442 n1_m1_148800_326400 0 5.006345e-07
I2443 n1_m1_148800_331200 0 1.291080e-07
I2444 n1_m1_148800_336000 0 5.594034e-07
I2445 n1_m1_148800_340800 0 5.192381e-07
I2446 n1_m1_148800_345600 0 7.182334e-07
I2447 n1_m1_148800_350400 0 2.478130e-07
I2448 n1_m1_148800_355200 0 5.451602e-07
I2449 n1_m1_148800_360000 0 9.888571e-07
I2450 n1_m1_148800_364800 0 3.931115e-07
I2451 n1_m1_148800_369600 0 6.964679e-07
I2452 n1_m1_148800_374400 0 3.704421e-07
I2453 n1_m1_148800_379200 0 7.574266e-07
I2454 n1_m1_148800_384000 0 6.769880e-07
I2455 n1_m1_148800_388800 0 9.487528e-07
I2456 n1_m1_148800_393600 0 7.625314e-07
I2457 n1_m1_148800_398400 0 3.188571e-07
I2458 n1_m1_153600_4800 0 3.690888e-07
I2459 n1_m1_153600_9600 0 8.084038e-07
I2460 n1_m1_153600_14400 0 6.854804e-07
I2461 n1_m1_153600_19200 0 6.074541e-07
I2462 n1_m1_153600_24000 0 9.366307e-07
I2463 n1_m1_153600_28800 0 3.502288e-06
I2464 n1_m1_153600_33600 0 1.068852e-06
I2465 n1_m1_153600_38400 0 4.250220e-07
I2466 n1_m1_153600_43200 0 4.747154e-07
I2467 n1_m1_153600_48000 0 1.175921e-06
I2468 n1_m1_153600_52800 0 1.683071e-07
I2469 n1_m1_153600_57600 0 1.109820e-06
I2470 n1_m1_153600_62400 0 7.207725e-07
I2471 n1_m1_153600_67200 0 9.372443e-07
I2472 n1_m1_153600_72000 0 4.303413e-07
I2473 n1_m1_153600_76800 0 7.942816e-07
I2474 n1_m1_153600_81600 0 1.043942e-06
I2475 n1_m1_153600_86400 0 5.804703e-07
I2476 n1_m1_153600_91200 0 3.546538e-07
I2477 n1_m1_153600_96000 0 2.942384e-06
I2478 n1_m1_153600_100800 0 1.485614e-06
I2479 n1_m1_153600_105600 0 4.749175e-07
I2480 n1_m1_153600_110400 0 4.263651e-07
I2481 n1_m1_153600_115200 0 4.859857e-07
I2482 n1_m1_153600_120000 0 7.793397e-07
I2483 n1_m1_153600_124800 0 8.500000e-08
I2484 n1_m1_153600_129600 0 3.072714e-07
I2485 n1_m1_153600_134400 0 4.920571e-08
I2486 n1_m1_153600_139200 0 2.393000e-07
I2487 n1_m1_153600_144000 0 9.510714e-07
I2488 n1_m1_153600_148800 0 6.102143e-07
I2489 n1_m1_153600_153600 0 5.861060e-07
I2490 n1_m1_153600_158400 0 3.517857e-07
I2491 n1_m1_153600_163200 0 4.888286e-07
I2492 n1_m1_153600_168000 0 1.106510e-06
I2493 n1_m1_153600_172800 0 6.306286e-07
I2494 n1_m1_153600_177600 0 1.727784e-06
I2495 n1_m1_153600_182400 0 1.025286e-07
I2496 n1_m1_153600_187200 0 5.134357e-07
I2497 n1_m1_153600_192000 0 7.257774e-07
I2498 n1_m1_153600_196800 0 3.927286e-07
I2499 n1_m1_153600_201600 0 4.636190e-07
I2500 n1_m1_153600_206400 0 3.183286e-07
I2501 n1_m1_153600_211200 0 1.321975e-06
I2502 n1_m1_153600_216000 0 1.304487e-06
I2503 n1_m1_153600_220800 0 1.131757e-06
I2504 n1_m1_153600_225600 0 8.012380e-07
I2505 n1_m1_153600_230400 0 9.275974e-07
I2506 n1_m1_153600_235200 0 6.726831e-07
I2507 n1_m1_153600_240000 0 2.977224e-07
I2508 n1_m1_153600_244800 0 9.965974e-07
I2509 n1_m1_153600_249600 0 7.498636e-07
I2510 n1_m1_153600_254400 0 3.109776e-07
I2511 n1_m1_153600_259200 0 1.051250e-06
I2512 n1_m1_153600_264000 0 5.803539e-07
I2513 n1_m1_153600_268800 0 4.024890e-07
I2514 n1_m1_153600_273600 0 6.522333e-07
I2515 n1_m1_153600_278400 0 6.574113e-07
I2516 n1_m1_153600_283200 0 5.237830e-07
I2517 n1_m1_153600_288000 0 1.187831e-07
I2518 n1_m1_153600_292800 0 7.543506e-07
I2519 n1_m1_153600_297600 0 1.182536e-06
I2520 n1_m1_153600_302400 0 5.246607e-07
I2521 n1_m1_153600_307200 0 1.190625e-06
I2522 n1_m1_153600_312000 0 1.042019e-06
I2523 n1_m1_153600_316800 0 9.578020e-07
I2524 n1_m1_153600_321600 0 8.843609e-07
I2525 n1_m1_153600_326400 0 8.733214e-07
I2526 n1_m1_153600_331200 0 6.292832e-07
I2527 n1_m1_153600_336000 0 4.373989e-07
I2528 n1_m1_153600_340800 0 8.056377e-07
I2529 n1_m1_153600_345600 0 9.666961e-07
I2530 n1_m1_153600_350400 0 1.644286e-07
I2531 n1_m1_153600_355200 0 1.340000e-07
I2532 n1_m1_153600_360000 0 7.868139e-07
I2533 n1_m1_153600_364800 0 2.705625e-07
I2534 n1_m1_153600_369600 0 7.218629e-07
I2535 n1_m1_153600_374400 0 8.189229e-07
I2536 n1_m1_153600_379200 0 1.513669e-06
I2537 n1_m1_153600_384000 0 9.471200e-07
I2538 n1_m1_153600_388800 0 6.029065e-07
I2539 n1_m1_153600_393600 0 7.463886e-07
I2540 n1_m1_153600_398400 0 2.451429e-07
I2541 n1_m1_158400_4800 0 1.487574e-07
I2542 n1_m1_158400_9600 0 6.565357e-07
I2543 n1_m1_158400_14400 0 6.429196e-07
I2544 n1_m1_158400_19200 0 2.793959e-07
I2545 n1_m1_158400_24000 0 4.927873e-07
I2546 n1_m1_158400_28800 0 3.924167e-07
I2547 n1_m1_158400_33600 0 4.560601e-07
I2548 n1_m1_158400_38400 0 2.719231e-07
I2549 n1_m1_158400_43200 0 6.129950e-07
I2550 n1_m1_158400_48000 0 7.300756e-07
I2551 n1_m1_158400_52800 0 6.771429e-08
I2552 n1_m1_158400_57600 0 5.572762e-07
I2553 n1_m1_158400_62400 0 2.650000e-07
I2554 n1_m1_158400_67200 0 7.914026e-07
I2555 n1_m1_158400_72000 0 3.655817e-07
I2556 n1_m1_158400_76800 0 7.693228e-07
I2557 n1_m1_158400_81600 0 1.032317e-06
I2558 n1_m1_158400_86400 0 8.786854e-07
I2559 n1_m1_158400_91200 0 3.282907e-07
I2560 n1_m1_158400_96000 0 6.465518e-07
I2561 n1_m1_158400_100800 0 3.285750e-07
I2562 n1_m1_158400_105600 0 6.071143e-07
I2563 n1_m1_158400_110400 0 2.903571e-07
I2564 n1_m1_158400_115200 0 7.839016e-07
I2565 n1_m1_158400_120000 0 5.064952e-07
I2566 n1_m1_158400_124800 0 4.509048e-07
I2567 n1_m1_158400_129600 0 3.327095e-07
I2568 n1_m1_158400_134400 0 1.298550e-07
I2569 n1_m1_158400_139200 0 1.647714e-07
I2570 n1_m1_158400_144000 0 9.109571e-07
I2571 n1_m1_158400_148800 0 5.215714e-07
I2572 n1_m1_158400_153600 0 4.930464e-07
I2573 n1_m1_158400_158400 0 2.352429e-07
I2574 n1_m1_158400_163200 0 2.364714e-07
I2575 n1_m1_158400_168000 0 4.331333e-07
I2576 n1_m1_158400_172800 0 8.846286e-07
I2577 n1_m1_158400_177600 0 1.377140e-06
I2578 n1_m1_158400_182400 0 7.842857e-08
I2579 n1_m1_158400_187200 0 2.797357e-07
I2580 n1_m1_158400_192000 0 1.451274e-07
I2581 n1_m1_158400_196800 0 9.290000e-08
I2582 n1_m1_158400_201600 0 3.600774e-07
I2583 n1_m1_158400_206400 0 1.447543e-07
I2584 n1_m1_158400_211200 0 4.502057e-07
I2585 n1_m1_158400_216000 0 7.083250e-07
I2586 n1_m1_158400_220800 0 1.066614e-06
I2587 n1_m1_158400_225600 0 1.346597e-06
I2588 n1_m1_158400_230400 0 1.091558e-07
I2589 n1_m1_158400_235200 0 1.879669e-07
I2590 n1_m1_158400_240000 0 6.091522e-07
I2591 n1_m1_158400_244800 0 5.404026e-07
I2592 n1_m1_158400_249600 0 6.060931e-07
I2593 n1_m1_158400_254400 0 1.925567e-07
I2594 n1_m1_158400_259200 0 4.201071e-07
I2595 n1_m1_158400_264000 0 7.626882e-07
I2596 n1_m1_158400_268800 0 7.262005e-07
I2597 n1_m1_158400_273600 0 2.029866e-07
I2598 n1_m1_158400_278400 0 2.347018e-07
I2599 n1_m1_158400_283200 0 5.068903e-07
I2600 n1_m1_158400_288000 0 8.362895e-07
I2601 n1_m1_158400_292800 0 6.436364e-07
I2602 n1_m1_158400_297600 0 3.668442e-07
I2603 n1_m1_158400_302400 0 7.868393e-07
I2604 n1_m1_158400_307200 0 3.250893e-07
I2605 n1_m1_158400_312000 0 8.251107e-07
I2606 n1_m1_158400_316800 0 2.990625e-07
I2607 n1_m1_158400_321600 0 4.667902e-07
I2608 n1_m1_158400_326400 0 4.326899e-07
I2609 n1_m1_158400_331200 0 5.392384e-07
I2610 n1_m1_158400_336000 0 3.258154e-07
I2611 n1_m1_158400_340800 0 5.130436e-07
I2612 n1_m1_158400_345600 0 1.134365e-06
I2613 n1_m1_158400_350400 0 3.222857e-07
I2614 n1_m1_158400_355200 0 4.771464e-07
I2615 n1_m1_158400_360000 0 3.101860e-07
I2616 n1_m1_158400_364800 0 6.720763e-07
I2617 n1_m1_158400_369600 0 7.723470e-07
I2618 n1_m1_158400_374400 0 4.343714e-07
I2619 n1_m1_158400_379200 0 5.076959e-07
I2620 n1_m1_158400_384000 0 7.017466e-07
I2621 n1_m1_158400_388800 0 6.766415e-07
I2622 n1_m1_158400_393600 0 9.236062e-07
I2623 n1_m1_158400_398400 0 2.006374e-07
I2624 n1_m1_163200_4800 0 2.492308e-07
I2625 n1_m1_163200_9600 0 6.112755e-07
I2626 n1_m1_163200_14400 0 2.981753e-07
I2627 n1_m1_163200_19200 0 3.309618e-07
I2628 n1_m1_163200_24000 0 7.423793e-07
I2629 n1_m1_163200_28800 0 4.291613e-07
I2630 n1_m1_163200_33600 0 3.919780e-07
I2631 n1_m1_163200_38400 0 6.340264e-07
I2632 n1_m1_163200_43200 0 4.128160e-07
I2633 n1_m1_163200_48000 0 8.753705e-07
I2634 n1_m1_163200_52800 0 4.182264e-07
I2635 n1_m1_163200_57600 0 3.969256e-07
I2636 n1_m1_163200_62400 0 4.553238e-07
I2637 n1_m1_163200_67200 0 1.200068e-06
I2638 n1_m1_163200_72000 0 7.654560e-07
I2639 n1_m1_163200_76800 0 3.694060e-07
I2640 n1_m1_163200_81600 0 4.551545e-07
I2641 n1_m1_163200_86400 0 4.020495e-07
I2642 n1_m1_163200_91200 0 3.175577e-07
I2643 n1_m1_163200_96000 0 5.673393e-06
I2644 n1_m1_163200_100800 0 2.379720e-06
I2645 n1_m1_163200_105600 0 4.922286e-07
I2646 n1_m1_163200_110400 0 7.714286e-08
I2647 n1_m1_163200_115200 0 8.029698e-07
I2648 n1_m1_163200_120000 0 3.476905e-07
I2649 n1_m1_163200_124800 0 1.575952e-07
I2650 n1_m1_163200_129600 0 8.609476e-07
I2651 n1_m1_163200_134400 0 1.409679e-07
I2652 n1_m1_163200_139200 0 1.673810e-07
I2653 n1_m1_163200_144000 0 1.548438e-06
I2654 n1_m1_163200_148800 0 2.475333e-07
I2655 n1_m1_163200_153600 0 1.111619e-07
I2656 n1_m1_163200_158400 0 3.941143e-07
I2657 n1_m1_163200_163200 0 1.267000e-07
I2658 n1_m1_163200_168000 0 2.380750e-07
I2659 n1_m1_163200_172800 0 3.811286e-07
I2660 n1_m1_163200_177600 0 9.635048e-07
I2661 n1_m1_163200_182400 0 6.917286e-07
I2662 n1_m1_163200_187200 0 3.231429e-07
I2663 n1_m1_163200_192000 0 4.164486e-07
I2664 n1_m1_163200_196800 0 1.561714e-07
I2665 n1_m1_163200_201600 0 2.993036e-07
I2666 n1_m1_163200_206400 0 2.045600e-07
I2667 n1_m1_163200_211200 0 7.771071e-07
I2668 n1_m1_163200_216000 0 2.901679e-07
I2669 n1_m1_163200_220800 0 5.381000e-07
I2670 n1_m1_163200_225600 0 9.542599e-07
I2671 n1_m1_163200_230400 0 5.084286e-07
I2672 n1_m1_163200_235200 0 1.523643e-07
I2673 n1_m1_163200_240000 0 9.973196e-07
I2674 n1_m1_163200_244800 0 3.231524e-07
I2675 n1_m1_163200_249600 0 5.641251e-07
I2676 n1_m1_163200_254400 0 3.340098e-07
I2677 n1_m1_163200_259200 0 7.817857e-07
I2678 n1_m1_163200_264000 0 6.007912e-07
I2679 n1_m1_163200_268800 0 3.964709e-07
I2680 n1_m1_163200_273600 0 3.473872e-07
I2681 n1_m1_163200_278400 0 3.371726e-07
I2682 n1_m1_163200_283200 0 3.648000e-07
I2683 n1_m1_163200_288000 0 2.827131e-07
I2684 n1_m1_163200_292800 0 5.721861e-07
I2685 n1_m1_163200_297600 0 4.122251e-07
I2686 n1_m1_163200_302400 0 6.026429e-07
I2687 n1_m1_163200_307200 0 4.604688e-07
I2688 n1_m1_163200_312000 0 4.443107e-07
I2689 n1_m1_163200_316800 0 4.317074e-07
I2690 n1_m1_163200_321600 0 2.960719e-07
I2691 n1_m1_163200_326400 0 7.725649e-07
I2692 n1_m1_163200_331200 0 2.447489e-07
I2693 n1_m1_163200_336000 0 5.695714e-08
I2694 n1_m1_163200_340800 0 2.666901e-07
I2695 n1_m1_163200_345600 0 7.765412e-07
I2696 n1_m1_163200_350400 0 2.704082e-07
I2697 n1_m1_163200_355200 0 8.009014e-07
I2698 n1_m1_163200_360000 0 4.676637e-07
I2699 n1_m1_163200_364800 0 5.004042e-07
I2700 n1_m1_163200_369600 0 6.275552e-07
I2701 n1_m1_163200_374400 0 4.465357e-07
I2702 n1_m1_163200_379200 0 2.457017e-07
I2703 n1_m1_163200_384000 0 6.775816e-07
I2704 n1_m1_163200_388800 0 4.614514e-07
I2705 n1_m1_163200_393600 0 8.619557e-07
I2706 n1_m1_163200_398400 0 1.679341e-07
I2707 n1_m1_168000_4800 0 6.000000e-07
I2708 n1_m1_168000_9600 0 9.376250e-07
I2709 n1_m1_168000_14400 0 4.165199e-07
I2710 n1_m1_168000_19200 0 4.094454e-07
I2711 n1_m1_168000_24000 0 7.177179e-07
I2712 n1_m1_168000_28800 0 6.988149e-07
I2713 n1_m1_168000_33600 0 8.813113e-07
I2714 n1_m1_168000_38400 0 7.777957e-07
I2715 n1_m1_168000_43200 0 3.905275e-07
I2716 n1_m1_168000_48000 0 7.417418e-07
I2717 n1_m1_168000_52800 0 5.807307e-07
I2718 n1_m1_168000_57600 0 9.697600e-07
I2719 n1_m1_168000_62400 0 1.486131e-06
I2720 n1_m1_168000_67200 0 1.501960e-06
I2721 n1_m1_168000_72000 0 1.190251e-06
I2722 n1_m1_168000_76800 0 7.999904e-07
I2723 n1_m1_168000_81600 0 2.426429e-07
I2724 n1_m1_168000_86400 0 4.624835e-07
I2725 n1_m1_168000_91200 0 9.289615e-07
I2726 n1_m1_168000_96000 0 1.057868e-06
I2727 n1_m1_168000_100800 0 6.934448e-07
I2728 n1_m1_168000_105600 0 7.250367e-07
I2729 n1_m1_168000_110400 0 8.957292e-07
I2730 n1_m1_168000_115200 0 2.866095e-07
I2731 n1_m1_168000_120000 0 6.143714e-07
I2732 n1_m1_168000_124800 0 4.285714e-07
I2733 n1_m1_168000_129600 0 1.323229e-06
I2734 n1_m1_168000_134400 0 4.653667e-07
I2735 n1_m1_168000_139200 0 8.819048e-08
I2736 n1_m1_168000_144000 0 1.337705e-06
I2737 n1_m1_168000_148800 0 7.333667e-07
I2738 n1_m1_168000_153600 0 1.791952e-07
I2739 n1_m1_168000_158400 0 1.184914e-06
I2740 n1_m1_168000_163200 0 1.821793e-06
I2741 n1_m1_168000_168000 0 8.210393e-07
I2742 n1_m1_168000_172800 0 5.100429e-07
I2743 n1_m1_168000_177600 0 2.170852e-06
I2744 n1_m1_168000_182400 0 1.086286e-07
I2745 n1_m1_168000_187200 0 6.225143e-07
I2746 n1_m1_168000_192000 0 1.221604e-06
I2747 n1_m1_168000_196800 0 5.849000e-07
I2748 n1_m1_168000_201600 0 4.690429e-07
I2749 n1_m1_168000_206400 0 3.294571e-07
I2750 n1_m1_168000_211200 0 7.354500e-07
I2751 n1_m1_168000_216000 0 9.482667e-07
I2752 n1_m1_168000_220800 0 1.430000e-07
I2753 n1_m1_168000_225600 0 1.249329e-06
I2754 n1_m1_168000_230400 0 4.285143e-07
I2755 n1_m1_168000_235200 0 6.565714e-08
I2756 n1_m1_168000_240000 0 1.295270e-06
I2757 n1_m1_168000_244800 0 6.961501e-07
I2758 n1_m1_168000_249600 0 1.339603e-06
I2759 n1_m1_168000_254400 0 3.501737e-07
I2760 n1_m1_168000_259200 0 9.639167e-07
I2761 n1_m1_168000_264000 0 6.036286e-07
I2762 n1_m1_168000_268800 0 4.704429e-07
I2763 n1_m1_168000_273600 0 5.032857e-07
I2764 n1_m1_168000_278400 0 4.640714e-07
I2765 n1_m1_168000_283200 0 8.086630e-06
I2766 n1_m1_168000_288000 0 1.154280e-06
I2767 n1_m1_168000_292800 0 7.434449e-07
I2768 n1_m1_168000_297600 0 4.211476e-07
I2769 n1_m1_168000_302400 0 7.190714e-07
I2770 n1_m1_168000_307200 0 1.296784e-06
I2771 n1_m1_168000_312000 0 8.921475e-07
I2772 n1_m1_168000_316800 0 8.089890e-07
I2773 n1_m1_168000_321600 0 1.209965e-06
I2774 n1_m1_168000_326400 0 9.605166e-07
I2775 n1_m1_168000_331200 0 5.322498e-07
I2776 n1_m1_168000_336000 0 8.469286e-07
I2777 n1_m1_168000_340800 0 7.425429e-07
I2778 n1_m1_168000_345600 0 7.562911e-07
I2779 n1_m1_168000_350400 0 1.936240e-06
I2780 n1_m1_168000_355200 0 2.031921e-06
I2781 n1_m1_168000_360000 0 3.345507e-07
I2782 n1_m1_168000_364800 0 6.806654e-07
I2783 n1_m1_168000_369600 0 7.104621e-07
I2784 n1_m1_168000_374400 0 4.737277e-07
I2785 n1_m1_168000_379200 0 3.612665e-06
I2786 n1_m1_168000_384000 0 4.854979e-06
I2787 n1_m1_168000_388800 0 5.217690e-07
I2788 n1_m1_168000_393600 0 6.014500e-07
I2789 n1_m1_168000_398400 0 2.014286e-07
I2790 n1_m1_172800_4800 0 6.873373e-08
I2791 n1_m1_172800_9600 0 3.562933e-07
I2792 n1_m1_172800_14400 0 1.498125e-07
I2793 n1_m1_172800_19200 0 5.696703e-08
I2794 n1_m1_172800_24000 0 4.874680e-07
I2795 n1_m1_172800_28800 0 7.523077e-08
I2796 n1_m1_172800_33600 0 4.515625e-07
I2797 n1_m1_172800_38400 0 2.028173e-07
I2798 n1_m1_172800_43200 0 5.993303e-07
I2799 n1_m1_172800_48000 0 4.592569e-07
I2800 n1_m1_172800_52800 0 4.071429e-08
I2801 n1_m1_172800_57600 0 8.962334e-07
I2802 n1_m1_172800_62400 0 2.700495e-07
I2803 n1_m1_172800_67200 0 3.619780e-08
I2804 n1_m1_172800_72000 0 1.648281e-07
I2805 n1_m1_172800_76800 0 1.238044e-07
I2806 n1_m1_172800_81600 0 2.939286e-07
I2807 n1_m1_172800_86400 0 2.257671e-07
I2808 n1_m1_172800_91200 0 4.799103e-08
I2809 n1_m1_172800_96000 0 8.428571e-08
I2810 n1_m1_172800_100800 0 1.283723e-07
I2811 n1_m1_172800_105600 0 3.780763e-07
I2812 n1_m1_172800_110400 0 1.465625e-07
I2813 n1_m1_172800_115200 0 8.986250e-08
I2814 n1_m1_172800_120000 0 3.168119e-07
I2815 n1_m1_172800_124800 0 1.187857e-07
I2816 n1_m1_172800_129600 0 1.295083e-07
I2817 n1_m1_172800_134400 0 1.775933e-08
I2818 n1_m1_172800_144000 0 1.249429e-07
I2819 n1_m1_172800_148800 0 2.100000e-08
I2820 n1_m1_172800_153600 0 4.061173e-08
I2821 n1_m1_172800_158400 0 1.113946e-08
I2822 n1_m1_172800_163200 0 4.163571e-08
I2823 n1_m1_172800_168000 0 1.147821e-07
I2824 n1_m1_172800_172800 0 1.540393e-07
I2825 n1_m1_172800_177600 0 1.352804e-07
I2826 n1_m1_172800_182400 0 9.042857e-09
I2827 n1_m1_172800_187200 0 2.860000e-08
I2828 n1_m1_172800_192000 0 9.274464e-08
I2829 n1_m1_172800_196800 0 6.267857e-08
I2830 n1_m1_172800_201600 0 9.589524e-08
I2831 n1_m1_172800_206400 0 2.111429e-07
I2832 n1_m1_172800_211200 0 6.373214e-08
I2833 n1_m1_172800_216000 0 3.059143e-07
I2834 n1_m1_172800_220800 0 3.587063e-07
I2835 n1_m1_172800_225600 0 2.345000e-07
I2836 n1_m1_172800_230400 0 1.260000e-07
I2837 n1_m1_172800_235200 0 2.185000e-07
I2838 n1_m1_172800_240000 0 3.261038e-07
I2839 n1_m1_172800_244800 0 2.316172e-07
I2840 n1_m1_172800_249600 0 1.426169e-07
I2841 n1_m1_172800_254400 0 1.980821e-07
I2842 n1_m1_172800_259200 0 4.088571e-08
I2843 n1_m1_172800_264000 0 1.796381e-07
I2844 n1_m1_172800_268800 0 1.721095e-07
I2845 n1_m1_172800_273600 0 3.304302e-07
I2846 n1_m1_172800_278400 0 1.511111e-07
I2847 n1_m1_172800_283200 0 3.612679e-07
I2848 n1_m1_172800_288000 0 4.683446e-07
I2849 n1_m1_172800_292800 0 2.095527e-07
I2850 n1_m1_172800_297600 0 9.045332e-08
I2851 n1_m1_172800_302400 0 7.557143e-08
I2852 n1_m1_172800_307200 0 3.754126e-07
I2853 n1_m1_172800_312000 0 2.838214e-07
I2854 n1_m1_172800_316800 0 2.864911e-07
I2855 n1_m1_172800_321600 0 3.298750e-07
I2856 n1_m1_172800_326400 0 4.148571e-08
I2857 n1_m1_172800_331200 0 3.797000e-07
I2858 n1_m1_172800_336000 0 2.708929e-07
I2859 n1_m1_172800_340800 0 1.974857e-07
I2860 n1_m1_172800_345600 0 2.446371e-07
I2861 n1_m1_172800_350400 0 5.671633e-07
I2862 n1_m1_172800_355200 0 7.670748e-07
I2863 n1_m1_172800_360000 0 3.713015e-07
I2864 n1_m1_172800_364800 0 1.787640e-07
I2865 n1_m1_172800_369600 0 2.770663e-07
I2866 n1_m1_172800_374400 0 8.070089e-07
I2867 n1_m1_172800_379200 0 2.745843e-07
I2868 n1_m1_172800_384000 0 4.047933e-07
I2869 n1_m1_172800_388800 0 1.577143e-07
I2870 n1_m1_172800_393600 0 5.019312e-07
I2871 n1_m1_172800_398400 0 9.391648e-08
I2872 n1_m1_177600_4800 0 3.171124e-07
I2873 n1_m1_177600_9600 0 1.002604e-06
I2874 n1_m1_177600_14400 0 9.090089e-07
I2875 n1_m1_177600_19200 0 5.544143e-07
I2876 n1_m1_177600_24000 0 1.599431e-06
I2877 n1_m1_177600_28800 0 5.341585e-07
I2878 n1_m1_177600_33600 0 3.656054e-07
I2879 n1_m1_177600_38400 0 5.651214e-07
I2880 n1_m1_177600_43200 0 9.480715e-07
I2881 n1_m1_177600_48000 0 7.409411e-07
I2882 n1_m1_177600_52800 0 3.146652e-07
I2883 n1_m1_177600_57600 0 1.015138e-06
I2884 n1_m1_177600_62400 0 6.906786e-07
I2885 n1_m1_177600_67200 0 4.447143e-07
I2886 n1_m1_177600_72000 0 1.561199e-06
I2887 n1_m1_177600_76800 0 1.745495e-07
I2888 n1_m1_177600_81600 0 8.575343e-07
I2889 n1_m1_177600_86400 0 9.326379e-07
I2890 n1_m1_177600_91200 0 7.998299e-07
I2891 n1_m1_177600_96000 0 8.425429e-07
I2892 n1_m1_177600_100800 0 5.300981e-07
I2893 n1_m1_177600_105600 0 7.893056e-07
I2894 n1_m1_177600_110400 0 1.460317e-07
I2895 n1_m1_177600_115200 0 2.735280e-07
I2896 n1_m1_177600_120000 0 1.155417e-06
I2897 n1_m1_177600_124800 0 2.710714e-07
I2898 n1_m1_177600_129600 0 5.317502e-07
I2899 n1_m1_177600_134400 0 2.821980e-07
I2900 n1_m1_177600_139200 0 1.133929e-07
I2901 n1_m1_177600_144000 0 2.885143e-07
I2902 n1_m1_177600_148800 0 2.882714e-07
I2903 n1_m1_177600_153600 0 1.821005e-07
I2904 n1_m1_177600_158400 0 1.308483e-07
I2905 n1_m1_177600_163200 0 9.615000e-08
I2906 n1_m1_177600_168000 0 3.126393e-07
I2907 n1_m1_177600_172800 0 3.392179e-07
I2908 n1_m1_177600_177600 0 1.102254e-07
I2909 n1_m1_177600_182400 0 4.260395e-07
I2910 n1_m1_177600_187200 0 7.796571e-07
I2911 n1_m1_177600_192000 0 9.597411e-07
I2912 n1_m1_177600_196800 0 7.919738e-07
I2913 n1_m1_177600_201600 0 9.353238e-07
I2914 n1_m1_177600_206400 0 4.141473e-07
I2915 n1_m1_177600_211200 0 7.413997e-07
I2916 n1_m1_177600_216000 0 8.020571e-07
I2917 n1_m1_177600_220800 0 8.054587e-07
I2918 n1_m1_177600_225600 0 5.186971e-07
I2919 n1_m1_177600_230400 0 7.150971e-07
I2920 n1_m1_177600_235200 0 1.019357e-06
I2921 n1_m1_177600_240000 0 5.478468e-07
I2922 n1_m1_177600_244800 0 5.418857e-07
I2923 n1_m1_177600_249600 0 6.581143e-07
I2924 n1_m1_177600_254400 0 5.902526e-07
I2925 n1_m1_177600_259200 0 5.221224e-07
I2926 n1_m1_177600_264000 0 6.958492e-07
I2927 n1_m1_177600_268800 0 4.284968e-07
I2928 n1_m1_177600_273600 0 4.768000e-07
I2929 n1_m1_177600_278400 0 5.821714e-07
I2930 n1_m1_177600_283200 0 6.444493e-07
I2931 n1_m1_177600_288000 0 3.447500e-07
I2932 n1_m1_177600_292800 0 4.291213e-07
I2933 n1_m1_177600_297600 0 1.630758e-06
I2934 n1_m1_177600_302400 0 5.218505e-07
I2935 n1_m1_177600_307200 0 8.023051e-07
I2936 n1_m1_177600_312000 0 9.484129e-07
I2937 n1_m1_177600_316800 0 1.756555e-06
I2938 n1_m1_177600_321600 0 7.383283e-06
I2939 n1_m1_177600_326400 0 4.596408e-07
I2940 n1_m1_177600_331200 0 7.009286e-07
I2941 n1_m1_177600_336000 0 7.648136e-07
I2942 n1_m1_177600_340800 0 6.360753e-07
I2943 n1_m1_177600_345600 0 1.114728e-06
I2944 n1_m1_177600_350400 0 1.199865e-06
I2945 n1_m1_177600_355200 0 7.886531e-07
I2946 n1_m1_177600_360000 0 1.384716e-06
I2947 n1_m1_177600_364800 0 7.648074e-07
I2948 n1_m1_177600_369600 0 5.839334e-07
I2949 n1_m1_177600_374400 0 7.818590e-07
I2950 n1_m1_177600_379200 0 5.758773e-07
I2951 n1_m1_177600_384000 0 1.107710e-06
I2952 n1_m1_177600_388800 0 5.632429e-07
I2953 n1_m1_177600_393600 0 8.470141e-07
I2954 n1_m1_177600_398400 0 3.584571e-07
I2955 n1_m1_182400_4800 0 1.872000e-07
I2956 n1_m1_182400_9600 0 7.836400e-07
I2957 n1_m1_182400_14400 0 6.433527e-07
I2958 n1_m1_182400_19200 0 2.987234e-07
I2959 n1_m1_182400_24000 0 6.969181e-07
I2960 n1_m1_182400_28800 0 3.452500e-07
I2961 n1_m1_182400_33600 0 3.359615e-07
I2962 n1_m1_182400_38400 0 5.510661e-07
I2963 n1_m1_182400_43200 0 6.135251e-07
I2964 n1_m1_182400_48000 0 7.607960e-07
I2965 n1_m1_182400_52800 0 2.617945e-07
I2966 n1_m1_182400_57600 0 1.138073e-06
I2967 n1_m1_182400_62400 0 3.158535e-07
I2968 n1_m1_182400_67200 0 1.190000e-07
I2969 n1_m1_182400_72000 0 5.553222e-07
I2970 n1_m1_182400_76800 0 1.103626e-07
I2971 n1_m1_182400_81600 0 1.221686e-07
I2972 n1_m1_182400_86400 0 3.608544e-07
I2973 n1_m1_182400_91200 0 5.072555e-07
I2974 n1_m1_182400_96000 0 2.071746e-07
I2975 n1_m1_182400_100800 0 3.293884e-07
I2976 n1_m1_182400_105600 0 6.282837e-07
I2977 n1_m1_182400_110400 0 2.107540e-07
I2978 n1_m1_182400_115200 0 1.246381e-08
I2979 n1_m1_182400_120000 0 4.863543e-07
I2980 n1_m1_182400_124800 0 1.022143e-07
I2981 n1_m1_182400_129600 0 2.543939e-07
I2982 n1_m1_182400_134400 0 1.992276e-07
I2983 n1_m1_182400_139200 0 9.210714e-08
I2984 n1_m1_182400_144000 0 3.542029e-07
I2985 n1_m1_182400_148800 0 3.286333e-07
I2986 n1_m1_182400_153600 0 1.835102e-07
I2987 n1_m1_182400_158400 0 4.664694e-08
I2988 n1_m1_182400_163200 0 4.439762e-08
I2989 n1_m1_182400_168000 0 1.163000e-07
I2990 n1_m1_182400_172800 0 9.957143e-08
I2991 n1_m1_182400_177600 0 7.515143e-08
I2992 n1_m1_182400_182400 0 3.773335e-07
I2993 n1_m1_182400_187200 0 2.434286e-07
I2994 n1_m1_182400_192000 0 3.662857e-07
I2995 n1_m1_182400_196800 0 6.501619e-07
I2996 n1_m1_182400_201600 0 5.786667e-07
I2997 n1_m1_182400_206400 0 5.869099e-07
I2998 n1_m1_182400_211200 0 6.351538e-07
I2999 n1_m1_182400_216000 0 6.302095e-07
I3000 n1_m1_182400_220800 0 2.739571e-07
I3001 n1_m1_182400_225600 0 4.485967e-07
I3002 n1_m1_182400_230400 0 3.865804e-07
I3003 n1_m1_182400_235200 0 3.464286e-07
I3004 n1_m1_182400_240000 0 4.679071e-07
I3005 n1_m1_182400_244800 0 3.291429e-07
I3006 n1_m1_182400_249600 0 6.071429e-07
I3007 n1_m1_182400_254400 0 3.041910e-07
I3008 n1_m1_182400_259200 0 1.847918e-07
I3009 n1_m1_182400_264000 0 4.948508e-07
I3010 n1_m1_182400_268800 0 3.550794e-07
I3011 n1_m1_182400_273600 0 8.123000e-07
I3012 n1_m1_182400_278400 0 4.083082e-07
I3013 n1_m1_182400_283200 0 3.492953e-07
I3014 n1_m1_182400_288000 0 8.204553e-07
I3015 n1_m1_182400_292800 0 3.752625e-07
I3016 n1_m1_182400_297600 0 5.744866e-07
I3017 n1_m1_182400_302400 0 1.751166e-07
I3018 n1_m1_182400_307200 0 2.123875e-07
I3019 n1_m1_182400_312000 0 4.032809e-07
I3020 n1_m1_182400_316800 0 8.109380e-07
I3021 n1_m1_182400_321600 0 3.417120e-06
I3022 n1_m1_182400_326400 0 5.737592e-07
I3023 n1_m1_182400_331200 0 4.645714e-07
I3024 n1_m1_182400_336000 0 6.397658e-07
I3025 n1_m1_182400_340800 0 2.471640e-07
I3026 n1_m1_182400_345600 0 1.780273e-07
I3027 n1_m1_182400_350400 0 1.038801e-06
I3028 n1_m1_182400_355200 0 2.379796e-07
I3029 n1_m1_182400_360000 0 8.816746e-07
I3030 n1_m1_182400_364800 0 5.363306e-07
I3031 n1_m1_182400_369600 0 5.958395e-07
I3032 n1_m1_182400_374400 0 6.844740e-07
I3033 n1_m1_182400_379200 0 5.260436e-07
I3034 n1_m1_182400_384000 0 7.954633e-07
I3035 n1_m1_182400_388800 0 3.222857e-07
I3036 n1_m1_182400_393600 0 8.357914e-07
I3037 n1_m1_182400_398400 0 8.197959e-08
I3038 n1_m1_187200_4800 0 3.101538e-07
I3039 n1_m1_187200_9600 0 5.028462e-07
I3040 n1_m1_187200_14400 0 6.839107e-07
I3041 n1_m1_187200_19200 0 3.556777e-07
I3042 n1_m1_187200_24000 0 6.465495e-07
I3043 n1_m1_187200_28800 0 3.556566e-06
I3044 n1_m1_187200_33600 0 4.521742e-06
I3045 n1_m1_187200_38400 0 4.205385e-07
I3046 n1_m1_187200_43200 0 5.564269e-07
I3047 n1_m1_187200_48000 0 3.736272e-07
I3048 n1_m1_187200_52800 0 1.519510e-07
I3049 n1_m1_187200_57600 0 5.640826e-07
I3050 n1_m1_187200_62400 0 4.264817e-06
I3051 n1_m1_187200_67200 0 3.179110e-06
I3052 n1_m1_187200_72000 0 1.096898e-06
I3053 n1_m1_187200_76800 0 2.603827e-07
I3054 n1_m1_187200_81600 0 1.763061e-07
I3055 n1_m1_187200_86400 0 2.681815e-07
I3056 n1_m1_187200_91200 0 5.195385e-07
I3057 n1_m1_187200_96000 0 4.108540e-07
I3058 n1_m1_187200_100800 0 2.692373e-07
I3059 n1_m1_187200_105600 0 6.164526e-07
I3060 n1_m1_187200_110400 0 2.293367e-07
I3061 n1_m1_187200_115200 0 6.386590e-07
I3062 n1_m1_187200_120000 0 6.571257e-07
I3063 n1_m1_187200_124800 0 2.650000e-07
I3064 n1_m1_187200_129600 0 9.308714e-07
I3065 n1_m1_187200_134400 0 2.500405e-07
I3066 n1_m1_187200_139200 0 1.583333e-07
I3067 n1_m1_187200_144000 0 5.458286e-08
I3068 n1_m1_187200_148800 0 4.401952e-07
I3069 n1_m1_187200_153600 0 1.187143e-08
I3070 n1_m1_187200_158400 0 6.855714e-08
I3071 n1_m1_187200_163200 0 2.982595e-07
I3072 n1_m1_187200_168000 0 1.339857e-07
I3073 n1_m1_187200_172800 0 1.897143e-07
I3074 n1_m1_187200_177600 0 4.714571e-07
I3075 n1_m1_187200_182400 0 3.835556e-07
I3076 n1_m1_187200_187200 0 6.171429e-08
I3077 n1_m1_187200_192000 0 6.822967e-07
I3078 n1_m1_187200_196800 0 1.917143e-07
I3079 n1_m1_187200_201600 0 3.723143e-07
I3080 n1_m1_187200_206400 0 4.134714e-07
I3081 n1_m1_187200_211200 0 4.685714e-07
I3082 n1_m1_187200_216000 0 3.976619e-07
I3083 n1_m1_187200_220800 0 2.506000e-07
I3084 n1_m1_187200_225600 0 3.245918e-07
I3085 n1_m1_187200_230400 0 4.415510e-07
I3086 n1_m1_187200_235200 0 4.231111e-07
I3087 n1_m1_187200_240000 0 1.102107e-06
I3088 n1_m1_187200_244800 0 1.131429e-07
I3089 n1_m1_187200_249600 0 5.300857e-07
I3090 n1_m1_187200_254400 0 4.306743e-07
I3091 n1_m1_187200_259200 0 1.187429e-07
I3092 n1_m1_187200_264000 0 3.605162e-07
I3093 n1_m1_187200_268800 0 2.135543e-07
I3094 n1_m1_187200_273600 0 8.104238e-07
I3095 n1_m1_187200_278400 0 5.816156e-07
I3096 n1_m1_187200_283200 0 1.553822e-07
I3097 n1_m1_187200_288000 0 8.581381e-07
I3098 n1_m1_187200_292800 0 4.287363e-07
I3099 n1_m1_187200_297600 0 9.550472e-07
I3100 n1_m1_187200_302400 0 1.265398e-07
I3101 n1_m1_187200_307200 0 3.919643e-07
I3102 n1_m1_187200_312000 0 8.280179e-07
I3103 n1_m1_187200_316800 0 4.241199e-07
I3104 n1_m1_187200_321600 0 1.393497e-06
I3105 n1_m1_187200_326400 0 6.471429e-07
I3106 n1_m1_187200_331200 0 7.363829e-07
I3107 n1_m1_187200_336000 0 1.041196e-06
I3108 n1_m1_187200_340800 0 7.003312e-07
I3109 n1_m1_187200_345600 0 8.300760e-07
I3110 n1_m1_187200_350400 0 3.705167e-07
I3111 n1_m1_187200_355200 0 1.450033e-07
I3112 n1_m1_187200_360000 0 8.137539e-07
I3113 n1_m1_187200_364800 0 2.671347e-06
I3114 n1_m1_187200_369600 0 5.156743e-07
I3115 n1_m1_187200_374400 0 4.016429e-07
I3116 n1_m1_187200_379200 0 3.992421e-07
I3117 n1_m1_187200_384000 0 6.995708e-07
I3118 n1_m1_187200_388800 0 2.688791e-07
I3119 n1_m1_187200_393600 0 8.691171e-07
I3120 n1_m1_187200_398400 0 1.125918e-07
I3121 n1_m1_192000_4800 0 2.353846e-07
I3122 n1_m1_192000_9600 0 1.257272e-06
I3123 n1_m1_192000_14400 0 5.665188e-07
I3124 n1_m1_192000_19200 0 3.978171e-07
I3125 n1_m1_192000_24000 0 1.110439e-06
I3126 n1_m1_192000_28800 0 7.197376e-07
I3127 n1_m1_192000_33600 0 7.506681e-07
I3128 n1_m1_192000_38400 0 9.186635e-07
I3129 n1_m1_192000_43200 0 1.430000e-07
I3130 n1_m1_192000_48000 0 1.262893e-06
I3131 n1_m1_192000_52800 0 6.617321e-07
I3132 n1_m1_192000_57600 0 9.795281e-07
I3133 n1_m1_192000_62400 0 1.322718e-06
I3134 n1_m1_192000_67200 0 7.348071e-07
I3135 n1_m1_192000_72000 0 5.930647e-07
I3136 n1_m1_192000_76800 0 8.258685e-07
I3137 n1_m1_192000_81600 0 9.576339e-07
I3138 n1_m1_192000_86400 0 6.431703e-07
I3139 n1_m1_192000_91200 0 5.276154e-07
I3140 n1_m1_192000_96000 0 6.018429e-07
I3141 n1_m1_192000_100800 0 1.832571e-07
I3142 n1_m1_192000_105600 0 5.922939e-07
I3143 n1_m1_192000_110400 0 9.235204e-07
I3144 n1_m1_192000_115200 0 9.168438e-07
I3145 n1_m1_192000_120000 0 1.229880e-06
I3146 n1_m1_192000_124800 0 3.729714e-07
I3147 n1_m1_192000_129600 0 4.770238e-07
I3148 n1_m1_192000_134400 0 5.119286e-07
I3149 n1_m1_192000_139200 0 9.021429e-07
I3150 n1_m1_192000_144000 0 5.113000e-07
I3151 n1_m1_192000_148800 0 2.246800e-07
I3152 n1_m1_192000_153600 0 1.892357e-07
I3153 n1_m1_192000_158400 0 2.195714e-07
I3154 n1_m1_192000_163200 0 1.859048e-07
I3155 n1_m1_192000_168000 0 5.319333e-07
I3156 n1_m1_192000_172800 0 2.165429e-07
I3157 n1_m1_192000_177600 0 2.736190e-07
I3158 n1_m1_192000_182400 0 8.690714e-08
I3159 n1_m1_192000_187200 0 2.705143e-07
I3160 n1_m1_192000_192000 0 6.884290e-07
I3161 n1_m1_192000_196800 0 3.612143e-07
I3162 n1_m1_192000_201600 0 3.933364e-07
I3163 n1_m1_192000_206400 0 5.024948e-07
I3164 n1_m1_192000_211200 0 4.888286e-07
I3165 n1_m1_192000_216000 0 6.099667e-07
I3166 n1_m1_192000_220800 0 1.901714e-07
I3167 n1_m1_192000_225600 0 7.238411e-07
I3168 n1_m1_192000_230400 0 2.197610e-07
I3169 n1_m1_192000_235200 0 6.351746e-07
I3170 n1_m1_192000_240000 0 1.418171e-06
I3171 n1_m1_192000_244800 0 1.954286e-07
I3172 n1_m1_192000_249600 0 8.490000e-07
I3173 n1_m1_192000_254400 0 7.461124e-07
I3174 n1_m1_192000_259200 0 3.789143e-07
I3175 n1_m1_192000_264000 0 6.239600e-07
I3176 n1_m1_192000_268800 0 6.362933e-07
I3177 n1_m1_192000_273600 0 9.032000e-07
I3178 n1_m1_192000_278400 0 1.396214e-06
I3179 n1_m1_192000_283200 0 1.230835e-06
I3180 n1_m1_192000_288000 0 7.880215e-07
I3181 n1_m1_192000_292800 0 5.821160e-07
I3182 n1_m1_192000_297600 0 1.502051e-06
I3183 n1_m1_192000_302400 0 7.392371e-07
I3184 n1_m1_192000_307200 0 5.559196e-07
I3185 n1_m1_192000_312000 0 1.128547e-06
I3186 n1_m1_192000_316800 0 8.646707e-07
I3187 n1_m1_192000_321600 0 8.296623e-07
I3188 n1_m1_192000_326400 0 6.664253e-07
I3189 n1_m1_192000_331200 0 5.426115e-07
I3190 n1_m1_192000_336000 0 1.027295e-06
I3191 n1_m1_192000_340800 0 6.591200e-07
I3192 n1_m1_192000_345600 0 1.333309e-06
I3193 n1_m1_192000_350400 0 2.004446e-06
I3194 n1_m1_192000_355200 0 1.827029e-07
I3195 n1_m1_192000_360000 0 1.242709e-06
I3196 n1_m1_192000_364800 0 5.525031e-06
I3197 n1_m1_192000_369600 0 1.147577e-06
I3198 n1_m1_192000_374400 0 5.401429e-07
I3199 n1_m1_192000_379200 0 7.017672e-07
I3200 n1_m1_192000_384000 0 7.072635e-07
I3201 n1_m1_192000_388800 0 4.608387e-07
I3202 n1_m1_192000_393600 0 7.912487e-07
I3203 n1_m1_192000_398400 0 1.920000e-07
I3204 n1_m1_196800_4800 0 2.458462e-07
I3205 n1_m1_196800_9600 0 5.662040e-07
I3206 n1_m1_196800_14400 0 3.431786e-07
I3207 n1_m1_196800_19200 0 5.390747e-07
I3208 n1_m1_196800_24000 0 5.622808e-07
I3209 n1_m1_196800_28800 0 4.198393e-07
I3210 n1_m1_196800_33600 0 4.173891e-07
I3211 n1_m1_196800_38400 0 5.163750e-07
I3212 n1_m1_196800_43200 0 4.809945e-07
I3213 n1_m1_196800_48000 0 2.853341e-07
I3214 n1_m1_196800_52800 0 8.466429e-07
I3215 n1_m1_196800_57600 0 6.355748e-07
I3216 n1_m1_196800_62400 0 3.810736e-07
I3217 n1_m1_196800_67200 0 3.341045e-07
I3218 n1_m1_196800_72000 0 2.468279e-07
I3219 n1_m1_196800_76800 0 5.070015e-07
I3220 n1_m1_196800_81600 0 2.314714e-07
I3221 n1_m1_196800_86400 0 2.506216e-07
I3222 n1_m1_196800_91200 0 3.775440e-07
I3223 n1_m1_196800_96000 0 4.053385e-07
I3224 n1_m1_196800_100800 0 4.641952e-07
I3225 n1_m1_196800_105600 0 5.504571e-07
I3226 n1_m1_196800_110400 0 8.235714e-07
I3227 n1_m1_196800_115200 0 9.415714e-08
I3228 n1_m1_196800_120000 0 6.396971e-07
I3229 n1_m1_196800_124800 0 2.392667e-07
I3230 n1_m1_196800_129600 0 3.246595e-07
I3231 n1_m1_196800_134400 0 3.382444e-07
I3232 n1_m1_196800_139200 0 4.775595e-07
I3233 n1_m1_196800_144000 0 1.265571e-07
I3234 n1_m1_196800_148800 0 2.869986e-07
I3235 n1_m1_196800_153600 0 1.664393e-07
I3236 n1_m1_196800_158400 0 1.581286e-07
I3237 n1_m1_196800_163200 0 1.466976e-07
I3238 n1_m1_196800_168000 0 4.885011e-07
I3239 n1_m1_196800_172800 0 1.997143e-07
I3240 n1_m1_196800_177600 0 1.763976e-07
I3241 n1_m1_196800_182400 0 4.962619e-08
I3242 n1_m1_196800_187200 0 8.645714e-08
I3243 n1_m1_196800_192000 0 7.497350e-07
I3244 n1_m1_196800_196800 0 8.255357e-08
I3245 n1_m1_196800_201600 0 3.515541e-07
I3246 n1_m1_196800_206400 0 1.871802e-07
I3247 n1_m1_196800_211200 0 4.327857e-07
I3248 n1_m1_196800_216000 0 4.173476e-07
I3249 n1_m1_196800_220800 0 1.407500e-07
I3250 n1_m1_196800_225600 0 5.154196e-07
I3251 n1_m1_196800_230400 0 4.385675e-07
I3252 n1_m1_196800_235200 0 3.895000e-07
I3253 n1_m1_196800_240000 0 9.239732e-07
I3254 n1_m1_196800_244800 0 1.037143e-07
I3255 n1_m1_196800_249600 0 7.525714e-07
I3256 n1_m1_196800_254400 0 3.834448e-07
I3257 n1_m1_196800_259200 0 3.820000e-07
I3258 n1_m1_196800_264000 0 3.408071e-07
I3259 n1_m1_196800_268800 0 9.660952e-08
I3260 n1_m1_196800_273600 0 5.186476e-07
I3261 n1_m1_196800_278400 0 2.614762e-07
I3262 n1_m1_196800_283200 0 3.019315e-07
I3263 n1_m1_196800_288000 0 1.586343e-06
I3264 n1_m1_196800_292800 0 6.382741e-07
I3265 n1_m1_196800_297600 0 7.152992e-07
I3266 n1_m1_196800_302400 0 7.598507e-07
I3267 n1_m1_196800_307200 0 4.728571e-07
I3268 n1_m1_196800_312000 0 3.622784e-07
I3269 n1_m1_196800_316800 0 1.900391e-07
I3270 n1_m1_196800_321600 0 2.243185e-07
I3271 n1_m1_196800_326400 0 6.477435e-07
I3272 n1_m1_196800_331200 0 3.972281e-07
I3273 n1_m1_196800_336000 0 9.653927e-07
I3274 n1_m1_196800_340800 0 7.072300e-07
I3275 n1_m1_196800_345600 0 4.786676e-07
I3276 n1_m1_196800_350400 0 1.071643e-06
I3277 n1_m1_196800_355200 0 2.871429e-07
I3278 n1_m1_196800_360000 0 7.742768e-07
I3279 n1_m1_196800_364800 0 2.128561e-07
I3280 n1_m1_196800_369600 0 5.602692e-07
I3281 n1_m1_196800_374400 0 4.527809e-07
I3282 n1_m1_196800_379200 0 4.181042e-07
I3283 n1_m1_196800_384000 0 6.968258e-07
I3284 n1_m1_196800_388800 0 5.683750e-07
I3285 n1_m1_196800_393600 0 5.015312e-07
I3286 n1_m1_196800_398400 0 1.710000e-07
I3287 n1_m1_201600_4800 0 2.974502e-07
I3288 n1_m1_201600_9600 0 6.372852e-07
I3289 n1_m1_201600_14400 0 3.004857e-07
I3290 n1_m1_201600_19200 0 2.870286e-07
I3291 n1_m1_201600_24000 0 1.047100e-06
I3292 n1_m1_201600_28800 0 1.780952e-07
I3293 n1_m1_201600_33600 0 7.377229e-07
I3294 n1_m1_201600_38400 0 4.863423e-07
I3295 n1_m1_201600_43200 0 5.063963e-07
I3296 n1_m1_201600_48000 0 5.310062e-07
I3297 n1_m1_201600_52800 0 4.314773e-07
I3298 n1_m1_201600_57600 0 1.138880e-06
I3299 n1_m1_201600_62400 0 1.179429e-07
I3300 n1_m1_201600_67200 0 6.191800e-07
I3301 n1_m1_201600_72000 0 6.579721e-07
I3302 n1_m1_201600_76800 0 7.588118e-07
I3303 n1_m1_201600_81600 0 4.409107e-07
I3304 n1_m1_201600_86400 0 6.255970e-07
I3305 n1_m1_201600_91200 0 5.541755e-07
I3306 n1_m1_201600_96000 0 8.959404e-07
I3307 n1_m1_201600_100800 0 3.417763e-07
I3308 n1_m1_201600_105600 0 1.036416e-06
I3309 n1_m1_201600_110400 0 4.659307e-07
I3310 n1_m1_201600_115200 0 7.594423e-07
I3311 n1_m1_201600_120000 0 1.047920e-06
I3312 n1_m1_201600_124800 0 8.214286e-08
I3313 n1_m1_201600_129600 0 6.809524e-07
I3314 n1_m1_201600_134400 0 3.007159e-07
I3315 n1_m1_201600_139200 0 2.362381e-07
I3316 n1_m1_201600_144000 0 2.698857e-07
I3317 n1_m1_201600_148800 0 1.539524e-07
I3318 n1_m1_201600_153600 0 1.699900e-07
I3319 n1_m1_201600_158400 0 1.649935e-07
I3320 n1_m1_201600_163200 0 2.482653e-08
I3321 n1_m1_201600_168000 0 2.031024e-07
I3322 n1_m1_201600_172800 0 1.764571e-08
I3323 n1_m1_201600_177600 0 1.142417e-07
I3324 n1_m1_201600_182400 0 3.806429e-08
I3325 n1_m1_201600_187200 0 4.325714e-08
I3326 n1_m1_201600_192000 0 1.584571e-07
I3327 n1_m1_201600_196800 0 4.447143e-07
I3328 n1_m1_201600_201600 0 7.609092e-06
I3329 n1_m1_201600_206400 0 6.270952e-07
I3330 n1_m1_201600_211200 0 1.230000e-07
I3331 n1_m1_201600_216000 0 1.692571e-07
I3332 n1_m1_201600_220800 0 2.749429e-07
I3333 n1_m1_201600_225600 0 9.717143e-07
I3334 n1_m1_201600_230400 0 3.774286e-07
I3335 n1_m1_201600_235200 0 1.185071e-07
I3336 n1_m1_201600_240000 0 5.419055e-07
I3337 n1_m1_201600_244800 0 1.252276e-07
I3338 n1_m1_201600_249600 0 4.784909e-07
I3339 n1_m1_201600_254400 0 2.447007e-07
I3340 n1_m1_201600_259200 0 2.480510e-07
I3341 n1_m1_201600_264000 0 4.141429e-07
I3342 n1_m1_201600_268800 0 9.364286e-08
I3343 n1_m1_201600_273600 0 4.225529e-07
I3344 n1_m1_201600_278400 0 4.087937e-07
I3345 n1_m1_201600_283200 0 6.174317e-07
I3346 n1_m1_201600_288000 0 9.882857e-07
I3347 n1_m1_201600_292800 0 6.617532e-07
I3348 n1_m1_201600_297600 0 2.435584e-07
I3349 n1_m1_201600_302400 0 4.916714e-07
I3350 n1_m1_201600_307200 0 3.629121e-07
I3351 n1_m1_201600_312000 0 9.953702e-07
I3352 n1_m1_201600_316800 0 3.577098e-07
I3353 n1_m1_201600_321600 0 7.927143e-07
I3354 n1_m1_201600_326400 0 6.402857e-07
I3355 n1_m1_201600_331200 0 3.037143e-07
I3356 n1_m1_201600_336000 0 8.544805e-07
I3357 n1_m1_201600_340800 0 3.973160e-07
I3358 n1_m1_201600_345600 0 3.166593e-07
I3359 n1_m1_201600_350400 0 7.003571e-07
I3360 n1_m1_201600_355200 0 5.995807e-07
I3361 n1_m1_201600_360000 0 1.843134e-06
I3362 n1_m1_201600_364800 0 3.907656e-07
I3363 n1_m1_201600_369600 0 4.188201e-07
I3364 n1_m1_201600_374400 0 4.541899e-07
I3365 n1_m1_201600_379200 0 5.037771e-07
I3366 n1_m1_201600_384000 0 4.522600e-07
I3367 n1_m1_201600_388800 0 2.955607e-07
I3368 n1_m1_201600_393600 0 1.420420e-06
I3369 n1_m1_201600_398400 0 3.160220e-07
I3370 n1_m1_206400_4800 0 1.402840e-07
I3371 n1_m1_206400_9600 0 8.440511e-07
I3372 n1_m1_206400_14400 0 1.981429e-07
I3373 n1_m1_206400_19200 0 2.010571e-07
I3374 n1_m1_206400_24000 0 9.695902e-07
I3375 n1_m1_206400_28800 0 9.780000e-08
I3376 n1_m1_206400_33600 0 2.834895e-07
I3377 n1_m1_206400_38400 0 1.653173e-07
I3378 n1_m1_206400_43200 0 8.380733e-07
I3379 n1_m1_206400_48000 0 5.494813e-07
I3380 n1_m1_206400_52800 0 3.104405e-07
I3381 n1_m1_206400_57600 0 3.925735e-07
I3382 n1_m1_206400_62400 0 1.136408e-07
I3383 n1_m1_206400_67200 0 4.070000e-07
I3384 n1_m1_206400_72000 0 8.660317e-07
I3385 n1_m1_206400_76800 0 4.035578e-07
I3386 n1_m1_206400_81600 0 3.369935e-07
I3387 n1_m1_206400_86400 0 2.549095e-07
I3388 n1_m1_206400_91200 0 3.677441e-07
I3389 n1_m1_206400_96000 0 8.498377e-07
I3390 n1_m1_206400_100800 0 2.251810e-07
I3391 n1_m1_206400_105600 0 8.840857e-07
I3392 n1_m1_206400_110400 0 5.908040e-07
I3393 n1_m1_206400_115200 0 4.775861e-07
I3394 n1_m1_206400_120000 0 9.762527e-07
I3395 n1_m1_206400_124800 0 4.074459e-07
I3396 n1_m1_206400_129600 0 4.671414e-07
I3397 n1_m1_206400_134400 0 4.070317e-08
I3398 n1_m1_206400_139200 0 1.443571e-07
I3399 n1_m1_206400_144000 0 1.150571e-07
I3400 n1_m1_206400_148800 0 7.515714e-08
I3401 n1_m1_206400_153600 0 2.471500e-07
I3402 n1_m1_206400_158400 0 3.708571e-08
I3403 n1_m1_206400_163200 0 1.844524e-07
I3404 n1_m1_206400_168000 0 3.474762e-07
I3405 n1_m1_206400_172800 0 1.205429e-07
I3406 n1_m1_206400_177600 0 9.587679e-07
I3407 n1_m1_206400_182400 0 1.190000e-07
I3408 n1_m1_206400_187200 0 1.350000e-07
I3409 n1_m1_206400_192000 0 3.935000e-07
I3410 n1_m1_206400_196800 0 6.905143e-07
I3411 n1_m1_206400_201600 0 1.583966e-06
I3412 n1_m1_206400_206400 0 6.807190e-07
I3413 n1_m1_206400_211200 0 2.453367e-07
I3414 n1_m1_206400_216000 0 2.992061e-07
I3415 n1_m1_206400_220800 0 1.570429e-07
I3416 n1_m1_206400_225600 0 6.260544e-07
I3417 n1_m1_206400_230400 0 1.823622e-07
I3418 n1_m1_206400_235200 0 4.458643e-07
I3419 n1_m1_206400_240000 0 2.001369e-07
I3420 n1_m1_206400_244800 0 4.274921e-07
I3421 n1_m1_206400_249600 0 5.133333e-07
I3422 n1_m1_206400_254400 0 3.753405e-07
I3423 n1_m1_206400_259200 0 9.492857e-08
I3424 n1_m1_206400_264000 0 5.049286e-07
I3425 n1_m1_206400_268800 0 3.632857e-07
I3426 n1_m1_206400_273600 0 3.156500e-07
I3427 n1_m1_206400_278400 0 3.573571e-07
I3428 n1_m1_206400_283200 0 4.717571e-07
I3429 n1_m1_206400_288000 0 4.172000e-07
I3430 n1_m1_206400_292800 0 6.238590e-07
I3431 n1_m1_206400_297600 0 3.572531e-07
I3432 n1_m1_206400_302400 0 6.751857e-07
I3433 n1_m1_206400_307200 0 4.049451e-07
I3434 n1_m1_206400_312000 0 2.497236e-07
I3435 n1_m1_206400_316800 0 2.478929e-07
I3436 n1_m1_206400_321600 0 1.029923e-06
I3437 n1_m1_206400_326400 0 1.702308e-07
I3438 n1_m1_206400_331200 0 2.767269e-07
I3439 n1_m1_206400_336000 0 1.342210e-06
I3440 n1_m1_206400_340800 0 5.281810e-07
I3441 n1_m1_206400_345600 0 6.137881e-07
I3442 n1_m1_206400_350400 0 2.010607e-07
I3443 n1_m1_206400_355200 0 4.725393e-07
I3444 n1_m1_206400_360000 0 6.622769e-07
I3445 n1_m1_206400_364800 0 6.035969e-07
I3446 n1_m1_206400_369600 0 3.961156e-07
I3447 n1_m1_206400_374400 0 5.347398e-07
I3448 n1_m1_206400_379200 0 5.037943e-07
I3449 n1_m1_206400_384000 0 5.178686e-07
I3450 n1_m1_206400_388800 0 7.125000e-07
I3451 n1_m1_206400_393600 0 5.255435e-07
I3452 n1_m1_206400_398400 0 2.142857e-07
I3453 n1_m1_211200_4800 0 1.231479e-07
I3454 n1_m1_211200_9600 0 7.996184e-07
I3455 n1_m1_211200_14400 0 2.422527e-07
I3456 n1_m1_211200_19200 0 4.043792e-07
I3457 n1_m1_211200_24000 0 5.642937e-07
I3458 n1_m1_211200_28800 0 5.679383e-07
I3459 n1_m1_211200_33600 0 1.147622e-06
I3460 n1_m1_211200_38400 0 3.517385e-07
I3461 n1_m1_211200_43200 0 2.250000e-08
I3462 n1_m1_211200_48000 0 1.831571e-07
I3463 n1_m1_211200_52800 0 2.678762e-07
I3464 n1_m1_211200_57600 0 4.434964e-07
I3465 n1_m1_211200_62400 0 1.272286e-07
I3466 n1_m1_211200_72000 0 1.061467e-06
I3467 n1_m1_211200_76800 0 1.939330e-07
I3468 n1_m1_211200_81600 0 7.362931e-07
I3469 n1_m1_211200_86400 0 2.790962e-07
I3470 n1_m1_211200_91200 0 1.480357e-07
I3471 n1_m1_211200_96000 0 2.227191e-07
I3472 n1_m1_211200_100800 0 9.962814e-08
I3473 n1_m1_211200_105600 0 5.997348e-07
I3474 n1_m1_211200_110400 0 1.491444e-07
I3475 n1_m1_211200_115200 0 2.738139e-07
I3476 n1_m1_211200_120000 0 7.327580e-07
I3477 n1_m1_211200_124800 0 5.316255e-07
I3478 n1_m1_211200_129600 0 5.610491e-07
I3479 n1_m1_211200_134400 0 2.659365e-07
I3480 n1_m1_211200_139200 0 5.446627e-07
I3481 n1_m1_211200_144000 0 2.293286e-07
I3482 n1_m1_211200_148800 0 7.351429e-08
I3483 n1_m1_211200_153600 0 1.267786e-07
I3484 n1_m1_211200_158400 0 4.727143e-08
I3485 n1_m1_211200_163200 0 5.875115e-07
I3486 n1_m1_211200_168000 0 1.844345e-07
I3487 n1_m1_211200_172800 0 2.892857e-08
I3488 n1_m1_211200_177600 0 3.858214e-07
I3489 n1_m1_211200_182400 0 4.870000e-07
I3490 n1_m1_211200_187200 0 1.774857e-07
I3491 n1_m1_211200_192000 0 5.494060e-07
I3492 n1_m1_211200_196800 0 7.268071e-07
I3493 n1_m1_211200_201600 0 6.594929e-07
I3494 n1_m1_211200_206400 0 8.500000e-09
I3495 n1_m1_211200_211200 0 2.107061e-07
I3496 n1_m1_211200_216000 0 8.270796e-07
I3497 n1_m1_211200_220800 0 1.070484e-06
I3498 n1_m1_211200_225600 0 4.822972e-07
I3499 n1_m1_211200_230400 0 5.099262e-07
I3500 n1_m1_211200_235200 0 7.269196e-07
I3501 n1_m1_211200_240000 0 1.767071e-06
I3502 n1_m1_211200_244800 0 6.976825e-06
I3503 n1_m1_211200_249600 0 7.611905e-07
I3504 n1_m1_211200_254400 0 4.061857e-07
I3505 n1_m1_211200_259200 0 3.071429e-07
I3506 n1_m1_211200_264000 0 5.350548e-07
I3507 n1_m1_211200_268800 0 3.018905e-07
I3508 n1_m1_211200_273600 0 1.889381e-07
I3509 n1_m1_211200_278400 0 3.020238e-07
I3510 n1_m1_211200_283200 0 5.899048e-08
I3511 n1_m1_211200_288000 0 2.901973e-07
I3512 n1_m1_211200_292800 0 6.035714e-07
I3513 n1_m1_211200_297600 0 6.498027e-07
I3514 n1_m1_211200_302400 0 2.782597e-07
I3515 n1_m1_211200_307200 0 1.097959e-07
I3516 n1_m1_211200_312000 0 6.887934e-07
I3517 n1_m1_211200_316800 0 9.002624e-08
I3518 n1_m1_211200_321600 0 2.812051e-07
I3519 n1_m1_211200_326400 0 7.367033e-08
I3520 n1_m1_211200_331200 0 3.878088e-07
I3521 n1_m1_211200_336000 0 1.406174e-06
I3522 n1_m1_211200_340800 0 8.330857e-07
I3523 n1_m1_211200_345600 0 3.447583e-07
I3524 n1_m1_211200_350400 0 9.885987e-07
I3525 n1_m1_211200_355200 0 3.395006e-07
I3526 n1_m1_211200_360000 0 3.462675e-07
I3527 n1_m1_211200_364800 0 5.156701e-07
I3528 n1_m1_211200_369600 0 5.798316e-07
I3529 n1_m1_211200_374400 0 4.707482e-07
I3530 n1_m1_211200_379200 0 1.671200e-07
I3531 n1_m1_211200_384000 0 3.693641e-07
I3532 n1_m1_211200_388800 0 4.483508e-07
I3533 n1_m1_211200_393600 0 5.878525e-07
I3534 n1_m1_211200_398400 0 1.412308e-07
I3535 n1_m1_216000_4800 0 2.947290e-07
I3536 n1_m1_216000_9600 0 1.055477e-06
I3537 n1_m1_216000_14400 0 6.529139e-07
I3538 n1_m1_216000_19200 0 8.460779e-07
I3539 n1_m1_216000_24000 0 7.111082e-07
I3540 n1_m1_216000_28800 0 9.755565e-07
I3541 n1_m1_216000_33600 0 1.029540e-06
I3542 n1_m1_216000_38400 0 3.668475e-07
I3543 n1_m1_216000_43200 0 8.141538e-08
I3544 n1_m1_216000_48000 0 1.144181e-06
I3545 n1_m1_216000_52800 0 4.702619e-07
I3546 n1_m1_216000_57600 0 6.904161e-07
I3547 n1_m1_216000_62400 0 7.828179e-07
I3548 n1_m1_216000_67200 0 7.212857e-08
I3549 n1_m1_216000_72000 0 1.064045e-06
I3550 n1_m1_216000_76800 0 8.145826e-07
I3551 n1_m1_216000_81600 0 1.369243e-06
I3552 n1_m1_216000_86400 0 7.195297e-07
I3553 n1_m1_216000_91200 0 4.183247e-07
I3554 n1_m1_216000_96000 0 1.033011e-06
I3555 n1_m1_216000_100800 0 6.799004e-07
I3556 n1_m1_216000_105600 0 1.288353e-06
I3557 n1_m1_216000_110400 0 3.434835e-07
I3558 n1_m1_216000_115200 0 8.621586e-07
I3559 n1_m1_216000_120000 0 8.098853e-07
I3560 n1_m1_216000_124800 0 2.132143e-07
I3561 n1_m1_216000_129600 0 1.019710e-06
I3562 n1_m1_216000_134400 0 8.926349e-08
I3563 n1_m1_216000_139200 0 8.554802e-07
I3564 n1_m1_216000_144000 0 1.260427e-06
I3565 n1_m1_216000_148800 0 2.009592e-07
I3566 n1_m1_216000_153600 0 1.380214e-07
I3567 n1_m1_216000_158400 0 1.818571e-08
I3568 n1_m1_216000_163200 0 2.457218e-07
I3569 n1_m1_216000_168000 0 9.796071e-08
I3570 n1_m1_216000_172800 0 1.587857e-07
I3571 n1_m1_216000_177600 0 9.524214e-07
I3572 n1_m1_216000_182400 0 2.926143e-07
I3573 n1_m1_216000_187200 0 4.504286e-07
I3574 n1_m1_216000_192000 0 7.023655e-07
I3575 n1_m1_216000_196800 0 8.647786e-07
I3576 n1_m1_216000_201600 0 2.072898e-06
I3577 n1_m1_216000_206400 0 7.891264e-07
I3578 n1_m1_216000_211200 0 7.439048e-07
I3579 n1_m1_216000_216000 0 4.439873e-07
I3580 n1_m1_216000_220800 0 2.907302e-07
I3581 n1_m1_216000_225600 0 8.162709e-07
I3582 n1_m1_216000_230400 0 6.282910e-07
I3583 n1_m1_216000_235200 0 1.920364e-07
I3584 n1_m1_216000_240000 0 9.798179e-07
I3585 n1_m1_216000_244800 0 4.779683e-07
I3586 n1_m1_216000_249600 0 1.009376e-06
I3587 n1_m1_216000_254400 0 3.474286e-07
I3588 n1_m1_216000_259200 0 1.152000e-08
I3589 n1_m1_216000_264000 0 3.649138e-07
I3590 n1_m1_216000_268800 0 6.067095e-07
I3591 n1_m1_216000_273600 0 7.401905e-07
I3592 n1_m1_216000_278400 0 6.646905e-07
I3593 n1_m1_216000_283200 0 1.400667e-07
I3594 n1_m1_216000_288000 0 8.722535e-07
I3595 n1_m1_216000_292800 0 4.667290e-07
I3596 n1_m1_216000_297600 0 1.243929e-06
I3597 n1_m1_216000_302400 0 3.868992e-07
I3598 n1_m1_216000_307200 0 2.226565e-07
I3599 n1_m1_216000_312000 0 1.204645e-06
I3600 n1_m1_216000_316800 0 4.308309e-07
I3601 n1_m1_216000_321600 0 1.542938e-06
I3602 n1_m1_216000_326400 0 9.030275e-07
I3603 n1_m1_216000_331200 0 4.877970e-07
I3604 n1_m1_216000_336000 0 1.111880e-06
I3605 n1_m1_216000_340800 0 2.491429e-07
I3606 n1_m1_216000_345600 0 1.414094e-06
I3607 n1_m1_216000_350400 0 6.032687e-07
I3608 n1_m1_216000_355200 0 6.967695e-07
I3609 n1_m1_216000_360000 0 8.406858e-07
I3610 n1_m1_216000_364800 0 8.814362e-07
I3611 n1_m1_216000_369600 0 9.841132e-07
I3612 n1_m1_216000_374400 0 8.753060e-07
I3613 n1_m1_216000_379200 0 5.478514e-07
I3614 n1_m1_216000_384000 0 9.633074e-07
I3615 n1_m1_216000_388800 0 5.301313e-07
I3616 n1_m1_216000_393600 0 1.269295e-06
I3617 n1_m1_216000_398400 0 3.490549e-07
I3618 n1_m1_220800_4800 0 1.387692e-07
I3619 n1_m1_220800_9600 0 6.232718e-07
I3620 n1_m1_220800_14400 0 5.275201e-07
I3621 n1_m1_220800_19200 0 3.623503e-07
I3622 n1_m1_220800_24000 0 8.835522e-07
I3623 n1_m1_220800_28800 0 3.398162e-07
I3624 n1_m1_220800_33600 0 4.959719e-07
I3625 n1_m1_220800_38400 0 9.093472e-07
I3626 n1_m1_220800_43200 0 1.209692e-07
I3627 n1_m1_220800_48000 0 4.098568e-07
I3628 n1_m1_220800_52800 0 1.583633e-07
I3629 n1_m1_220800_57600 0 4.271161e-07
I3630 n1_m1_220800_62400 0 3.597536e-07
I3631 n1_m1_220800_67200 0 1.555857e-07
I3632 n1_m1_220800_72000 0 1.087748e-06
I3633 n1_m1_220800_76800 0 1.616138e-07
I3634 n1_m1_220800_81600 0 9.370171e-07
I3635 n1_m1_220800_86400 0 5.975385e-07
I3636 n1_m1_220800_91200 0 2.300637e-07
I3637 n1_m1_220800_96000 0 7.212892e-07
I3638 n1_m1_220800_100800 0 1.821003e-07
I3639 n1_m1_220800_105600 0 8.327293e-07
I3640 n1_m1_220800_110400 0 2.761850e-07
I3641 n1_m1_220800_115200 0 2.112449e-07
I3642 n1_m1_220800_120000 0 6.008839e-07
I3643 n1_m1_220800_124800 0 7.937500e-07
I3644 n1_m1_220800_129600 0 5.125045e-07
I3645 n1_m1_220800_134400 0 4.631071e-07
I3646 n1_m1_220800_139200 0 2.496250e-07
I3647 n1_m1_220800_144000 0 7.458449e-07
I3648 n1_m1_220800_148800 0 1.948980e-07
I3649 n1_m1_220800_153600 0 3.351111e-07
I3650 n1_m1_220800_158400 0 2.607429e-08
I3651 n1_m1_220800_163200 0 2.326156e-07
I3652 n1_m1_220800_168000 0 3.447143e-07
I3653 n1_m1_220800_172800 0 4.674286e-07
I3654 n1_m1_220800_177600 0 2.375379e-07
I3655 n1_m1_220800_182400 0 1.983000e-07
I3656 n1_m1_220800_187200 0 2.792857e-07
I3657 n1_m1_220800_192000 0 3.733810e-07
I3658 n1_m1_220800_196800 0 2.909857e-07
I3659 n1_m1_220800_201600 0 1.686505e-06
I3660 n1_m1_220800_206400 0 7.979908e-07
I3661 n1_m1_220800_211200 0 7.842905e-07
I3662 n1_m1_220800_216000 0 4.565470e-07
I3663 n1_m1_220800_220800 0 2.424800e-07
I3664 n1_m1_220800_225600 0 7.753962e-07
I3665 n1_m1_220800_230400 0 5.071349e-07
I3666 n1_m1_220800_235200 0 1.596154e-07
I3667 n1_m1_220800_240000 0 1.131469e-06
I3668 n1_m1_220800_244800 0 4.059054e-07
I3669 n1_m1_220800_249600 0 5.884714e-07
I3670 n1_m1_220800_254400 0 4.526743e-07
I3671 n1_m1_220800_259200 0 1.953829e-07
I3672 n1_m1_220800_264000 0 5.620543e-07
I3673 n1_m1_220800_268800 0 1.264143e-07
I3674 n1_m1_220800_273600 0 3.179802e-07
I3675 n1_m1_220800_278400 0 4.919104e-07
I3676 n1_m1_220800_283200 0 2.583388e-07
I3677 n1_m1_220800_288000 0 5.424635e-07
I3678 n1_m1_220800_292800 0 5.051587e-07
I3679 n1_m1_220800_297600 0 6.845330e-07
I3680 n1_m1_220800_302400 0 6.509821e-07
I3681 n1_m1_220800_307200 0 1.511905e-08
I3682 n1_m1_220800_312000 0 6.107229e-07
I3683 n1_m1_220800_316800 0 3.524935e-07
I3684 n1_m1_220800_321600 0 5.345991e-07
I3685 n1_m1_220800_326400 0 4.000137e-06
I3686 n1_m1_220800_331200 0 8.653274e-07
I3687 n1_m1_220800_336000 0 4.592630e-07
I3688 n1_m1_220800_340800 0 3.395027e-07
I3689 n1_m1_220800_345600 0 8.599722e-07
I3690 n1_m1_220800_350400 0 2.498062e-07
I3691 n1_m1_220800_355200 0 3.946008e-07
I3692 n1_m1_220800_360000 0 9.712311e-07
I3693 n1_m1_220800_364800 0 3.096901e-07
I3694 n1_m1_220800_369600 0 8.015123e-06
I3695 n1_m1_220800_374400 0 2.933981e-07
I3696 n1_m1_220800_379200 0 6.156956e-07
I3697 n1_m1_220800_384000 0 6.511466e-07
I3698 n1_m1_220800_388800 0 2.575714e-07
I3699 n1_m1_220800_393600 0 6.085966e-07
I3700 n1_m1_220800_398400 0 1.896923e-07
I3701 n1_m1_225600_4800 0 3.756923e-07
I3702 n1_m1_225600_9600 0 4.706000e-07
I3703 n1_m1_225600_14400 0 5.585275e-07
I3704 n1_m1_225600_19200 0 5.839176e-07
I3705 n1_m1_225600_24000 0 8.947781e-07
I3706 n1_m1_225600_28800 0 2.381901e-06
I3707 n1_m1_225600_33600 0 3.270253e-06
I3708 n1_m1_225600_38400 0 7.467788e-07
I3709 n1_m1_225600_43200 0 3.987692e-08
I3710 n1_m1_225600_48000 0 3.070292e-07
I3711 n1_m1_225600_52800 0 3.111796e-07
I3712 n1_m1_225600_57600 0 1.495000e-07
I3713 n1_m1_225600_62400 0 1.526571e-07
I3714 n1_m1_225600_67200 0 2.200000e-08
I3715 n1_m1_225600_72000 0 7.645829e-07
I3716 n1_m1_225600_76800 0 2.415956e-07
I3717 n1_m1_225600_81600 0 6.404184e-07
I3718 n1_m1_225600_86400 0 4.913901e-07
I3719 n1_m1_225600_91200 0 8.602198e-08
I3720 n1_m1_225600_96000 0 6.786992e-07
I3721 n1_m1_225600_100800 0 1.866113e-07
I3722 n1_m1_225600_105600 0 1.189090e-06
I3723 n1_m1_225600_110400 0 9.140952e-07
I3724 n1_m1_225600_115200 0 1.837810e-07
I3725 n1_m1_225600_120000 0 8.577714e-07
I3726 n1_m1_225600_124800 0 6.441071e-07
I3727 n1_m1_225600_129600 0 3.781865e-06
I3728 n1_m1_225600_134400 0 3.869230e-07
I3729 n1_m1_225600_139200 0 6.514342e-07
I3730 n1_m1_225600_144000 0 5.398078e-07
I3731 n1_m1_225600_148800 0 5.095510e-08
I3732 n1_m1_225600_153600 0 8.648338e-07
I3733 n1_m1_225600_158400 0 2.599200e-07
I3734 n1_m1_225600_163200 0 6.849676e-07
I3735 n1_m1_225600_168000 0 1.636629e-07
I3736 n1_m1_225600_172800 0 2.104094e-07
I3737 n1_m1_225600_177600 0 6.512556e-07
I3738 n1_m1_225600_182400 0 3.781600e-07
I3739 n1_m1_225600_187200 0 5.849143e-07
I3740 n1_m1_225600_192000 0 3.548524e-07
I3741 n1_m1_225600_196800 0 1.297121e-07
I3742 n1_m1_225600_201600 0 8.693937e-07
I3743 n1_m1_225600_206400 0 5.107399e-07
I3744 n1_m1_225600_211200 0 8.119426e-07
I3745 n1_m1_225600_216000 0 2.952068e-07
I3746 n1_m1_225600_220800 0 1.573486e-07
I3747 n1_m1_225600_225600 0 7.010428e-07
I3748 n1_m1_225600_230400 0 3.185455e-07
I3749 n1_m1_225600_235200 0 1.350000e-07
I3750 n1_m1_225600_240000 0 5.363214e-07
I3751 n1_m1_225600_244800 0 4.826786e-07
I3752 n1_m1_225600_249600 0 5.366367e-07
I3753 n1_m1_225600_254400 0 5.133318e-07
I3754 n1_m1_225600_259200 0 2.338400e-07
I3755 n1_m1_225600_264000 0 6.313041e-07
I3756 n1_m1_225600_268800 0 3.038794e-07
I3757 n1_m1_225600_273600 0 4.299151e-07
I3758 n1_m1_225600_278400 0 6.615420e-07
I3759 n1_m1_225600_283200 0 2.898559e-07
I3760 n1_m1_225600_288000 0 5.213036e-07
I3761 n1_m1_225600_292800 0 2.439286e-07
I3762 n1_m1_225600_297600 0 3.943956e-07
I3763 n1_m1_225600_302400 0 3.178304e-07
I3764 n1_m1_225600_307200 0 7.107143e-08
I3765 n1_m1_225600_312000 0 9.756952e-07
I3766 n1_m1_225600_316800 0 2.965029e-07
I3767 n1_m1_225600_321600 0 3.583527e-07
I3768 n1_m1_225600_326400 0 3.439805e-06
I3769 n1_m1_225600_331200 0 7.609899e-07
I3770 n1_m1_225600_336000 0 7.128729e-07
I3771 n1_m1_225600_340800 0 3.511374e-07
I3772 n1_m1_225600_345600 0 3.707734e-07
I3773 n1_m1_225600_350400 0 6.178808e-07
I3774 n1_m1_225600_355200 0 4.985290e-07
I3775 n1_m1_225600_360000 0 6.487966e-07
I3776 n1_m1_225600_364800 0 6.257429e-07
I3777 n1_m1_225600_369600 0 1.109044e-06
I3778 n1_m1_225600_374400 0 2.895367e-07
I3779 n1_m1_225600_379200 0 4.507686e-07
I3780 n1_m1_225600_384000 0 5.917404e-07
I3781 n1_m1_225600_388800 0 1.960000e-07
I3782 n1_m1_225600_393600 0 1.093933e-06
I3783 n1_m1_225600_398400 0 2.823485e-07
I3784 n1_m1_230400_4800 0 4.620979e-07
I3785 n1_m1_230400_9600 0 6.690082e-07
I3786 n1_m1_230400_14400 0 3.718054e-07
I3787 n1_m1_230400_19200 0 4.101786e-07
I3788 n1_m1_230400_24000 0 4.920714e-07
I3789 n1_m1_230400_28800 0 5.515022e-07
I3790 n1_m1_230400_33600 0 4.856896e-07
I3791 n1_m1_230400_38400 0 5.786971e-07
I3792 n1_m1_230400_43200 0 1.917000e-07
I3793 n1_m1_230400_48000 0 5.878286e-07
I3794 n1_m1_230400_52800 0 5.853259e-07
I3795 n1_m1_230400_57600 0 6.415517e-07
I3796 n1_m1_230400_62400 0 5.737071e-07
I3797 n1_m1_230400_67200 0 2.195167e-07
I3798 n1_m1_230400_72000 0 5.881944e-07
I3799 n1_m1_230400_76800 0 2.809000e-06
I3800 n1_m1_230400_81600 0 2.152455e-06
I3801 n1_m1_230400_86400 0 3.484360e-07
I3802 n1_m1_230400_91200 0 2.095319e-07
I3803 n1_m1_230400_96000 0 8.212185e-07
I3804 n1_m1_230400_100800 0 2.632619e-07
I3805 n1_m1_230400_105600 0 3.278571e-07
I3806 n1_m1_230400_110400 0 7.187033e-07
I3807 n1_m1_230400_115200 0 4.631786e-07
I3808 n1_m1_230400_120000 0 4.635119e-07
I3809 n1_m1_230400_124800 0 7.007857e-07
I3810 n1_m1_230400_129600 0 1.033529e-06
I3811 n1_m1_230400_134400 0 1.776500e-07
I3812 n1_m1_230400_139200 0 4.677143e-07
I3813 n1_m1_230400_144000 0 3.714494e-07
I3814 n1_m1_230400_148800 0 2.005571e-07
I3815 n1_m1_230400_153600 0 5.294857e-07
I3816 n1_m1_230400_158400 0 3.523810e-07
I3817 n1_m1_230400_163200 0 7.961304e-07
I3818 n1_m1_230400_168000 0 3.303492e-07
I3819 n1_m1_230400_172800 0 2.292857e-07
I3820 n1_m1_230400_177600 0 2.415429e-07
I3821 n1_m1_230400_182400 0 2.319048e-07
I3822 n1_m1_230400_187200 0 6.312571e-07
I3823 n1_m1_230400_192000 0 5.210714e-07
I3824 n1_m1_230400_196800 0 9.424330e-07
I3825 n1_m1_230400_201600 0 6.483349e-07
I3826 n1_m1_230400_206400 0 2.081786e-07
I3827 n1_m1_230400_211200 0 3.004732e-07
I3828 n1_m1_230400_216000 0 7.591964e-07
I3829 n1_m1_230400_220800 0 8.552967e-07
I3830 n1_m1_230400_225600 0 3.889584e-07
I3831 n1_m1_230400_230400 0 5.159221e-07
I3832 n1_m1_230400_235200 0 8.785714e-08
I3833 n1_m1_230400_240000 0 1.068812e-06
I3834 n1_m1_230400_244800 0 5.075625e-07
I3835 n1_m1_230400_249600 0 1.232571e-06
I3836 n1_m1_230400_254400 0 2.297286e-07
I3837 n1_m1_230400_264000 0 6.502679e-07
I3838 n1_m1_230400_268800 0 1.360119e-07
I3839 n1_m1_230400_273600 0 5.389357e-07
I3840 n1_m1_230400_278400 0 1.421753e-07
I3841 n1_m1_230400_283200 0 5.632273e-07
I3842 n1_m1_230400_288000 0 5.241190e-07
I3843 n1_m1_230400_292800 0 3.705357e-07
I3844 n1_m1_230400_297600 0 6.418941e-07
I3845 n1_m1_230400_302400 0 7.531684e-07
I3846 n1_m1_230400_307200 0 4.629209e-07
I3847 n1_m1_230400_312000 0 2.378909e-07
I3848 n1_m1_230400_316800 0 5.763265e-07
I3849 n1_m1_230400_321600 0 5.868632e-07
I3850 n1_m1_230400_326400 0 4.180000e-07
I3851 n1_m1_230400_331200 0 4.896299e-07
I3852 n1_m1_230400_336000 0 4.666011e-07
I3853 n1_m1_230400_340800 0 7.100343e-07
I3854 n1_m1_230400_345600 0 6.545174e-07
I3855 n1_m1_230400_350400 0 5.968598e-07
I3856 n1_m1_230400_355200 0 3.743214e-07
I3857 n1_m1_230400_360000 0 1.132250e-06
I3858 n1_m1_230400_364800 0 6.912571e-07
I3859 n1_m1_230400_369600 0 4.748357e-07
I3860 n1_m1_230400_374400 0 2.571571e-07
I3861 n1_m1_230400_379200 0 9.753956e-07
I3862 n1_m1_230400_384000 0 1.246321e-06
I3863 n1_m1_230400_388800 0 1.168400e-06
I3864 n1_m1_230400_393600 0 1.821293e-06
I3865 n1_m1_230400_398400 0 1.085000e-07
I3866 n1_m1_235200_4800 0 2.498965e-07
I3867 n1_m1_235200_9600 0 3.357935e-07
I3868 n1_m1_235200_14400 0 4.629375e-07
I3869 n1_m1_235200_19200 0 5.293357e-07
I3870 n1_m1_235200_24000 0 7.777048e-07
I3871 n1_m1_235200_28800 0 5.456800e-07
I3872 n1_m1_235200_33600 0 8.702179e-07
I3873 n1_m1_235200_38400 0 6.772572e-07
I3874 n1_m1_235200_43200 0 8.632445e-07
I3875 n1_m1_235200_48000 0 5.508437e-07
I3876 n1_m1_235200_52800 0 5.843607e-07
I3877 n1_m1_235200_57600 0 3.156888e-07
I3878 n1_m1_235200_62400 0 4.090964e-07
I3879 n1_m1_235200_67200 0 2.269648e-07
I3880 n1_m1_235200_72000 0 8.845635e-07
I3881 n1_m1_235200_76800 0 4.095300e-07
I3882 n1_m1_235200_81600 0 4.610446e-07
I3883 n1_m1_235200_86400 0 3.861854e-07
I3884 n1_m1_235200_91200 0 2.562788e-07
I3885 n1_m1_235200_96000 0 4.554286e-07
I3886 n1_m1_235200_100800 0 4.211714e-07
I3887 n1_m1_235200_105600 0 5.456714e-07
I3888 n1_m1_235200_110400 0 2.360000e-07
I3889 n1_m1_235200_115200 0 9.496939e-08
I3890 n1_m1_235200_120000 0 5.847449e-07
I3891 n1_m1_235200_124800 0 4.324286e-07
I3892 n1_m1_235200_129600 0 3.921143e-07
I3893 n1_m1_235200_134400 0 1.729500e-07
I3894 n1_m1_235200_139200 0 2.377381e-07
I3895 n1_m1_235200_144000 0 6.967381e-07
I3896 n1_m1_235200_148800 0 2.517905e-07
I3897 n1_m1_235200_153600 0 1.035690e-06
I3898 n1_m1_235200_158400 0 2.225810e-07
I3899 n1_m1_235200_163200 0 3.869577e-07
I3900 n1_m1_235200_168000 0 8.801508e-07
I3901 n1_m1_235200_172800 0 2.814286e-07
I3902 n1_m1_235200_177600 0 6.463571e-07
I3903 n1_m1_235200_182400 0 1.204095e-07
I3904 n1_m1_235200_187200 0 2.822000e-07
I3905 n1_m1_235200_192000 0 1.559905e-07
I3906 n1_m1_235200_196800 0 4.436393e-07
I3907 n1_m1_235200_201600 0 6.617533e-07
I3908 n1_m1_235200_206400 0 5.008163e-07
I3909 n1_m1_235200_211200 0 8.029464e-07
I3910 n1_m1_235200_216000 0 4.484286e-07
I3911 n1_m1_235200_220800 0 1.140000e-07
I3912 n1_m1_235200_225600 0 6.503750e-07
I3913 n1_m1_235200_230400 0 4.458980e-07
I3914 n1_m1_235200_235200 0 2.086625e-07
I3915 n1_m1_235200_240000 0 9.003363e-07
I3916 n1_m1_235200_244800 0 8.270440e-07
I3917 n1_m1_235200_249600 0 8.081223e-07
I3918 n1_m1_235200_254400 0 1.317095e-07
I3919 n1_m1_235200_259200 0 2.667619e-07
I3920 n1_m1_235200_264000 0 7.835000e-07
I3921 n1_m1_235200_268800 0 6.791429e-08
I3922 n1_m1_235200_273600 0 5.661643e-07
I3923 n1_m1_235200_278400 0 7.486201e-07
I3924 n1_m1_235200_283200 0 3.025552e-07
I3925 n1_m1_235200_288000 0 3.543667e-07
I3926 n1_m1_235200_292800 0 2.488661e-07
I3927 n1_m1_235200_297600 0 7.807577e-07
I3928 n1_m1_235200_302400 0 5.837781e-07
I3929 n1_m1_235200_307200 0 4.708482e-07
I3930 n1_m1_235200_312000 0 8.845055e-08
I3931 n1_m1_235200_316800 0 4.079754e-07
I3932 n1_m1_235200_321600 0 2.946676e-07
I3933 n1_m1_235200_326400 0 3.080982e-07
I3934 n1_m1_235200_331200 0 1.891964e-07
I3935 n1_m1_235200_336000 0 2.696741e-07
I3936 n1_m1_235200_340800 0 3.542857e-07
I3937 n1_m1_235200_345600 0 1.442857e-07
I3938 n1_m1_235200_350400 0 6.243857e-07
I3939 n1_m1_235200_355200 0 4.611429e-07
I3940 n1_m1_235200_360000 0 4.836964e-07
I3941 n1_m1_235200_364800 0 1.572602e-07
I3942 n1_m1_235200_369600 0 8.037719e-07
I3943 n1_m1_235200_374400 0 2.850464e-07
I3944 n1_m1_235200_379200 0 5.178750e-07
I3945 n1_m1_235200_384000 0 1.270597e-06
I3946 n1_m1_235200_388800 0 2.058986e-06
I3947 n1_m1_235200_393600 0 2.210696e-06
I3948 n1_m1_235200_398400 0 2.518052e-07
I3949 n1_m1_240000_4800 0 2.116686e-07
I3950 n1_m1_240000_9600 0 1.041944e-06
I3951 n1_m1_240000_14400 0 5.928162e-07
I3952 n1_m1_240000_19200 0 7.660216e-07
I3953 n1_m1_240000_24000 0 1.500167e-06
I3954 n1_m1_240000_28800 0 6.642347e-07
I3955 n1_m1_240000_33600 0 4.341021e-07
I3956 n1_m1_240000_38400 0 7.419603e-07
I3957 n1_m1_240000_43200 0 2.853247e-07
I3958 n1_m1_240000_48000 0 1.167209e-06
I3959 n1_m1_240000_52800 0 9.359821e-07
I3960 n1_m1_240000_57600 0 9.761259e-07
I3961 n1_m1_240000_62400 0 6.978571e-07
I3962 n1_m1_240000_67200 0 2.820780e-07
I3963 n1_m1_240000_72000 0 1.159675e-06
I3964 n1_m1_240000_76800 0 2.932659e-07
I3965 n1_m1_240000_81600 0 8.439367e-07
I3966 n1_m1_240000_86400 0 8.678418e-07
I3967 n1_m1_240000_91200 0 4.772383e-07
I3968 n1_m1_240000_96000 0 7.803986e-07
I3969 n1_m1_240000_100800 0 4.359190e-07
I3970 n1_m1_240000_105600 0 1.223459e-06
I3971 n1_m1_240000_110400 0 4.307857e-07
I3972 n1_m1_240000_115200 0 5.097597e-07
I3973 n1_m1_240000_120000 0 7.954294e-07
I3974 n1_m1_240000_124800 0 2.635714e-07
I3975 n1_m1_240000_129600 0 9.896367e-07
I3976 n1_m1_240000_134400 0 4.369418e-07
I3977 n1_m1_240000_139200 0 4.582944e-07
I3978 n1_m1_240000_144000 0 6.636177e-07
I3979 n1_m1_240000_148800 0 6.815476e-07
I3980 n1_m1_240000_153600 0 1.452095e-06
I3981 n1_m1_240000_158400 0 5.010571e-07
I3982 n1_m1_240000_163200 0 2.933857e-07
I3983 n1_m1_240000_168000 0 6.216548e-07
I3984 n1_m1_240000_172800 0 2.743929e-07
I3985 n1_m1_240000_177600 0 5.858940e-07
I3986 n1_m1_240000_182400 0 3.008571e-07
I3987 n1_m1_240000_187200 0 2.764286e-07
I3988 n1_m1_240000_192000 0 6.804881e-07
I3989 n1_m1_240000_196800 0 5.419797e-07
I3990 n1_m1_240000_201600 0 1.020830e-06
I3991 n1_m1_240000_206400 0 3.060337e-07
I3992 n1_m1_240000_211200 0 5.159982e-07
I3993 n1_m1_240000_216000 0 4.958531e-07
I3994 n1_m1_240000_220800 0 5.136283e-07
I3995 n1_m1_240000_225600 0 1.060336e-06
I3996 n1_m1_240000_230400 0 5.745680e-07
I3997 n1_m1_240000_235200 0 7.215929e-07
I3998 n1_m1_240000_240000 0 9.535771e-07
I3999 n1_m1_240000_244800 0 2.200989e-07
I4000 n1_m1_240000_249600 0 8.373063e-07
I4001 n1_m1_240000_254400 0 6.976690e-07
I4002 n1_m1_240000_259200 0 6.322524e-07
I4003 n1_m1_240000_264000 0 1.176165e-06
I4004 n1_m1_240000_268800 0 9.006429e-07
I4005 n1_m1_240000_273600 0 6.535000e-07
I4006 n1_m1_240000_278400 0 5.738474e-07
I4007 n1_m1_240000_283200 0 3.785080e-07
I4008 n1_m1_240000_288000 0 8.927429e-07
I4009 n1_m1_240000_292800 0 4.823214e-07
I4010 n1_m1_240000_297600 0 9.913518e-07
I4011 n1_m1_240000_302400 0 7.940774e-07
I4012 n1_m1_240000_307200 0 9.341861e-07
I4013 n1_m1_240000_312000 0 4.494703e-07
I4014 n1_m1_240000_316800 0 9.442353e-07
I4015 n1_m1_240000_321600 0 1.054100e-06
I4016 n1_m1_240000_326400 0 1.141616e-06
I4017 n1_m1_240000_331200 0 5.346314e-07
I4018 n1_m1_240000_336000 0 1.317513e-06
I4019 n1_m1_240000_340800 0 6.074545e-07
I4020 n1_m1_240000_345600 0 9.740969e-07
I4021 n1_m1_240000_350400 0 1.286287e-06
I4022 n1_m1_240000_355200 0 5.032857e-07
I4023 n1_m1_240000_360000 0 1.274177e-06
I4024 n1_m1_240000_364800 0 5.788398e-07
I4025 n1_m1_240000_369600 0 8.547888e-07
I4026 n1_m1_240000_374400 0 3.417448e-07
I4027 n1_m1_240000_379200 0 8.930357e-07
I4028 n1_m1_240000_384000 0 1.948568e-06
I4029 n1_m1_240000_388800 0 3.088479e-06
I4030 n1_m1_240000_393600 0 3.300176e-06
I4031 n1_m1_240000_398400 0 5.376846e-07
I4032 n1_m1_244800_4800 0 1.575621e-07
I4033 n1_m1_244800_9600 0 5.259248e-07
I4034 n1_m1_244800_14400 0 6.471266e-07
I4035 n1_m1_244800_19200 0 5.657316e-07
I4036 n1_m1_244800_24000 0 1.677431e-06
I4037 n1_m1_244800_28800 0 1.240074e-07
I4038 n1_m1_244800_33600 0 5.449750e-07
I4039 n1_m1_244800_38400 0 5.373931e-07
I4040 n1_m1_244800_43200 0 1.121077e-06
I4041 n1_m1_244800_48000 0 2.952713e-07
I4042 n1_m1_244800_52800 0 3.741955e-07
I4043 n1_m1_244800_57600 0 2.622455e-07
I4044 n1_m1_244800_62400 0 4.438571e-07
I4045 n1_m1_244800_67200 0 2.004286e-07
I4046 n1_m1_244800_72000 0 7.702410e-07
I4047 n1_m1_244800_76800 0 4.624301e-07
I4048 n1_m1_244800_81600 0 5.661526e-07
I4049 n1_m1_244800_86400 0 7.697959e-08
I4050 n1_m1_244800_91200 0 9.926531e-08
I4051 n1_m1_244800_96000 0 1.148020e-06
I4052 n1_m1_244800_100800 0 3.208571e-07
I4053 n1_m1_244800_105600 0 5.686984e-07
I4054 n1_m1_244800_110400 0 2.328571e-07
I4055 n1_m1_244800_115200 0 5.691709e-07
I4056 n1_m1_244800_120000 0 8.651998e-07
I4057 n1_m1_244800_124800 0 4.957143e-07
I4058 n1_m1_244800_129600 0 4.538776e-07
I4059 n1_m1_244800_134400 0 1.843367e-07
I4060 n1_m1_244800_139200 0 1.845032e-07
I4061 n1_m1_244800_144000 0 3.288584e-07
I4062 n1_m1_244800_148800 0 4.361905e-08
I4063 n1_m1_244800_153600 0 4.049048e-07
I4064 n1_m1_244800_158400 0 2.561714e-07
I4065 n1_m1_244800_163200 0 2.363619e-07
I4066 n1_m1_244800_168000 0 2.811405e-07
I4067 n1_m1_244800_172800 0 3.388738e-07
I4068 n1_m1_244800_177600 0 3.262917e-07
I4069 n1_m1_244800_182400 0 4.031071e-07
I4070 n1_m1_244800_187200 0 4.835510e-07
I4071 n1_m1_244800_192000 0 2.506276e-07
I4072 n1_m1_244800_196800 0 3.931610e-07
I4073 n1_m1_244800_201600 0 5.798816e-07
I4074 n1_m1_244800_206400 0 3.792684e-07
I4075 n1_m1_244800_211200 0 3.034048e-07
I4076 n1_m1_244800_216000 0 2.904041e-07
I4077 n1_m1_244800_220800 0 4.431574e-07
I4078 n1_m1_244800_225600 0 2.231604e-07
I4079 n1_m1_244800_230400 0 2.457118e-07
I4080 n1_m1_244800_235200 0 3.832494e-07
I4081 n1_m1_244800_240000 0 6.463361e-07
I4082 n1_m1_244800_244800 0 5.252987e-07
I4083 n1_m1_244800_249600 0 7.292814e-07
I4084 n1_m1_244800_254400 0 1.970976e-07
I4085 n1_m1_244800_259200 0 4.676905e-07
I4086 n1_m1_244800_264000 0 2.124955e-07
I4087 n1_m1_244800_268800 0 4.220857e-07
I4088 n1_m1_244800_273600 0 4.656571e-07
I4089 n1_m1_244800_278400 0 3.300000e-07
I4090 n1_m1_244800_283200 0 2.323810e-07
I4091 n1_m1_244800_288000 0 5.567381e-07
I4092 n1_m1_244800_292800 0 2.007738e-07
I4093 n1_m1_244800_297600 0 1.708267e-06
I4094 n1_m1_244800_302400 0 8.062976e-07
I4095 n1_m1_244800_307200 0 4.565728e-07
I4096 n1_m1_244800_312000 0 1.571077e-07
I4097 n1_m1_244800_316800 0 3.754228e-07
I4098 n1_m1_244800_321600 0 2.161429e-07
I4099 n1_m1_244800_326400 0 2.400000e-07
I4100 n1_m1_244800_331200 0 6.798214e-08
I4101 n1_m1_244800_336000 0 3.522696e-07
I4102 n1_m1_244800_340800 0 4.102026e-07
I4103 n1_m1_244800_345600 0 3.287221e-07
I4104 n1_m1_244800_350400 0 4.012059e-07
I4105 n1_m1_244800_355200 0 3.928286e-07
I4106 n1_m1_244800_360000 0 8.699130e-07
I4107 n1_m1_244800_364800 0 1.331830e-07
I4108 n1_m1_244800_369600 0 8.925357e-07
I4109 n1_m1_244800_374400 0 4.570231e-07
I4110 n1_m1_244800_379200 0 5.478214e-07
I4111 n1_m1_244800_384000 0 7.966417e-07
I4112 n1_m1_244800_388800 0 1.950415e-06
I4113 n1_m1_244800_393600 0 1.361418e-06
I4114 n1_m1_244800_398400 0 8.351020e-08
I4115 n1_m1_249600_4800 0 2.878462e-07
I4116 n1_m1_249600_9600 0 8.739030e-07
I4117 n1_m1_249600_14400 0 5.401875e-07
I4118 n1_m1_249600_19200 0 6.786753e-07
I4119 n1_m1_249600_24000 0 1.417898e-06
I4120 n1_m1_249600_28800 0 2.538214e-07
I4121 n1_m1_249600_33600 0 7.025824e-07
I4122 n1_m1_249600_38400 0 8.007212e-07
I4123 n1_m1_249600_43200 0 2.720308e-07
I4124 n1_m1_249600_48000 0 1.163282e-06
I4125 n1_m1_249600_52800 0 7.872500e-07
I4126 n1_m1_249600_57600 0 5.717520e-07
I4127 n1_m1_249600_62400 0 4.357892e-07
I4128 n1_m1_249600_67200 0 3.368505e-07
I4129 n1_m1_249600_72000 0 1.472648e-06
I4130 n1_m1_249600_76800 0 1.048578e-06
I4131 n1_m1_249600_81600 0 1.052845e-06
I4132 n1_m1_249600_86400 0 2.831033e-07
I4133 n1_m1_249600_91200 0 5.593495e-07
I4134 n1_m1_249600_96000 0 1.049660e-06
I4135 n1_m1_249600_100800 0 1.222149e-06
I4136 n1_m1_249600_105600 0 1.065919e-06
I4137 n1_m1_249600_110400 0 7.064386e-07
I4138 n1_m1_249600_115200 0 3.223828e-07
I4139 n1_m1_249600_120000 0 1.137348e-06
I4140 n1_m1_249600_124800 0 2.505357e-07
I4141 n1_m1_249600_129600 0 9.179000e-07
I4142 n1_m1_249600_134400 0 5.728143e-07
I4143 n1_m1_249600_139200 0 3.522024e-07
I4144 n1_m1_249600_144000 0 4.793467e-07
I4145 n1_m1_249600_148800 0 4.439086e-07
I4146 n1_m1_249600_153600 0 9.664524e-07
I4147 n1_m1_249600_158400 0 1.394214e-07
I4148 n1_m1_249600_163200 0 2.306538e-07
I4149 n1_m1_249600_168000 0 6.911619e-07
I4150 n1_m1_249600_172800 0 7.462234e-07
I4151 n1_m1_249600_177600 0 3.082753e-07
I4152 n1_m1_249600_182400 0 4.840357e-07
I4153 n1_m1_249600_187200 0 6.390204e-07
I4154 n1_m1_249600_192000 0 2.986510e-07
I4155 n1_m1_249600_196800 0 5.274686e-07
I4156 n1_m1_249600_201600 0 9.288098e-07
I4157 n1_m1_249600_206400 0 6.042988e-07
I4158 n1_m1_249600_211200 0 3.578810e-07
I4159 n1_m1_249600_216000 0 9.414357e-07
I4160 n1_m1_249600_220800 0 5.995769e-07
I4161 n1_m1_249600_225600 0 1.108518e-06
I4162 n1_m1_249600_230400 0 1.207365e-06
I4163 n1_m1_249600_235200 0 3.733810e-07
I4164 n1_m1_249600_240000 0 3.517130e-07
I4165 n1_m1_249600_244800 0 5.268351e-07
I4166 n1_m1_249600_249600 0 6.893368e-07
I4167 n1_m1_249600_254400 0 5.780667e-07
I4168 n1_m1_249600_259200 0 1.128698e-06
I4169 n1_m1_249600_264000 0 6.825016e-07
I4170 n1_m1_249600_268800 0 3.922611e-07
I4171 n1_m1_249600_273600 0 6.477000e-07
I4172 n1_m1_249600_278400 0 2.881429e-07
I4173 n1_m1_249600_283200 0 2.638649e-07
I4174 n1_m1_249600_288000 0 8.828503e-07
I4175 n1_m1_249600_292800 0 9.592473e-07
I4176 n1_m1_249600_297600 0 9.641037e-07
I4177 n1_m1_249600_302400 0 4.623051e-07
I4178 n1_m1_249600_307200 0 4.435714e-07
I4179 n1_m1_249600_312000 0 7.878929e-07
I4180 n1_m1_249600_316800 0 1.454319e-06
I4181 n1_m1_249600_321600 0 2.383079e-06
I4182 n1_m1_249600_326400 0 5.863077e-07
I4183 n1_m1_249600_331200 0 9.669712e-08
I4184 n1_m1_249600_336000 0 1.104610e-06
I4185 n1_m1_249600_340800 0 4.853846e-07
I4186 n1_m1_249600_345600 0 4.123524e-07
I4187 n1_m1_249600_350400 0 9.982232e-08
I4188 n1_m1_249600_355200 0 4.528315e-07
I4189 n1_m1_249600_360000 0 3.929320e-07
I4190 n1_m1_249600_364800 0 9.869063e-07
I4191 n1_m1_249600_369600 0 7.649091e-07
I4192 n1_m1_249600_374400 0 8.037505e-07
I4193 n1_m1_249600_379200 0 6.760179e-07
I4194 n1_m1_249600_384000 0 1.208403e-06
I4195 n1_m1_249600_388800 0 1.675188e-06
I4196 n1_m1_249600_393600 0 1.516932e-06
I4197 n1_m1_249600_398400 0 4.020000e-07
I4198 n1_m1_254400_4800 0 2.000000e-07
I4199 n1_m1_254400_9600 0 3.505128e-07
I4200 n1_m1_254400_14400 0 2.594872e-07
I4201 n1_m1_254400_19200 0 1.016735e-07
I4202 n1_m1_254400_24000 0 2.870857e-07
I4203 n1_m1_254400_28800 0 1.190357e-06
I4204 n1_m1_254400_33600 0 1.398527e-06
I4205 n1_m1_254400_38400 0 3.561779e-07
I4206 n1_m1_254400_43200 0 1.330923e-07
I4207 n1_m1_254400_48000 0 2.002730e-07
I4208 n1_m1_254400_52800 0 7.421990e-07
I4209 n1_m1_254400_57600 0 8.626611e-07
I4210 n1_m1_254400_62400 0 2.689510e-07
I4211 n1_m1_254400_67200 0 2.061293e-07
I4212 n1_m1_254400_72000 0 7.485510e-07
I4213 n1_m1_254400_76800 0 2.866330e-07
I4214 n1_m1_254400_81600 0 2.509945e-07
I4215 n1_m1_254400_86400 0 1.671571e-07
I4216 n1_m1_254400_91200 0 2.085105e-07
I4217 n1_m1_254400_96000 0 4.867900e-07
I4218 n1_m1_254400_100800 0 6.530893e-07
I4219 n1_m1_254400_105600 0 3.207955e-07
I4220 n1_m1_254400_110400 0 1.992757e-07
I4221 n1_m1_254400_115200 0 3.008172e-07
I4222 n1_m1_254400_120000 0 6.005455e-07
I4223 n1_m1_254400_124800 0 1.498777e-07
I4224 n1_m1_254400_129600 0 9.922035e-08
I4225 n1_m1_254400_134400 0 3.000000e-08
I4226 n1_m1_254400_139200 0 1.454762e-07
I4227 n1_m1_254400_144000 0 2.308390e-07
I4228 n1_m1_254400_148800 0 3.908429e-08
I4229 n1_m1_254400_153600 0 1.262286e-07
I4230 n1_m1_254400_158400 0 8.883571e-08
I4231 n1_m1_254400_163200 0 9.065097e-08
I4232 n1_m1_254400_168000 0 1.554643e-07
I4233 n1_m1_254400_172800 0 9.473853e-08
I4234 n1_m1_254400_177600 0 3.690913e-07
I4235 n1_m1_254400_182400 0 4.328571e-08
I4236 n1_m1_254400_187200 0 1.194286e-07
I4237 n1_m1_254400_192000 0 3.520524e-07
I4238 n1_m1_254400_196800 0 1.087800e-07
I4239 n1_m1_254400_201600 0 2.031852e-06
I4240 n1_m1_254400_206400 0 1.459399e-06
I4241 n1_m1_254400_211200 0 1.815714e-07
I4242 n1_m1_254400_216000 0 4.352619e-07
I4243 n1_m1_254400_220800 0 1.536016e-07
I4244 n1_m1_254400_225600 0 4.433393e-07
I4245 n1_m1_254400_230400 0 1.062857e-07
I4246 n1_m1_254400_235200 0 3.600000e-08
I4247 n1_m1_254400_240000 0 8.169286e-08
I4248 n1_m1_254400_244800 0 7.278052e-08
I4249 n1_m1_254400_249600 0 3.346753e-08
I4250 n1_m1_254400_254400 0 6.108571e-08
I4251 n1_m1_254400_259200 0 1.513968e-07
I4252 n1_m1_254400_264000 0 2.908135e-07
I4253 n1_m1_254400_268800 0 1.871659e-07
I4254 n1_m1_254400_273600 0 4.025714e-07
I4255 n1_m1_254400_278400 0 1.285714e-07
I4256 n1_m1_254400_283200 0 8.960649e-08
I4257 n1_m1_254400_288000 0 1.195544e-07
I4258 n1_m1_254400_292800 0 4.378663e-06
I4259 n1_m1_254400_297600 0 1.889632e-06
I4260 n1_m1_254400_302400 0 3.588423e-07
I4261 n1_m1_254400_307200 0 2.321909e-07
I4262 n1_m1_254400_312000 0 2.321049e-07
I4263 n1_m1_254400_316800 0 1.794474e-06
I4264 n1_m1_254400_321600 0 4.432064e-06
I4265 n1_m1_254400_326400 0 1.265495e-07
I4266 n1_m1_254400_331200 0 1.737761e-07
I4267 n1_m1_254400_336000 0 4.864147e-07
I4268 n1_m1_254400_340800 0 2.913686e-07
I4269 n1_m1_254400_345600 0 4.100000e-07
I4270 n1_m1_254400_350400 0 1.171875e-07
I4271 n1_m1_254400_355200 0 3.723539e-07
I4272 n1_m1_254400_360000 0 2.562965e-07
I4273 n1_m1_254400_364800 0 1.406250e-07
I4274 n1_m1_254400_369600 0 3.519121e-07
I4275 n1_m1_254400_374400 0 7.479341e-07
I4276 n1_m1_254400_379200 0 2.033798e-06
I4277 n1_m1_254400_384000 0 2.556932e-06
I4278 n1_m1_254400_388800 0 3.039123e-07
I4279 n1_m1_254400_393600 0 2.640682e-07
I4280 n1_m1_254400_398400 0 2.280000e-07
I4281 n1_m1_259200_4800 0 1.363077e-07
I4282 n1_m1_259200_9600 0 7.899483e-07
I4283 n1_m1_259200_14400 0 3.225625e-07
I4284 n1_m1_259200_19200 0 4.821071e-07
I4285 n1_m1_259200_24000 0 6.523429e-07
I4286 n1_m1_259200_28800 0 4.548482e-07
I4287 n1_m1_259200_33600 0 4.854066e-07
I4288 n1_m1_259200_38400 0 4.370354e-07
I4289 n1_m1_259200_43200 0 3.466731e-07
I4290 n1_m1_259200_48000 0 9.588999e-07
I4291 n1_m1_259200_52800 0 4.218776e-07
I4292 n1_m1_259200_57600 0 3.760273e-07
I4293 n1_m1_259200_62400 0 2.199886e-07
I4294 n1_m1_259200_67200 0 5.024465e-07
I4295 n1_m1_259200_72000 0 9.083032e-07
I4296 n1_m1_259200_76800 0 7.291612e-07
I4297 n1_m1_259200_81600 0 1.216984e-06
I4298 n1_m1_259200_86400 0 7.430122e-07
I4299 n1_m1_259200_91200 0 5.886797e-07
I4300 n1_m1_259200_96000 0 6.178609e-07
I4301 n1_m1_259200_100800 0 6.767802e-07
I4302 n1_m1_259200_105600 0 6.523614e-07
I4303 n1_m1_259200_110400 0 4.974214e-07
I4304 n1_m1_259200_115200 0 7.225304e-07
I4305 n1_m1_259200_120000 0 7.970788e-07
I4306 n1_m1_259200_124800 0 7.515368e-07
I4307 n1_m1_259200_129600 0 3.502085e-07
I4308 n1_m1_259200_134400 0 4.266065e-07
I4309 n1_m1_259200_139200 0 2.044330e-07
I4310 n1_m1_259200_144000 0 7.912643e-07
I4311 n1_m1_259200_148800 0 1.436250e-07
I4312 n1_m1_259200_153600 0 6.047286e-07
I4313 n1_m1_259200_158400 0 1.776190e-07
I4314 n1_m1_259200_163200 0 5.208571e-08
I4315 n1_m1_259200_168000 0 7.589159e-07
I4316 n1_m1_259200_172800 0 1.401388e-07
I4317 n1_m1_259200_177600 0 1.114085e-06
I4318 n1_m1_259200_182400 0 2.912857e-07
I4319 n1_m1_259200_187200 0 3.518503e-07
I4320 n1_m1_259200_192000 0 1.162753e-06
I4321 n1_m1_259200_196800 0 2.219803e-07
I4322 n1_m1_259200_201600 0 3.121619e-07
I4323 n1_m1_259200_206400 0 5.424823e-07
I4324 n1_m1_259200_211200 0 1.743000e-07
I4325 n1_m1_259200_216000 0 6.795700e-07
I4326 n1_m1_259200_220800 0 3.116286e-07
I4327 n1_m1_259200_225600 0 2.090000e-07
I4328 n1_m1_259200_230400 0 4.117143e-07
I4329 n1_m1_259200_235200 0 1.628571e-08
I4330 n1_m1_259200_240000 0 4.408143e-07
I4331 n1_m1_259200_244800 0 2.410857e-07
I4332 n1_m1_259200_249600 0 7.175714e-07
I4333 n1_m1_259200_254400 0 1.854000e-07
I4334 n1_m1_259200_259200 0 5.528571e-07
I4335 n1_m1_259200_264000 0 3.580000e-07
I4336 n1_m1_259200_268800 0 1.770286e-07
I4337 n1_m1_259200_273600 0 2.683500e-07
I4338 n1_m1_259200_278400 0 8.357143e-08
I4339 n1_m1_259200_283200 0 2.245714e-07
I4340 n1_m1_259200_288000 0 2.450571e-07
I4341 n1_m1_259200_292800 0 2.427857e-07
I4342 n1_m1_259200_297600 0 3.148705e-07
I4343 n1_m1_259200_302400 0 4.424988e-07
I4344 n1_m1_259200_307200 0 2.840625e-07
I4345 n1_m1_259200_312000 0 8.470046e-07
I4346 n1_m1_259200_316800 0 5.136357e-07
I4347 n1_m1_259200_321600 0 8.457830e-07
I4348 n1_m1_259200_326400 0 4.663571e-07
I4349 n1_m1_259200_331200 0 7.672321e-08
I4350 n1_m1_259200_336000 0 3.954080e-07
I4351 n1_m1_259200_340800 0 4.286649e-07
I4352 n1_m1_259200_345600 0 2.722286e-07
I4353 n1_m1_259200_350400 0 2.324712e-07
I4354 n1_m1_259200_355200 0 2.896607e-07
I4355 n1_m1_259200_360000 0 1.020381e-06
I4356 n1_m1_259200_364800 0 1.802380e-07
I4357 n1_m1_259200_369600 0 6.343295e-07
I4358 n1_m1_259200_374400 0 1.563509e-07
I4359 n1_m1_259200_379200 0 6.247500e-07
I4360 n1_m1_259200_384000 0 7.446811e-07
I4361 n1_m1_259200_388800 0 3.017069e-07
I4362 n1_m1_259200_393600 0 4.608321e-07
I4363 n1_m1_259200_398400 0 1.825714e-07
I4364 n1_m1_264000_4800 0 3.184615e-07
I4365 n1_m1_264000_9600 0 9.902617e-07
I4366 n1_m1_264000_14400 0 5.511107e-07
I4367 n1_m1_264000_19200 0 6.393607e-07
I4368 n1_m1_264000_24000 0 5.561956e-07
I4369 n1_m1_264000_28800 0 7.561446e-07
I4370 n1_m1_264000_33600 0 1.191426e-06
I4371 n1_m1_264000_38400 0 1.082161e-06
I4372 n1_m1_264000_43200 0 1.845096e-07
I4373 n1_m1_264000_48000 0 7.125975e-07
I4374 n1_m1_264000_52800 0 4.411664e-07
I4375 n1_m1_264000_57600 0 8.149591e-07
I4376 n1_m1_264000_62400 0 7.521650e-07
I4377 n1_m1_264000_67200 0 6.570459e-07
I4378 n1_m1_264000_72000 0 1.197917e-06
I4379 n1_m1_264000_76800 0 7.593839e-07
I4380 n1_m1_264000_81600 0 1.389021e-06
I4381 n1_m1_264000_86400 0 1.302988e-06
I4382 n1_m1_264000_91200 0 7.519341e-07
I4383 n1_m1_264000_96000 0 7.075769e-06
I4384 n1_m1_264000_100800 0 2.662997e-06
I4385 n1_m1_264000_105600 0 6.603045e-07
I4386 n1_m1_264000_110400 0 2.894714e-07
I4387 n1_m1_264000_115200 0 6.679641e-07
I4388 n1_m1_264000_120000 0 3.410511e-07
I4389 n1_m1_264000_124800 0 5.553598e-07
I4390 n1_m1_264000_129600 0 1.542613e-06
I4391 n1_m1_264000_134400 0 1.047188e-06
I4392 n1_m1_264000_139200 0 6.415625e-07
I4393 n1_m1_264000_144000 0 1.780810e-06
I4394 n1_m1_264000_148800 0 1.684611e-06
I4395 n1_m1_264000_153600 0 7.470036e-07
I4396 n1_m1_264000_158400 0 3.537810e-07
I4397 n1_m1_264000_163200 0 2.987714e-07
I4398 n1_m1_264000_168000 0 8.750198e-07
I4399 n1_m1_264000_172800 0 1.980214e-07
I4400 n1_m1_264000_177600 0 7.992179e-07
I4401 n1_m1_264000_182400 0 5.770857e-07
I4402 n1_m1_264000_187200 0 8.842306e-07
I4403 n1_m1_264000_192000 0 1.790045e-06
I4404 n1_m1_264000_196800 0 8.377244e-07
I4405 n1_m1_264000_201600 0 1.109321e-06
I4406 n1_m1_264000_206400 0 4.970040e-07
I4407 n1_m1_264000_211200 0 1.578714e-06
I4408 n1_m1_264000_216000 0 1.013694e-06
I4409 n1_m1_264000_220800 0 1.866836e-06
I4410 n1_m1_264000_225600 0 9.043413e-07
I4411 n1_m1_264000_230400 0 1.232048e-06
I4412 n1_m1_264000_235200 0 1.912000e-07
I4413 n1_m1_264000_240000 0 1.160874e-06
I4414 n1_m1_264000_244800 0 2.905143e-07
I4415 n1_m1_264000_249600 0 8.449714e-07
I4416 n1_m1_264000_254400 0 2.340095e-07
I4417 n1_m1_264000_259200 0 6.395429e-07
I4418 n1_m1_264000_264000 0 5.911857e-07
I4419 n1_m1_264000_268800 0 3.348571e-07
I4420 n1_m1_264000_273600 0 1.457879e-06
I4421 n1_m1_264000_278400 0 7.679286e-07
I4422 n1_m1_264000_283200 0 5.636226e-07
I4423 n1_m1_264000_288000 0 5.828143e-07
I4424 n1_m1_264000_292800 0 5.144000e-06
I4425 n1_m1_264000_297600 0 2.720681e-06
I4426 n1_m1_264000_302400 0 9.692682e-07
I4427 n1_m1_264000_307200 0 6.464286e-07
I4428 n1_m1_264000_312000 0 1.261353e-06
I4429 n1_m1_264000_316800 0 6.763368e-07
I4430 n1_m1_264000_321600 0 9.586545e-07
I4431 n1_m1_264000_326400 0 3.364500e-07
I4432 n1_m1_264000_331200 0 3.327119e-07
I4433 n1_m1_264000_336000 0 1.052955e-06
I4434 n1_m1_264000_340800 0 6.464500e-07
I4435 n1_m1_264000_345600 0 9.331724e-07
I4436 n1_m1_264000_350400 0 3.618267e-07
I4437 n1_m1_264000_355200 0 7.026286e-07
I4438 n1_m1_264000_360000 0 1.947274e-06
I4439 n1_m1_264000_364800 0 2.439241e-07
I4440 n1_m1_264000_369600 0 1.155123e-06
I4441 n1_m1_264000_374400 0 3.880869e-07
I4442 n1_m1_264000_379200 0 8.132143e-07
I4443 n1_m1_264000_384000 0 8.713323e-07
I4444 n1_m1_264000_388800 0 4.998776e-07
I4445 n1_m1_264000_393600 0 1.407521e-06
I4446 n1_m1_264000_398400 0 2.151429e-07
I4447 n1_m1_268800_4800 0 1.409231e-07
I4448 n1_m1_268800_9600 0 8.833269e-07
I4449 n1_m1_268800_14400 0 2.110714e-07
I4450 n1_m1_268800_19200 0 6.768661e-07
I4451 n1_m1_268800_24000 0 2.603517e-07
I4452 n1_m1_268800_28800 0 5.084866e-07
I4453 n1_m1_268800_33600 0 5.462475e-07
I4454 n1_m1_268800_38400 0 3.245125e-07
I4455 n1_m1_268800_43200 0 6.438462e-08
I4456 n1_m1_268800_48000 0 8.416937e-07
I4457 n1_m1_268800_52800 0 2.170685e-06
I4458 n1_m1_268800_57600 0 2.349480e-07
I4459 n1_m1_268800_62400 0 6.115673e-07
I4460 n1_m1_268800_67200 0 3.971558e-07
I4461 n1_m1_268800_72000 0 2.554827e-06
I4462 n1_m1_268800_76800 0 1.096071e-06
I4463 n1_m1_268800_81600 0 7.217589e-07
I4464 n1_m1_268800_86400 0 3.048599e-07
I4465 n1_m1_268800_91200 0 6.655687e-07
I4466 n1_m1_268800_96000 0 1.550676e-06
I4467 n1_m1_268800_100800 0 9.521066e-07
I4468 n1_m1_268800_105600 0 6.503502e-07
I4469 n1_m1_268800_110400 0 4.522857e-07
I4470 n1_m1_268800_115200 0 5.423626e-07
I4471 n1_m1_268800_120000 0 7.392571e-07
I4472 n1_m1_268800_124800 0 4.841250e-07
I4473 n1_m1_268800_129600 0 1.152365e-06
I4474 n1_m1_268800_134400 0 8.369914e-07
I4475 n1_m1_268800_139200 0 5.683616e-07
I4476 n1_m1_268800_144000 0 3.071333e-07
I4477 n1_m1_268800_148800 0 2.003357e-07
I4478 n1_m1_268800_153600 0 5.747250e-07
I4479 n1_m1_268800_158400 0 1.287429e-07
I4480 n1_m1_268800_163200 0 1.804000e-07
I4481 n1_m1_268800_168000 0 5.586754e-07
I4482 n1_m1_268800_172800 0 2.993500e-07
I4483 n1_m1_268800_177600 0 3.344884e-07
I4484 n1_m1_268800_182400 0 2.097013e-07
I4485 n1_m1_268800_187200 0 1.852387e-07
I4486 n1_m1_268800_192000 0 5.837116e-07
I4487 n1_m1_268800_196800 0 3.183810e-07
I4488 n1_m1_268800_201600 0 4.820500e-07
I4489 n1_m1_268800_206400 0 3.492399e-07
I4490 n1_m1_268800_211200 0 2.587033e-07
I4491 n1_m1_268800_216000 0 4.077000e-07
I4492 n1_m1_268800_220800 0 1.578429e-07
I4493 n1_m1_268800_225600 0 2.158988e-07
I4494 n1_m1_268800_230400 0 7.459286e-08
I4495 n1_m1_268800_235200 0 2.190000e-07
I4496 n1_m1_268800_240000 0 2.607357e-07
I4497 n1_m1_268800_244800 0 2.063143e-07
I4498 n1_m1_268800_249600 0 6.560857e-07
I4499 n1_m1_268800_254400 0 8.449276e-07
I4500 n1_m1_268800_259200 0 6.148000e-07
I4501 n1_m1_268800_264000 0 4.851000e-07
I4502 n1_m1_268800_268800 0 1.227000e-07
I4503 n1_m1_268800_273600 0 6.115857e-07
I4504 n1_m1_268800_278400 0 1.930714e-07
I4505 n1_m1_268800_283200 0 2.311274e-07
I4506 n1_m1_268800_288000 0 6.516532e-07
I4507 n1_m1_268800_292800 0 1.844061e-06
I4508 n1_m1_268800_297600 0 1.239662e-06
I4509 n1_m1_268800_302400 0 5.620725e-07
I4510 n1_m1_268800_307200 0 2.850000e-07
I4511 n1_m1_268800_312000 0 4.092857e-08
I4512 n1_m1_268800_316800 0 5.056034e-07
I4513 n1_m1_268800_321600 0 6.766214e-07
I4514 n1_m1_268800_326400 0 6.494679e-07
I4515 n1_m1_268800_331200 0 2.341470e-07
I4516 n1_m1_268800_336000 0 9.995657e-07
I4517 n1_m1_268800_340800 0 5.676786e-07
I4518 n1_m1_268800_345600 0 6.184724e-07
I4519 n1_m1_268800_350400 0 7.344960e-07
I4520 n1_m1_268800_355200 0 6.364490e-07
I4521 n1_m1_268800_360000 0 9.502679e-07
I4522 n1_m1_268800_364800 0 2.320393e-07
I4523 n1_m1_268800_369600 0 8.191744e-07
I4524 n1_m1_268800_374400 0 6.054254e-07
I4525 n1_m1_268800_379200 0 5.662321e-07
I4526 n1_m1_268800_384000 0 8.471964e-07
I4527 n1_m1_268800_388800 0 3.120659e-07
I4528 n1_m1_268800_393600 0 4.128014e-07
I4529 n1_m1_268800_398400 0 2.118571e-07
I4530 n1_m1_273600_4800 0 2.716923e-07
I4531 n1_m1_273600_9600 0 4.043077e-07
I4532 n1_m1_273600_14400 0 1.681205e-07
I4533 n1_m1_273600_19200 0 6.592946e-07
I4534 n1_m1_273600_24000 0 3.650714e-07
I4535 n1_m1_273600_28800 0 6.740848e-07
I4536 n1_m1_273600_33600 0 9.751344e-07
I4537 n1_m1_273600_38400 0 9.380782e-07
I4538 n1_m1_273600_43200 0 3.329769e-07
I4539 n1_m1_273600_48000 0 7.649638e-07
I4540 n1_m1_273600_52800 0 2.857754e-06
I4541 n1_m1_273600_57600 0 1.158195e-06
I4542 n1_m1_273600_62400 0 3.603738e-07
I4543 n1_m1_273600_67200 0 8.251013e-07
I4544 n1_m1_273600_72000 0 1.506128e-06
I4545 n1_m1_273600_76800 0 1.771929e-06
I4546 n1_m1_273600_81600 0 1.273957e-06
I4547 n1_m1_273600_86400 0 8.579880e-07
I4548 n1_m1_273600_91200 0 7.783671e-07
I4549 n1_m1_273600_96000 0 6.147462e-06
I4550 n1_m1_273600_100800 0 2.349699e-06
I4551 n1_m1_273600_105600 0 1.392883e-06
I4552 n1_m1_273600_110400 0 2.958163e-07
I4553 n1_m1_273600_115200 0 4.601000e-07
I4554 n1_m1_273600_120000 0 3.236571e-07
I4555 n1_m1_273600_124800 0 2.151786e-07
I4556 n1_m1_273600_129600 0 6.777450e-07
I4557 n1_m1_273600_134400 0 3.710705e-07
I4558 n1_m1_273600_139200 0 8.660000e-07
I4559 n1_m1_273600_144000 0 6.426786e-07
I4560 n1_m1_273600_148800 0 3.986857e-07
I4561 n1_m1_273600_153600 0 9.960000e-07
I4562 n1_m1_273600_158400 0 7.266857e-07
I4563 n1_m1_273600_163200 0 4.420429e-07
I4564 n1_m1_273600_168000 0 1.231868e-06
I4565 n1_m1_273600_172800 0 6.457143e-08
I4566 n1_m1_273600_177600 0 1.532494e-06
I4567 n1_m1_273600_182400 0 1.294671e-06
I4568 n1_m1_273600_187200 0 5.995418e-07
I4569 n1_m1_273600_192000 0 1.243777e-06
I4570 n1_m1_273600_196800 0 5.676833e-07
I4571 n1_m1_273600_201600 0 1.390023e-06
I4572 n1_m1_273600_206400 0 2.096401e-07
I4573 n1_m1_273600_211200 0 6.552482e-07
I4574 n1_m1_273600_216000 0 8.415357e-07
I4575 n1_m1_273600_220800 0 9.788036e-07
I4576 n1_m1_273600_225600 0 1.817012e-06
I4577 n1_m1_273600_230400 0 5.922857e-07
I4578 n1_m1_273600_235200 0 9.512857e-07
I4579 n1_m1_273600_240000 0 3.320825e-07
I4580 n1_m1_273600_244800 0 2.925061e-07
I4581 n1_m1_273600_249600 0 1.285087e-06
I4582 n1_m1_273600_254400 0 4.678183e-07
I4583 n1_m1_273600_259200 0 4.422655e-07
I4584 n1_m1_273600_264000 0 1.184530e-06
I4585 n1_m1_273600_268800 0 2.846143e-07
I4586 n1_m1_273600_273600 0 6.757714e-07
I4587 n1_m1_273600_278400 0 4.027143e-07
I4588 n1_m1_273600_283200 0 3.600071e-07
I4589 n1_m1_273600_288000 0 8.483182e-07
I4590 n1_m1_273600_292800 0 5.147959e-07
I4591 n1_m1_273600_297600 0 1.025481e-06
I4592 n1_m1_273600_302400 0 7.225330e-07
I4593 n1_m1_273600_307200 0 5.711339e-07
I4594 n1_m1_273600_312000 0 9.974286e-07
I4595 n1_m1_273600_316800 0 7.023032e-07
I4596 n1_m1_273600_321600 0 1.420061e-06
I4597 n1_m1_273600_326400 0 7.085261e-07
I4598 n1_m1_273600_331200 0 2.397905e-07
I4599 n1_m1_273600_336000 0 1.230269e-06
I4600 n1_m1_273600_340800 0 3.550000e-07
I4601 n1_m1_273600_345600 0 8.147695e-07
I4602 n1_m1_273600_350400 0 6.805517e-07
I4603 n1_m1_273600_355200 0 3.598939e-07
I4604 n1_m1_273600_360000 0 9.403054e-07
I4605 n1_m1_273600_364800 0 4.066250e-07
I4606 n1_m1_273600_369600 0 1.030364e-06
I4607 n1_m1_273600_374400 0 4.528250e-07
I4608 n1_m1_273600_379200 0 6.789796e-08
I4609 n1_m1_273600_384000 0 9.405810e-07
I4610 n1_m1_273600_388800 0 5.165381e-07
I4611 n1_m1_273600_393600 0 1.412185e-06
I4612 n1_m1_273600_398400 0 1.968286e-07
I4613 n1_m1_278400_4800 0 2.446154e-07
I4614 n1_m1_278400_9600 0 2.683846e-07
I4615 n1_m1_278400_14400 0 3.065250e-07
I4616 n1_m1_278400_19200 0 3.182473e-07
I4617 n1_m1_278400_24000 0 8.635859e-07
I4618 n1_m1_278400_28800 0 3.865000e-07
I4619 n1_m1_278400_33600 0 3.319178e-07
I4620 n1_m1_278400_38400 0 3.414382e-07
I4621 n1_m1_278400_43200 0 3.200962e-07
I4622 n1_m1_278400_48000 0 8.415536e-07
I4623 n1_m1_278400_52800 0 4.449089e-07
I4624 n1_m1_278400_57600 0 7.954107e-07
I4625 n1_m1_278400_62400 0 5.132500e-07
I4626 n1_m1_278400_67200 0 3.140571e-07
I4627 n1_m1_278400_72000 0 5.538235e-07
I4628 n1_m1_278400_76800 0 2.597692e-07
I4629 n1_m1_278400_81600 0 3.873559e-07
I4630 n1_m1_278400_86400 0 2.778903e-07
I4631 n1_m1_278400_91200 0 3.558926e-07
I4632 n1_m1_278400_96000 0 3.549216e-07
I4633 n1_m1_278400_100800 0 1.792368e-07
I4634 n1_m1_278400_105600 0 7.254092e-07
I4635 n1_m1_278400_110400 0 2.593265e-07
I4636 n1_m1_278400_115200 0 3.976086e-07
I4637 n1_m1_278400_120000 0 8.146976e-07
I4638 n1_m1_278400_124800 0 6.696429e-07
I4639 n1_m1_278400_129600 0 1.139732e-06
I4640 n1_m1_278400_134400 0 2.971774e-07
I4641 n1_m1_278400_139200 0 1.140595e-07
I4642 n1_m1_278400_144000 0 3.852041e-07
I4643 n1_m1_278400_148800 0 2.055638e-07
I4644 n1_m1_278400_153600 0 3.140571e-07
I4645 n1_m1_278400_158400 0 2.912408e-07
I4646 n1_m1_278400_163200 0 1.015592e-07
I4647 n1_m1_278400_168000 0 9.744543e-07
I4648 n1_m1_278400_172800 0 3.418198e-07
I4649 n1_m1_278400_177600 0 4.365050e-07
I4650 n1_m1_278400_182400 0 4.521991e-07
I4651 n1_m1_278400_187200 0 4.391481e-07
I4652 n1_m1_278400_192000 0 1.466286e-07
I4653 n1_m1_278400_196800 0 2.024143e-07
I4654 n1_m1_278400_201600 0 7.361671e-07
I4655 n1_m1_278400_206400 0 1.135385e-07
I4656 n1_m1_278400_211200 0 6.632946e-07
I4657 n1_m1_278400_216000 0 1.913566e-06
I4658 n1_m1_278400_220800 0 3.764256e-07
I4659 n1_m1_278400_225600 0 3.124985e-07
I4660 n1_m1_278400_235200 0 5.888889e-07
I4661 n1_m1_278400_240000 0 2.245447e-07
I4662 n1_m1_278400_244800 0 1.552289e-07
I4663 n1_m1_278400_249600 0 9.276716e-07
I4664 n1_m1_278400_254400 0 2.425895e-07
I4665 n1_m1_278400_259200 0 8.647736e-08
I4666 n1_m1_278400_264000 0 7.407317e-07
I4667 n1_m1_278400_268800 0 1.616190e-07
I4668 n1_m1_278400_273600 0 5.260635e-07
I4669 n1_m1_278400_278400 0 3.089286e-07
I4670 n1_m1_278400_283200 0 1.492286e-07
I4671 n1_m1_278400_288000 0 3.174000e-07
I4672 n1_m1_278400_292800 0 2.400000e-07
I4673 n1_m1_278400_297600 0 1.104571e-06
I4674 n1_m1_278400_302400 0 3.130058e-07
I4675 n1_m1_278400_307200 0 2.790946e-07
I4676 n1_m1_278400_312000 0 4.897577e-07
I4677 n1_m1_278400_316800 0 7.497802e-08
I4678 n1_m1_278400_321600 0 5.574746e-07
I4679 n1_m1_278400_326400 0 3.798489e-07
I4680 n1_m1_278400_331200 0 2.301042e-07
I4681 n1_m1_278400_336000 0 1.150906e-06
I4682 n1_m1_278400_340800 0 4.354286e-07
I4683 n1_m1_278400_345600 0 3.455036e-07
I4684 n1_m1_278400_350400 0 2.132143e-07
I4685 n1_m1_278400_360000 0 7.087115e-07
I4686 n1_m1_278400_364800 0 6.391978e-08
I4687 n1_m1_278400_369600 0 7.192134e-07
I4688 n1_m1_278400_374400 0 2.876284e-07
I4689 n1_m1_278400_379200 0 1.147649e-07
I4690 n1_m1_278400_384000 0 5.543628e-07
I4691 n1_m1_278400_388800 0 5.419592e-08
I4692 n1_m1_278400_393600 0 4.279512e-07
I4693 n1_m1_278400_398400 0 2.505714e-07
I4694 n1_m1_283200_4800 0 1.569231e-08
I4695 n1_m1_283200_9600 0 4.160577e-07
I4696 n1_m1_283200_14400 0 8.076683e-08
I4697 n1_m1_283200_19200 0 1.446635e-07
I4698 n1_m1_283200_24000 0 4.238293e-07
I4699 n1_m1_283200_28800 0 2.953348e-07
I4700 n1_m1_283200_33600 0 2.006027e-07
I4701 n1_m1_283200_38400 0 2.875000e-07
I4702 n1_m1_283200_43200 0 3.033510e-07
I4703 n1_m1_283200_48000 0 1.779082e-07
I4704 n1_m1_283200_52800 0 8.186154e-08
I4705 n1_m1_283200_57600 0 3.029928e-07
I4706 n1_m1_283200_62400 0 2.244032e-07
I4707 n1_m1_283200_67200 0 1.703125e-07
I4708 n1_m1_283200_72000 0 1.586339e-07
I4709 n1_m1_283200_76800 0 3.883425e-07
I4710 n1_m1_283200_81600 0 2.163393e-07
I4711 n1_m1_283200_86400 0 8.034320e-09
I4712 n1_m1_283200_91200 0 1.877385e-07
I4713 n1_m1_283200_96000 0 2.873160e-07
I4714 n1_m1_283200_100800 0 2.709587e-07
I4715 n1_m1_283200_105600 0 7.239560e-08
I4716 n1_m1_283200_110400 0 5.760714e-08
I4717 n1_m1_283200_115200 0 2.443629e-07
I4718 n1_m1_283200_120000 0 4.372667e-07
I4719 n1_m1_283200_124800 0 3.773214e-07
I4720 n1_m1_283200_129600 0 2.929591e-07
I4721 n1_m1_283200_134400 0 1.509106e-07
I4722 n1_m1_283200_139200 0 3.815476e-08
I4723 n1_m1_283200_144000 0 1.670735e-07
I4724 n1_m1_283200_148800 0 1.172414e-07
I4725 n1_m1_283200_153600 0 1.266786e-07
I4726 n1_m1_283200_158400 0 1.073497e-07
I4727 n1_m1_283200_163200 0 1.381224e-08
I4728 n1_m1_283200_168000 0 4.596038e-07
I4729 n1_m1_283200_172800 0 3.540061e-07
I4730 n1_m1_283200_177600 0 1.325617e-07
I4731 n1_m1_283200_182400 0 1.377662e-07
I4732 n1_m1_283200_187200 0 1.516883e-07
I4733 n1_m1_283200_192000 0 1.291000e-07
I4734 n1_m1_283200_196800 0 5.155000e-08
I4735 n1_m1_283200_201600 0 2.962857e-07
I4736 n1_m1_283200_206400 0 3.464286e-09
I4737 n1_m1_283200_211200 0 1.174750e-07
I4738 n1_m1_283200_216000 0 5.132771e-07
I4739 n1_m1_283200_220800 0 2.955796e-07
I4740 n1_m1_283200_225600 0 5.546857e-07
I4741 n1_m1_283200_230400 0 2.392273e-07
I4742 n1_m1_283200_235200 0 2.226276e-07
I4743 n1_m1_283200_240000 0 1.614160e-07
I4744 n1_m1_283200_244800 0 4.049610e-08
I4745 n1_m1_283200_249600 0 1.561046e-07
I4746 n1_m1_283200_254400 0 2.959184e-08
I4747 n1_m1_283200_264000 0 2.448810e-07
I4748 n1_m1_283200_268800 0 9.634921e-08
I4749 n1_m1_283200_273600 0 4.048889e-07
I4750 n1_m1_283200_278400 0 7.892857e-08
I4751 n1_m1_283200_283200 0 3.794286e-08
I4752 n1_m1_283200_288000 0 2.064333e-07
I4753 n1_m1_283200_292800 0 1.854762e-07
I4754 n1_m1_283200_297600 0 1.895440e-07
I4755 n1_m1_283200_302400 0 1.724691e-08
I4756 n1_m1_283200_307200 0 7.420000e-08
I4757 n1_m1_283200_312000 0 5.093085e-07
I4758 n1_m1_283200_316800 0 1.670594e-07
I4759 n1_m1_283200_321600 0 5.368304e-07
I4760 n1_m1_283200_326400 0 3.830357e-07
I4761 n1_m1_283200_331200 0 3.114132e-07
I4762 n1_m1_283200_336000 0 1.767731e-07
I4763 n1_m1_283200_340800 0 1.134176e-07
I4764 n1_m1_283200_345600 0 2.688255e-07
I4765 n1_m1_283200_350400 0 2.878929e-07
I4766 n1_m1_283200_355200 0 1.885714e-08
I4767 n1_m1_283200_360000 0 5.334375e-07
I4768 n1_m1_283200_364800 0 1.049231e-07
I4769 n1_m1_283200_369600 0 4.332589e-07
I4770 n1_m1_283200_374400 0 1.891511e-06
I4771 n1_m1_283200_379200 0 1.041800e-07
I4772 n1_m1_283200_384000 0 1.465179e-07
I4773 n1_m1_283200_388800 0 5.363839e-08
I4774 n1_m1_283200_393600 0 2.411577e-07
I4775 n1_m1_283200_398400 0 1.265714e-07
I4776 n1_m1_288000_4800 0 1.140355e-07
I4777 n1_m1_288000_9600 0 5.734467e-07
I4778 n1_m1_288000_14400 0 2.608671e-07
I4779 n1_m1_288000_19200 0 3.060314e-07
I4780 n1_m1_288000_24000 0 6.609320e-07
I4781 n1_m1_288000_28800 0 4.198527e-07
I4782 n1_m1_288000_33600 0 7.694811e-07
I4783 n1_m1_288000_38400 0 6.656731e-06
I4784 n1_m1_288000_43200 0 4.774255e-07
I4785 n1_m1_288000_48000 0 2.871204e-07
I4786 n1_m1_288000_52800 0 5.849719e-07
I4787 n1_m1_288000_57600 0 1.576703e-06
I4788 n1_m1_288000_62400 0 1.023910e-06
I4789 n1_m1_288000_67200 0 5.317302e-07
I4790 n1_m1_288000_72000 0 9.329748e-07
I4791 n1_m1_288000_76800 0 2.098462e-07
I4792 n1_m1_288000_81600 0 4.682116e-07
I4793 n1_m1_288000_86400 0 3.517662e-07
I4794 n1_m1_288000_91200 0 4.926894e-07
I4795 n1_m1_288000_96000 0 1.969419e-07
I4796 n1_m1_288000_100800 0 3.304589e-07
I4797 n1_m1_288000_105600 0 6.515661e-07
I4798 n1_m1_288000_110400 0 2.526000e-07
I4799 n1_m1_288000_115200 0 2.247534e-07
I4800 n1_m1_288000_120000 0 5.260241e-07
I4801 n1_m1_288000_124800 0 8.071429e-08
I4802 n1_m1_288000_129600 0 5.290071e-07
I4803 n1_m1_288000_134400 0 3.382250e-07
I4804 n1_m1_288000_139200 0 1.808571e-07
I4805 n1_m1_288000_144000 0 9.588825e-07
I4806 n1_m1_288000_148800 0 1.898429e-07
I4807 n1_m1_288000_153600 0 5.581714e-07
I4808 n1_m1_288000_158400 0 2.742857e-07
I4809 n1_m1_288000_163200 0 1.498286e-07
I4810 n1_m1_288000_168000 0 1.765714e-07
I4811 n1_m1_288000_172800 0 9.857143e-08
I4812 n1_m1_288000_177600 0 5.423758e-07
I4813 n1_m1_288000_182400 0 3.886857e-07
I4814 n1_m1_288000_187200 0 2.800571e-07
I4815 n1_m1_288000_192000 0 7.170943e-07
I4816 n1_m1_288000_196800 0 2.697881e-07
I4817 n1_m1_288000_201600 0 7.769238e-07
I4818 n1_m1_288000_206400 0 4.013571e-07
I4819 n1_m1_288000_211200 0 7.539334e-07
I4820 n1_m1_288000_216000 0 4.617281e-07
I4821 n1_m1_288000_220800 0 1.784107e-07
I4822 n1_m1_288000_225600 0 4.061313e-07
I4823 n1_m1_288000_230400 0 3.596916e-07
I4824 n1_m1_288000_235200 0 2.496000e-07
I4825 n1_m1_288000_240000 0 2.703381e-07
I4826 n1_m1_288000_244800 0 4.348571e-07
I4827 n1_m1_288000_249600 0 5.452381e-07
I4828 n1_m1_288000_254400 0 1.618619e-07
I4829 n1_m1_288000_259200 0 2.295143e-07
I4830 n1_m1_288000_264000 0 6.836980e-07
I4831 n1_m1_288000_268800 0 1.805586e-07
I4832 n1_m1_288000_273600 0 2.841667e-07
I4833 n1_m1_288000_278400 0 4.576990e-07
I4834 n1_m1_288000_283200 0 1.529143e-07
I4835 n1_m1_288000_288000 0 4.175510e-07
I4836 n1_m1_288000_292800 0 4.920536e-07
I4837 n1_m1_288000_297600 0 1.126410e-06
I4838 n1_m1_288000_302400 0 6.583393e-07
I4839 n1_m1_288000_307200 0 2.337755e-07
I4840 n1_m1_288000_312000 0 8.428048e-07
I4841 n1_m1_288000_316800 0 1.058117e-07
I4842 n1_m1_288000_321600 0 1.141222e-06
I4843 n1_m1_288000_326400 0 4.694469e-07
I4844 n1_m1_288000_331200 0 1.687993e-07
I4845 n1_m1_288000_336000 0 7.047923e-07
I4846 n1_m1_288000_340800 0 5.213680e-07
I4847 n1_m1_288000_345600 0 3.936973e-07
I4848 n1_m1_288000_350400 0 8.521652e-07
I4849 n1_m1_288000_355200 0 2.902816e-07
I4850 n1_m1_288000_360000 0 9.977753e-07
I4851 n1_m1_288000_364800 0 9.900000e-08
I4852 n1_m1_288000_369600 0 3.374220e-07
I4853 n1_m1_288000_374400 0 6.854627e-07
I4854 n1_m1_288000_379200 0 9.600000e-08
I4855 n1_m1_288000_384000 0 3.782679e-07
I4856 n1_m1_288000_388800 0 2.486782e-07
I4857 n1_m1_288000_393600 0 7.554417e-07
I4858 n1_m1_288000_398400 0 1.630000e-07
I4859 n1_m1_292800_4800 0 2.201183e-07
I4860 n1_m1_292800_9600 0 6.742057e-07
I4861 n1_m1_292800_14400 0 5.680096e-07
I4862 n1_m1_292800_19200 0 5.002358e-07
I4863 n1_m1_292800_24000 0 5.273593e-07
I4864 n1_m1_292800_28800 0 3.496870e-07
I4865 n1_m1_292800_33600 0 7.161084e-07
I4866 n1_m1_292800_38400 0 1.117781e-07
I4867 n1_m1_292800_43200 0 7.717788e-07
I4868 n1_m1_292800_48000 0 5.593324e-07
I4869 n1_m1_292800_52800 0 3.829459e-07
I4870 n1_m1_292800_57600 0 1.558914e-06
I4871 n1_m1_292800_62400 0 3.303112e-07
I4872 n1_m1_292800_67200 0 7.083546e-07
I4873 n1_m1_292800_72000 0 4.629692e-07
I4874 n1_m1_292800_76800 0 2.864589e-07
I4875 n1_m1_292800_81600 0 6.456692e-07
I4876 n1_m1_292800_86400 0 3.765998e-07
I4877 n1_m1_292800_91200 0 3.647304e-07
I4878 n1_m1_292800_96000 0 5.915670e-07
I4879 n1_m1_292800_100800 0 7.159643e-07
I4880 n1_m1_292800_105600 0 8.069375e-07
I4881 n1_m1_292800_110400 0 4.826034e-07
I4882 n1_m1_292800_115200 0 1.612132e-07
I4883 n1_m1_292800_120000 0 1.089809e-06
I4884 n1_m1_292800_124800 0 2.388163e-07
I4885 n1_m1_292800_129600 0 8.409929e-07
I4886 n1_m1_292800_134400 0 3.577575e-07
I4887 n1_m1_292800_139200 0 2.126429e-07
I4888 n1_m1_292800_144000 0 5.323175e-07
I4889 n1_m1_292800_148800 0 1.840048e-07
I4890 n1_m1_292800_153600 0 3.582333e-07
I4891 n1_m1_292800_158400 0 2.822857e-07
I4892 n1_m1_292800_163200 0 5.256831e-07
I4893 n1_m1_292800_168000 0 3.880879e-07
I4894 n1_m1_292800_172800 0 2.128571e-07
I4895 n1_m1_292800_177600 0 6.697857e-07
I4896 n1_m1_292800_182400 0 5.340000e-08
I4897 n1_m1_292800_187200 0 8.494286e-08
I4898 n1_m1_292800_192000 0 4.434200e-07
I4899 n1_m1_292800_196800 0 1.119738e-07
I4900 n1_m1_292800_201600 0 7.474762e-07
I4901 n1_m1_292800_206400 0 3.562000e-07
I4902 n1_m1_292800_211200 0 4.836964e-07
I4903 n1_m1_292800_216000 0 8.797812e-07
I4904 n1_m1_292800_220800 0 1.654036e-07
I4905 n1_m1_292800_225600 0 2.493041e-07
I4906 n1_m1_292800_230400 0 5.740816e-07
I4907 n1_m1_292800_235200 0 2.920571e-07
I4908 n1_m1_292800_240000 0 8.023794e-06
I4909 n1_m1_292800_244800 0 4.968000e-07
I4910 n1_m1_292800_249600 0 4.271686e-07
I4911 n1_m1_292800_254400 0 1.947671e-07
I4912 n1_m1_292800_259200 0 7.866667e-08
I4913 n1_m1_292800_264000 0 3.656750e-07
I4914 n1_m1_292800_268800 0 3.576357e-07
I4915 n1_m1_292800_273600 0 3.984387e-07
I4916 n1_m1_292800_278400 0 2.636105e-07
I4917 n1_m1_292800_283200 0 4.114476e-07
I4918 n1_m1_292800_288000 0 4.106776e-07
I4919 n1_m1_292800_292800 0 3.522423e-07
I4920 n1_m1_292800_297600 0 4.388398e-07
I4921 n1_m1_292800_302400 0 4.829125e-07
I4922 n1_m1_292800_307200 0 1.854464e-07
I4923 n1_m1_292800_312000 0 1.654643e-07
I4924 n1_m1_292800_316800 0 5.408334e-07
I4925 n1_m1_292800_321600 0 6.650402e-07
I4926 n1_m1_292800_326400 0 1.617619e-07
I4927 n1_m1_292800_331200 0 8.738095e-09
I4928 n1_m1_292800_336000 0 4.970369e-07
I4929 n1_m1_292800_340800 0 2.439327e-07
I4930 n1_m1_292800_345600 0 5.907500e-07
I4931 n1_m1_292800_350400 0 5.969107e-07
I4932 n1_m1_292800_355200 0 1.302041e-07
I4933 n1_m1_292800_360000 0 1.100601e-06
I4934 n1_m1_292800_364800 0 2.222857e-07
I4935 n1_m1_292800_369600 0 5.201851e-07
I4936 n1_m1_292800_374400 0 3.222062e-07
I4937 n1_m1_292800_379200 0 8.761958e-07
I4938 n1_m1_292800_384000 0 5.010100e-07
I4939 n1_m1_292800_388800 0 3.247799e-07
I4940 n1_m1_292800_393600 0 5.612271e-07
I4941 n1_m1_292800_398400 0 1.418000e-07
I4942 n1_m1_297600_4800 0 3.443077e-07
I4943 n1_m1_297600_9600 0 7.656298e-07
I4944 n1_m1_297600_14400 0 2.872563e-07
I4945 n1_m1_297600_19200 0 5.529050e-07
I4946 n1_m1_297600_24000 0 8.406021e-07
I4947 n1_m1_297600_28800 0 6.604511e-07
I4948 n1_m1_297600_33600 0 1.089955e-06
I4949 n1_m1_297600_38400 0 3.761930e-07
I4950 n1_m1_297600_43200 0 1.914880e-07
I4951 n1_m1_297600_48000 0 7.237518e-07
I4952 n1_m1_297600_52800 0 8.664329e-07
I4953 n1_m1_297600_57600 0 1.246953e-06
I4954 n1_m1_297600_62400 0 5.364055e-07
I4955 n1_m1_297600_67200 0 6.448800e-07
I4956 n1_m1_297600_72000 0 5.776837e-07
I4957 n1_m1_297600_76800 0 8.681143e-08
I4958 n1_m1_297600_81600 0 5.987943e-07
I4959 n1_m1_297600_86400 0 4.747451e-07
I4960 n1_m1_297600_91200 0 7.914407e-07
I4961 n1_m1_297600_96000 0 5.313339e-07
I4962 n1_m1_297600_100800 0 6.546420e-07
I4963 n1_m1_297600_105600 0 6.143821e-07
I4964 n1_m1_297600_110400 0 4.829394e-07
I4965 n1_m1_297600_115200 0 2.039477e-07
I4966 n1_m1_297600_120000 0 6.686815e-07
I4967 n1_m1_297600_124800 0 3.813265e-07
I4968 n1_m1_297600_129600 0 3.137143e-07
I4969 n1_m1_297600_134400 0 6.360794e-07
I4970 n1_m1_297600_139200 0 3.627619e-07
I4971 n1_m1_297600_144000 0 6.673857e-07
I4972 n1_m1_297600_148800 0 3.612024e-07
I4973 n1_m1_297600_153600 0 9.906238e-07
I4974 n1_m1_297600_158400 0 5.685143e-07
I4975 n1_m1_297600_163200 0 8.800312e-07
I4976 n1_m1_297600_168000 0 8.624121e-07
I4977 n1_m1_297600_172800 0 7.325714e-07
I4978 n1_m1_297600_177600 0 7.114321e-07
I4979 n1_m1_297600_182400 0 3.745143e-07
I4980 n1_m1_297600_187200 0 4.470571e-07
I4981 n1_m1_297600_192000 0 3.225286e-07
I4982 n1_m1_297600_196800 0 4.951571e-07
I4983 n1_m1_297600_201600 0 8.873810e-07
I4984 n1_m1_297600_206400 0 4.937036e-07
I4985 n1_m1_297600_211200 0 2.766339e-07
I4986 n1_m1_297600_216000 0 2.097433e-06
I4987 n1_m1_297600_220800 0 5.727143e-07
I4988 n1_m1_297600_225600 0 9.600619e-07
I4989 n1_m1_297600_230400 0 5.333619e-07
I4990 n1_m1_297600_235200 0 4.039429e-07
I4991 n1_m1_297600_240000 0 9.621778e-07
I4992 n1_m1_297600_244800 0 2.347429e-06
I4993 n1_m1_297600_249600 0 1.503208e-06
I4994 n1_m1_297600_254400 0 7.487948e-07
I4995 n1_m1_297600_259200 0 5.668952e-07
I4996 n1_m1_297600_264000 0 6.978000e-07
I4997 n1_m1_297600_268800 0 3.850629e-07
I4998 n1_m1_297600_273600 0 2.822089e-07
I4999 n1_m1_297600_278400 0 7.209048e-07
I5000 n1_m1_297600_283200 0 3.233000e-07
I5001 n1_m1_297600_288000 0 6.758000e-07
I5002 n1_m1_297600_292800 0 8.027551e-08
I5003 n1_m1_297600_297600 0 1.384214e-06
I5004 n1_m1_297600_302400 0 2.936688e-07
I5005 n1_m1_297600_307200 0 4.816964e-07
I5006 n1_m1_297600_312000 0 1.137721e-06
I5007 n1_m1_297600_316800 0 7.005815e-07
I5008 n1_m1_297600_321600 0 1.189227e-06
I5009 n1_m1_297600_326400 0 1.182589e-06
I5010 n1_m1_297600_331200 0 5.797314e-06
I5011 n1_m1_297600_336000 0 1.421564e-06
I5012 n1_m1_297600_340800 0 1.086107e-06
I5013 n1_m1_297600_345600 0 6.542875e-07
I5014 n1_m1_297600_350400 0 6.282650e-07
I5015 n1_m1_297600_355200 0 2.960446e-07
I5016 n1_m1_297600_360000 0 6.318438e-07
I5017 n1_m1_297600_364800 0 1.832208e-07
I5018 n1_m1_297600_369600 0 9.484470e-07
I5019 n1_m1_297600_374400 0 4.619625e-07
I5020 n1_m1_297600_379200 0 4.451809e-07
I5021 n1_m1_297600_384000 0 8.904579e-07
I5022 n1_m1_297600_388800 0 3.698286e-07
I5023 n1_m1_297600_393600 0 1.344169e-06
I5024 n1_m1_297600_398400 0 2.926286e-07
I5025 n1_m1_302400_4800 0 1.421538e-07
I5026 n1_m1_302400_9600 0 5.864977e-07
I5027 n1_m1_302400_14400 0 3.613903e-07
I5028 n1_m1_302400_19200 0 3.082972e-07
I5029 n1_m1_302400_24000 0 5.658767e-07
I5030 n1_m1_302400_28800 0 3.143333e-08
I5031 n1_m1_302400_33600 0 4.812885e-07
I5032 n1_m1_302400_38400 0 7.278365e-07
I5033 n1_m1_302400_43200 0 1.468846e-07
I5034 n1_m1_302400_48000 0 2.212208e-07
I5035 n1_m1_302400_52800 0 5.700885e-07
I5036 n1_m1_302400_57600 0 1.094960e-06
I5037 n1_m1_302400_62400 0 1.467941e-06
I5038 n1_m1_302400_67200 0 9.969172e-07
I5039 n1_m1_302400_72000 0 1.133250e-06
I5040 n1_m1_302400_76800 0 2.748857e-07
I5041 n1_m1_302400_81600 0 5.964714e-07
I5042 n1_m1_302400_86400 0 3.021236e-07
I5043 n1_m1_302400_91200 0 2.625728e-07
I5044 n1_m1_302400_96000 0 3.530893e-07
I5045 n1_m1_302400_100800 0 3.814714e-07
I5046 n1_m1_302400_105600 0 3.770143e-07
I5047 n1_m1_302400_110400 0 2.777857e-07
I5048 n1_m1_302400_115200 0 4.705714e-07
I5049 n1_m1_302400_120000 0 6.485571e-07
I5050 n1_m1_302400_124800 0 2.974107e-07
I5051 n1_m1_302400_129600 0 5.041429e-07
I5052 n1_m1_302400_134400 0 1.475131e-07
I5053 n1_m1_302400_139200 0 3.045238e-07
I5054 n1_m1_302400_144000 0 5.559143e-07
I5055 n1_m1_302400_148800 0 4.441000e-07
I5056 n1_m1_302400_153600 0 4.987750e-07
I5057 n1_m1_302400_158400 0 2.875929e-07
I5058 n1_m1_302400_163200 0 2.178750e-07
I5059 n1_m1_302400_168000 0 3.909286e-07
I5060 n1_m1_302400_172800 0 2.296286e-07
I5061 n1_m1_302400_177600 0 7.559357e-07
I5062 n1_m1_302400_182400 0 5.580571e-07
I5063 n1_m1_302400_187200 0 5.125714e-07
I5064 n1_m1_302400_192000 0 5.175714e-07
I5065 n1_m1_302400_196800 0 1.436000e-07
I5066 n1_m1_302400_201600 0 4.093832e-07
I5067 n1_m1_302400_206400 0 8.305687e-07
I5068 n1_m1_302400_211200 0 7.356875e-07
I5069 n1_m1_302400_216000 0 4.879695e-07
I5070 n1_m1_302400_220800 0 5.681396e-07
I5071 n1_m1_302400_225600 0 1.986095e-07
I5072 n1_m1_302400_230400 0 4.846190e-07
I5073 n1_m1_302400_235200 0 6.306500e-07
I5074 n1_m1_302400_240000 0 3.233111e-07
I5075 n1_m1_302400_244800 0 2.420952e-07
I5076 n1_m1_302400_249600 0 4.740714e-07
I5077 n1_m1_302400_254400 0 1.641857e-07
I5078 n1_m1_302400_259200 0 2.451810e-07
I5079 n1_m1_302400_264000 0 2.874429e-07
I5080 n1_m1_302400_268800 0 3.365571e-07
I5081 n1_m1_302400_273600 0 6.727643e-07
I5082 n1_m1_302400_278400 0 3.054107e-07
I5083 n1_m1_302400_283200 0 2.499952e-07
I5084 n1_m1_302400_288000 0 4.908964e-07
I5085 n1_m1_302400_292800 0 2.223929e-07
I5086 n1_m1_302400_297600 0 6.587093e-07
I5087 n1_m1_302400_302400 0 2.556905e-07
I5088 n1_m1_302400_307200 0 1.907143e-07
I5089 n1_m1_302400_312000 0 2.423857e-07
I5090 n1_m1_302400_316800 0 3.186224e-07
I5091 n1_m1_302400_321600 0 8.156122e-07
I5092 n1_m1_302400_326400 0 3.439821e-07
I5093 n1_m1_302400_331200 0 2.606182e-06
I5094 n1_m1_302400_336000 0 5.988273e-07
I5095 n1_m1_302400_340800 0 1.933429e-07
I5096 n1_m1_302400_345600 0 6.021613e-07
I5097 n1_m1_302400_350400 0 5.122602e-07
I5098 n1_m1_302400_355200 0 4.871929e-07
I5099 n1_m1_302400_360000 0 7.495000e-07
I5100 n1_m1_302400_364800 0 6.026970e-07
I5101 n1_m1_302400_369600 0 3.122397e-07
I5102 n1_m1_302400_374400 0 1.372366e-07
I5103 n1_m1_302400_379200 0 3.636277e-07
I5104 n1_m1_302400_384000 0 2.861827e-07
I5105 n1_m1_302400_388800 0 4.380790e-07
I5106 n1_m1_302400_393600 0 1.294226e-07
I5107 n1_m1_302400_398400 0 4.628571e-08
I5108 n1_m1_307200_4800 0 2.972308e-07
I5109 n1_m1_307200_9600 0 9.228450e-07
I5110 n1_m1_307200_14400 0 5.220383e-07
I5111 n1_m1_307200_19200 0 1.035510e-07
I5112 n1_m1_307200_24000 0 9.700000e-07
I5113 n1_m1_307200_28800 0 1.091747e-07
I5114 n1_m1_307200_33600 0 6.041057e-07
I5115 n1_m1_307200_38400 0 3.383750e-07
I5116 n1_m1_307200_43200 0 7.534769e-07
I5117 n1_m1_307200_48000 0 6.973332e-07
I5118 n1_m1_307200_52800 0 2.880626e-07
I5119 n1_m1_307200_57600 0 2.152068e-07
I5120 n1_m1_307200_62400 0 3.470416e-07
I5121 n1_m1_307200_67200 0 3.430220e-06
I5122 n1_m1_307200_72000 0 1.849187e-06
I5123 n1_m1_307200_76800 0 5.464374e-07
I5124 n1_m1_307200_81600 0 4.839000e-07
I5125 n1_m1_307200_86400 0 3.442280e-07
I5126 n1_m1_307200_91200 0 3.596898e-07
I5127 n1_m1_307200_96000 0 6.168679e-07
I5128 n1_m1_307200_100800 0 4.134714e-07
I5129 n1_m1_307200_105600 0 4.516643e-07
I5130 n1_m1_307200_110400 0 4.922143e-07
I5131 n1_m1_307200_115200 0 8.082286e-07
I5132 n1_m1_307200_120000 0 7.349429e-07
I5133 n1_m1_307200_124800 0 1.119732e-06
I5134 n1_m1_307200_129600 0 3.595821e-07
I5135 n1_m1_307200_134400 0 8.331488e-08
I5136 n1_m1_307200_139200 0 2.457143e-07
I5137 n1_m1_307200_144000 0 1.761681e-06
I5138 n1_m1_307200_148800 0 4.124170e-07
I5139 n1_m1_307200_153600 0 3.772036e-07
I5140 n1_m1_307200_158400 0 4.351214e-07
I5141 n1_m1_307200_163200 0 4.611345e-07
I5142 n1_m1_307200_168000 0 4.320857e-07
I5143 n1_m1_307200_172800 0 6.054857e-07
I5144 n1_m1_307200_177600 0 5.035214e-07
I5145 n1_m1_307200_182400 0 1.131229e-06
I5146 n1_m1_307200_187200 0 1.065905e-06
I5147 n1_m1_307200_192000 0 1.340222e-07
I5148 n1_m1_307200_196800 0 5.845786e-07
I5149 n1_m1_307200_201600 0 6.338168e-07
I5150 n1_m1_307200_206400 0 4.676277e-07
I5151 n1_m1_307200_211200 0 4.940982e-07
I5152 n1_m1_307200_216000 0 9.003409e-07
I5153 n1_m1_307200_220800 0 6.116491e-07
I5154 n1_m1_307200_225600 0 4.856923e-07
I5155 n1_m1_307200_230400 0 3.993619e-07
I5156 n1_m1_307200_235200 0 3.728929e-07
I5157 n1_m1_307200_240000 0 1.909783e-07
I5158 n1_m1_307200_244800 0 4.573697e-07
I5159 n1_m1_307200_249600 0 6.205714e-07
I5160 n1_m1_307200_254400 0 5.226229e-07
I5161 n1_m1_307200_259200 0 2.486000e-07
I5162 n1_m1_307200_264000 0 5.363000e-07
I5163 n1_m1_307200_268800 0 4.196000e-07
I5164 n1_m1_307200_273600 0 1.407214e-07
I5165 n1_m1_307200_278400 0 3.048036e-07
I5166 n1_m1_307200_283200 0 4.317143e-07
I5167 n1_m1_307200_288000 0 6.294464e-07
I5168 n1_m1_307200_292800 0 4.959949e-07
I5169 n1_m1_307200_297600 0 6.851571e-07
I5170 n1_m1_307200_302400 0 2.453668e-07
I5171 n1_m1_307200_307200 0 7.231027e-07
I5172 n1_m1_307200_312000 0 2.967360e-07
I5173 n1_m1_307200_316800 0 5.257980e-07
I5174 n1_m1_307200_321600 0 8.060517e-07
I5175 n1_m1_307200_326400 0 1.015510e-07
I5176 n1_m1_307200_331200 0 3.839733e-07
I5177 n1_m1_307200_336000 0 6.904814e-07
I5178 n1_m1_307200_340800 0 1.220714e-07
I5179 n1_m1_307200_345600 0 5.100753e-07
I5180 n1_m1_307200_350400 0 5.306775e-07
I5181 n1_m1_307200_355200 0 2.929911e-07
I5182 n1_m1_307200_360000 0 4.967161e-07
I5183 n1_m1_307200_364800 0 4.892381e-07
I5184 n1_m1_307200_369600 0 7.080216e-07
I5185 n1_m1_307200_374400 0 3.387607e-07
I5186 n1_m1_307200_379200 0 7.115179e-07
I5187 n1_m1_307200_384000 0 4.032637e-07
I5188 n1_m1_307200_388800 0 4.782424e-07
I5189 n1_m1_307200_393600 0 4.614286e-08
I5190 n1_m1_307200_398400 0 2.768571e-07
I5191 n1_m1_312000_4800 0 1.938462e-07
I5192 n1_m1_312000_9600 0 1.141327e-06
I5193 n1_m1_312000_14400 0 4.162286e-07
I5194 n1_m1_312000_19200 0 2.839238e-07
I5195 n1_m1_312000_24000 0 8.901147e-07
I5196 n1_m1_312000_28800 0 2.131104e-06
I5197 n1_m1_312000_33600 0 1.318353e-06
I5198 n1_m1_312000_38400 0 6.300865e-07
I5199 n1_m1_312000_43200 0 4.047577e-07
I5200 n1_m1_312000_48000 0 1.220739e-06
I5201 n1_m1_312000_52800 0 4.627445e-07
I5202 n1_m1_312000_57600 0 1.246367e-06
I5203 n1_m1_312000_62400 0 5.056693e-07
I5204 n1_m1_312000_67200 0 4.943134e-06
I5205 n1_m1_312000_72000 0 3.773852e-06
I5206 n1_m1_312000_76800 0 4.624728e-07
I5207 n1_m1_312000_81600 0 6.026188e-07
I5208 n1_m1_312000_86400 0 5.174407e-07
I5209 n1_m1_312000_91200 0 4.578593e-07
I5210 n1_m1_312000_96000 0 5.342585e-07
I5211 n1_m1_312000_100800 0 4.734548e-07
I5212 n1_m1_312000_105600 0 4.637232e-07
I5213 n1_m1_312000_110400 0 5.934286e-07
I5214 n1_m1_312000_115200 0 7.925381e-07
I5215 n1_m1_312000_120000 0 8.724339e-07
I5216 n1_m1_312000_124800 0 7.220580e-07
I5217 n1_m1_312000_129600 0 1.532564e-06
I5218 n1_m1_312000_134400 0 3.995958e-07
I5219 n1_m1_312000_139200 0 4.690879e-07
I5220 n1_m1_312000_144000 0 6.688261e-06
I5221 n1_m1_312000_148800 0 1.116585e-06
I5222 n1_m1_312000_153600 0 1.004074e-06
I5223 n1_m1_312000_158400 0 4.605429e-07
I5224 n1_m1_312000_163200 0 2.198137e-07
I5225 n1_m1_312000_168000 0 6.802009e-07
I5226 n1_m1_312000_172800 0 3.921714e-07
I5227 n1_m1_312000_177600 0 8.399232e-07
I5228 n1_m1_312000_182400 0 6.243661e-07
I5229 n1_m1_312000_187200 0 1.416488e-06
I5230 n1_m1_312000_192000 0 4.017778e-07
I5231 n1_m1_312000_196800 0 7.073143e-07
I5232 n1_m1_312000_201600 0 4.202857e-07
I5233 n1_m1_312000_206400 0 8.775000e-07
I5234 n1_m1_312000_211200 0 8.551494e-07
I5235 n1_m1_312000_216000 0 2.040028e-07
I5236 n1_m1_312000_220800 0 5.369255e-07
I5237 n1_m1_312000_225600 0 6.399461e-07
I5238 n1_m1_312000_230400 0 7.522857e-07
I5239 n1_m1_312000_235200 0 5.398482e-07
I5240 n1_m1_312000_240000 0 5.555452e-07
I5241 n1_m1_312000_244800 0 7.240000e-07
I5242 n1_m1_312000_249600 0 9.521357e-07
I5243 n1_m1_312000_254400 0 3.760767e-07
I5244 n1_m1_312000_259200 0 6.489714e-07
I5245 n1_m1_312000_264000 0 5.674143e-07
I5246 n1_m1_312000_268800 0 6.948224e-07
I5247 n1_m1_312000_273600 0 4.189851e-07
I5248 n1_m1_312000_278400 0 5.340898e-07
I5249 n1_m1_312000_283200 0 6.183959e-07
I5250 n1_m1_312000_288000 0 1.818675e-07
I5251 n1_m1_312000_292800 0 4.636435e-07
I5252 n1_m1_312000_297600 0 1.122053e-06
I5253 n1_m1_312000_302400 0 2.879167e-07
I5254 n1_m1_312000_307200 0 6.579962e-07
I5255 n1_m1_312000_312000 0 4.615322e-07
I5256 n1_m1_312000_316800 0 1.341016e-06
I5257 n1_m1_312000_321600 0 1.042441e-06
I5258 n1_m1_312000_326400 0 5.977061e-07
I5259 n1_m1_312000_331200 0 9.227136e-07
I5260 n1_m1_312000_336000 0 7.784155e-07
I5261 n1_m1_312000_340800 0 7.477286e-07
I5262 n1_m1_312000_345600 0 1.127286e-06
I5263 n1_m1_312000_350400 0 3.177143e-07
I5264 n1_m1_312000_355200 0 6.689870e-07
I5265 n1_m1_312000_360000 0 5.408999e-07
I5266 n1_m1_312000_364800 0 5.018263e-07
I5267 n1_m1_312000_369600 0 4.897520e-07
I5268 n1_m1_312000_374400 0 3.146455e-07
I5269 n1_m1_312000_379200 0 6.534330e-07
I5270 n1_m1_312000_384000 0 2.250357e-07
I5271 n1_m1_312000_388800 0 2.492308e-08
I5272 n1_m1_312000_393600 0 4.631000e-07
I5273 n1_m1_312000_398400 0 9.600000e-08
I5274 n1_m1_316800_4800 0 1.608000e-07
I5275 n1_m1_316800_9600 0 2.196000e-07
I5276 n1_m1_316800_14400 0 4.743776e-07
I5277 n1_m1_316800_19200 0 1.016850e-06
I5278 n1_m1_316800_24000 0 8.712639e-07
I5279 n1_m1_316800_28800 0 5.997503e-06
I5280 n1_m1_316800_33600 0 5.986064e-07
I5281 n1_m1_316800_38400 0 2.271683e-07
I5282 n1_m1_316800_43200 0 2.873654e-07
I5283 n1_m1_316800_48000 0 9.546686e-07
I5284 n1_m1_316800_52800 0 2.761357e-07
I5285 n1_m1_316800_57600 0 5.800920e-07
I5286 n1_m1_316800_62400 0 6.009430e-07
I5287 n1_m1_316800_67200 0 5.884372e-07
I5288 n1_m1_316800_72000 0 7.600198e-07
I5289 n1_m1_316800_76800 0 3.677830e-07
I5290 n1_m1_316800_81600 0 8.004552e-07
I5291 n1_m1_316800_86400 0 3.146484e-08
I5292 n1_m1_316800_91200 0 2.908588e-07
I5293 n1_m1_316800_96000 0 9.380162e-07
I5294 n1_m1_316800_100800 0 7.425136e-07
I5295 n1_m1_316800_105600 0 6.586929e-07
I5296 n1_m1_316800_110400 0 2.781970e-07
I5297 n1_m1_316800_115200 0 5.024588e-07
I5298 n1_m1_316800_120000 0 4.420765e-07
I5299 n1_m1_316800_124800 0 7.620536e-07
I5300 n1_m1_316800_129600 0 5.637033e-07
I5301 n1_m1_316800_134400 0 3.464571e-07
I5302 n1_m1_316800_139200 0 8.113496e-07
I5303 n1_m1_316800_144000 0 8.684909e-07
I5304 n1_m1_316800_148800 0 3.538055e-07
I5305 n1_m1_316800_153600 0 5.804620e-07
I5306 n1_m1_316800_158400 0 1.369796e-07
I5307 n1_m1_316800_163200 0 7.991008e-07
I5308 n1_m1_316800_168000 0 5.450889e-07
I5309 n1_m1_316800_172800 0 2.386245e-07
I5310 n1_m1_316800_177600 0 7.005996e-07
I5311 n1_m1_316800_182400 0 3.261786e-07
I5312 n1_m1_316800_187200 0 2.455714e-07
I5313 n1_m1_316800_196800 0 9.750000e-07
I5314 n1_m1_316800_201600 0 5.836250e-07
I5315 n1_m1_316800_206400 0 3.309750e-07
I5316 n1_m1_316800_211200 0 5.331649e-07
I5317 n1_m1_316800_216000 0 2.414868e-07
I5318 n1_m1_316800_220800 0 4.606607e-07
I5319 n1_m1_316800_225600 0 6.790893e-07
I5320 n1_m1_316800_230400 0 2.545714e-07
I5321 n1_m1_316800_235200 0 6.569732e-07
I5322 n1_m1_316800_240000 0 3.826210e-07
I5323 n1_m1_316800_244800 0 4.733432e-07
I5324 n1_m1_316800_249600 0 3.009490e-07
I5325 n1_m1_316800_254400 0 6.207209e-07
I5326 n1_m1_316800_259200 0 6.435165e-08
I5327 n1_m1_316800_264000 0 7.809091e-08
I5328 n1_m1_316800_268800 0 5.698187e-07
I5329 n1_m1_316800_273600 0 3.898292e-07
I5330 n1_m1_316800_278400 0 2.386245e-07
I5331 n1_m1_316800_283200 0 3.522584e-07
I5332 n1_m1_316800_288000 0 9.887969e-07
I5333 n1_m1_316800_292800 0 4.698214e-07
I5334 n1_m1_316800_297600 0 5.849554e-07
I5335 n1_m1_316800_302400 0 2.283893e-07
I5336 n1_m1_316800_307200 0 4.432225e-07
I5337 n1_m1_316800_312000 0 3.762845e-07
I5338 n1_m1_316800_316800 0 3.329307e-07
I5339 n1_m1_316800_321600 0 5.865993e-07
I5340 n1_m1_316800_326400 0 4.451948e-08
I5341 n1_m1_316800_331200 0 4.635100e-07
I5342 n1_m1_316800_336000 0 2.649038e-07
I5343 n1_m1_316800_340800 0 1.716429e-07
I5344 n1_m1_316800_345600 0 3.138661e-07
I5345 n1_m1_316800_350400 0 9.132857e-08
I5346 n1_m1_316800_355200 0 4.564273e-07
I5347 n1_m1_316800_360000 0 3.603508e-07
I5348 n1_m1_316800_364800 0 6.270089e-07
I5349 n1_m1_316800_369600 0 8.179393e-07
I5350 n1_m1_316800_374400 0 1.411143e-07
I5351 n1_m1_316800_379200 0 6.023929e-07
I5352 n1_m1_316800_384000 0 4.561429e-07
I5353 n1_m1_316800_388800 0 1.766484e-07
I5354 n1_m1_316800_393600 0 8.936420e-07
I5355 n1_m1_316800_398400 0 2.231250e-07
I5356 n1_m1_321600_4800 0 6.923077e-07
I5357 n1_m1_321600_9600 0 1.001121e-06
I5358 n1_m1_321600_14400 0 6.449938e-07
I5359 n1_m1_321600_19200 0 4.527692e-07
I5360 n1_m1_321600_24000 0 9.985680e-07
I5361 n1_m1_321600_28800 0 1.732330e-07
I5362 n1_m1_321600_33600 0 9.477353e-07
I5363 n1_m1_321600_38400 0 5.455144e-07
I5364 n1_m1_321600_43200 0 1.116875e-06
I5365 n1_m1_321600_48000 0 9.742156e-07
I5366 n1_m1_321600_52800 0 3.279898e-07
I5367 n1_m1_321600_57600 0 5.452784e-07
I5368 n1_m1_321600_62400 0 7.507286e-07
I5369 n1_m1_321600_67200 0 6.906255e-07
I5370 n1_m1_321600_72000 0 5.715875e-07
I5371 n1_m1_321600_76800 0 1.104179e-07
I5372 n1_m1_321600_81600 0 1.231555e-06
I5373 n1_m1_321600_86400 0 3.550885e-07
I5374 n1_m1_321600_91200 0 3.964343e-07
I5375 n1_m1_321600_96000 0 7.115967e-07
I5376 n1_m1_321600_100800 0 7.716757e-07
I5377 n1_m1_321600_105600 0 8.223651e-07
I5378 n1_m1_321600_110400 0 5.694805e-07
I5379 n1_m1_321600_115200 0 8.441455e-07
I5380 n1_m1_321600_120000 0 3.827038e-07
I5381 n1_m1_321600_124800 0 4.077902e-07
I5382 n1_m1_321600_129600 0 5.069538e-07
I5383 n1_m1_321600_134400 0 4.110232e-07
I5384 n1_m1_321600_139200 0 1.101786e-06
I5385 n1_m1_321600_144000 0 1.273022e-06
I5386 n1_m1_321600_148800 0 6.582286e-07
I5387 n1_m1_321600_153600 0 1.341944e-06
I5388 n1_m1_321600_158400 0 3.488408e-07
I5389 n1_m1_321600_163200 0 1.046280e-06
I5390 n1_m1_321600_168000 0 9.498763e-07
I5391 n1_m1_321600_172800 0 7.317755e-07
I5392 n1_m1_321600_177600 0 1.201634e-06
I5393 n1_m1_321600_182400 0 5.632982e-07
I5394 n1_m1_321600_187200 0 8.312679e-07
I5395 n1_m1_321600_192000 0 4.692442e-07
I5396 n1_m1_321600_196800 0 4.579084e-07
I5397 n1_m1_321600_201600 0 7.350386e-07
I5398 n1_m1_321600_206400 0 2.201679e-07
I5399 n1_m1_321600_211200 0 6.449130e-07
I5400 n1_m1_321600_216000 0 5.911429e-07
I5401 n1_m1_321600_220800 0 8.426753e-07
I5402 n1_m1_321600_225600 0 1.771240e-06
I5403 n1_m1_321600_230400 0 5.139402e-06
I5404 n1_m1_321600_235200 0 1.236125e-06
I5405 n1_m1_321600_240000 0 1.643425e-06
I5406 n1_m1_321600_244800 0 7.864668e-07
I5407 n1_m1_321600_249600 0 7.421224e-07
I5408 n1_m1_321600_254400 0 6.296685e-07
I5409 n1_m1_321600_259200 0 5.546214e-07
I5410 n1_m1_321600_264000 0 1.135831e-06
I5411 n1_m1_321600_268800 0 5.499564e-07
I5412 n1_m1_321600_273600 0 1.047410e-06
I5413 n1_m1_321600_278400 0 5.885982e-07
I5414 n1_m1_321600_283200 0 9.008567e-07
I5415 n1_m1_321600_288000 0 1.082286e-06
I5416 n1_m1_321600_292800 0 3.685045e-07
I5417 n1_m1_321600_297600 0 7.671607e-07
I5418 n1_m1_321600_302400 0 9.376964e-07
I5419 n1_m1_321600_307200 0 9.641071e-07
I5420 n1_m1_321600_312000 0 1.878504e-06
I5421 n1_m1_321600_316800 0 4.155065e-07
I5422 n1_m1_321600_321600 0 1.465666e-06
I5423 n1_m1_321600_326400 0 5.626234e-07
I5424 n1_m1_321600_331200 0 7.938622e-07
I5425 n1_m1_321600_336000 0 8.254937e-07
I5426 n1_m1_321600_340800 0 6.086786e-07
I5427 n1_m1_321600_345600 0 8.409277e-07
I5428 n1_m1_321600_350400 0 3.542286e-06
I5429 n1_m1_321600_355200 0 5.007214e-06
I5430 n1_m1_321600_360000 0 1.104614e-06
I5431 n1_m1_321600_364800 0 1.144821e-07
I5432 n1_m1_321600_369600 0 6.546580e-07
I5433 n1_m1_321600_374400 0 1.416729e-06
I5434 n1_m1_321600_379200 0 6.300223e-06
I5435 n1_m1_321600_384000 0 1.067812e-06
I5436 n1_m1_321600_388800 0 5.027000e-07
I5437 n1_m1_321600_393600 0 7.833580e-07
I5438 n1_m1_321600_398400 0 5.731607e-07
I5439 n1_m1_326400_4800 0 9.600000e-08
I5440 n1_m1_326400_9600 0 6.104689e-07
I5441 n1_m1_326400_14400 0 1.289000e-07
I5442 n1_m1_326400_19200 0 1.190769e-07
I5443 n1_m1_326400_24000 0 7.938630e-07
I5444 n1_m1_326400_28800 0 2.138005e-07
I5445 n1_m1_326400_33600 0 9.494937e-07
I5446 n1_m1_326400_38400 0 3.935673e-07
I5447 n1_m1_326400_43200 0 4.384583e-07
I5448 n1_m1_326400_48000 0 6.214987e-07
I5449 n1_m1_326400_52800 0 1.849459e-07
I5450 n1_m1_326400_57600 0 5.589787e-07
I5451 n1_m1_326400_62400 0 5.241857e-07
I5452 n1_m1_326400_67200 0 5.781030e-07
I5453 n1_m1_326400_72000 0 7.475972e-07
I5454 n1_m1_326400_76800 0 4.277857e-07
I5455 n1_m1_326400_81600 0 9.112500e-07
I5456 n1_m1_326400_86400 0 1.979374e-07
I5457 n1_m1_326400_91200 0 7.600412e-07
I5458 n1_m1_326400_96000 0 4.094286e-07
I5459 n1_m1_326400_100800 0 6.578260e-07
I5460 n1_m1_326400_105600 0 6.775358e-07
I5461 n1_m1_326400_110400 0 2.335982e-07
I5462 n1_m1_326400_115200 0 5.374406e-07
I5463 n1_m1_326400_120000 0 6.958736e-07
I5464 n1_m1_326400_124800 0 7.611607e-07
I5465 n1_m1_326400_129600 0 4.348014e-07
I5466 n1_m1_326400_134400 0 7.210536e-07
I5467 n1_m1_326400_139200 0 6.183546e-07
I5468 n1_m1_326400_144000 0 8.950187e-07
I5469 n1_m1_326400_148800 0 2.703393e-07
I5470 n1_m1_326400_153600 0 6.874267e-07
I5471 n1_m1_326400_158400 0 2.216641e-08
I5472 n1_m1_326400_163200 0 3.854032e-07
I5473 n1_m1_326400_168000 0 4.417466e-07
I5474 n1_m1_326400_172800 0 1.929107e-07
I5475 n1_m1_326400_177600 0 7.205068e-06
I5476 n1_m1_326400_182400 0 3.776429e-07
I5477 n1_m1_326400_187200 0 5.601964e-07
I5478 n1_m1_326400_192000 0 3.148130e-07
I5479 n1_m1_326400_196800 0 3.467551e-07
I5480 n1_m1_326400_201600 0 5.167554e-07
I5481 n1_m1_326400_206400 0 3.409429e-07
I5482 n1_m1_326400_211200 0 2.784102e-07
I5483 n1_m1_326400_216000 0 3.964500e-07
I5484 n1_m1_326400_220800 0 2.626525e-07
I5485 n1_m1_326400_225600 0 9.131797e-07
I5486 n1_m1_326400_230400 0 2.269524e-06
I5487 n1_m1_326400_235200 0 7.573214e-07
I5488 n1_m1_326400_240000 0 3.081139e-07
I5489 n1_m1_326400_244800 0 7.065893e-07
I5490 n1_m1_326400_249600 0 9.350714e-07
I5491 n1_m1_326400_254400 0 1.366967e-07
I5492 n1_m1_326400_259200 0 3.968452e-07
I5493 n1_m1_326400_264000 0 3.694416e-07
I5494 n1_m1_326400_268800 0 6.055065e-07
I5495 n1_m1_326400_273600 0 1.007950e-06
I5496 n1_m1_326400_278400 0 6.906250e-07
I5497 n1_m1_326400_283200 0 2.836319e-07
I5498 n1_m1_326400_288000 0 6.202335e-07
I5499 n1_m1_326400_292800 0 3.928571e-07
I5500 n1_m1_326400_297600 0 4.262607e-07
I5501 n1_m1_326400_302400 0 5.406000e-07
I5502 n1_m1_326400_307200 0 7.557143e-07
I5503 n1_m1_326400_312000 0 2.862008e-07
I5504 n1_m1_326400_316800 0 9.985741e-08
I5505 n1_m1_326400_321600 0 1.221826e-06
I5506 n1_m1_326400_326400 0 7.085714e-08
I5507 n1_m1_326400_331200 0 7.195918e-08
I5508 n1_m1_326400_336000 0 4.801738e-07
I5509 n1_m1_326400_340800 0 3.721462e-07
I5510 n1_m1_326400_345600 0 4.130079e-07
I5511 n1_m1_326400_350400 0 6.995089e-07
I5512 n1_m1_326400_355200 0 2.897679e-07
I5513 n1_m1_326400_360000 0 2.365045e-07
I5514 n1_m1_326400_364800 0 2.267750e-07
I5515 n1_m1_326400_369600 0 8.413036e-07
I5516 n1_m1_326400_374400 0 7.767902e-07
I5517 n1_m1_326400_379200 0 2.585502e-06
I5518 n1_m1_326400_384000 0 3.887971e-07
I5519 n1_m1_326400_388800 0 3.413429e-07
I5520 n1_m1_326400_393600 0 3.512321e-07
I5521 n1_m1_326400_398400 0 3.274286e-07
I5522 n1_m1_331200_9600 0 7.074359e-07
I5523 n1_m1_331200_14400 0 2.921429e-07
I5524 n1_m1_331200_19200 0 3.741088e-07
I5525 n1_m1_331200_24000 0 1.253563e-06
I5526 n1_m1_331200_28800 0 5.632637e-07
I5527 n1_m1_331200_33600 0 6.110776e-07
I5528 n1_m1_331200_38400 0 3.121551e-07
I5529 n1_m1_331200_43200 0 2.292869e-07
I5530 n1_m1_331200_48000 0 8.043107e-07
I5531 n1_m1_331200_52800 0 6.074505e-08
I5532 n1_m1_331200_57600 0 8.350971e-07
I5533 n1_m1_331200_62400 0 2.614714e-07
I5534 n1_m1_331200_67200 0 2.109464e-07
I5535 n1_m1_331200_72000 0 6.768153e-07
I5536 n1_m1_331200_76800 0 1.840714e-07
I5537 n1_m1_331200_81600 0 7.681614e-07
I5538 n1_m1_331200_86400 0 1.697437e-07
I5539 n1_m1_331200_91200 0 4.014382e-07
I5540 n1_m1_331200_96000 0 3.273626e-07
I5541 n1_m1_331200_100800 0 4.699525e-07
I5542 n1_m1_331200_105600 0 3.827330e-07
I5543 n1_m1_331200_110400 0 4.586722e-08
I5544 n1_m1_331200_115200 0 6.001742e-07
I5545 n1_m1_331200_120000 0 6.014407e-07
I5546 n1_m1_331200_124800 0 2.684375e-07
I5547 n1_m1_331200_129600 0 1.735188e-07
I5548 n1_m1_331200_134400 0 3.927397e-07
I5549 n1_m1_331200_139200 0 4.355980e-07
I5550 n1_m1_331200_144000 0 1.921554e-07
I5551 n1_m1_331200_148800 0 3.485747e-07
I5552 n1_m1_331200_153600 0 9.513255e-07
I5553 n1_m1_331200_158400 0 2.054330e-07
I5554 n1_m1_331200_163200 0 6.790561e-07
I5555 n1_m1_331200_168000 0 9.360632e-07
I5556 n1_m1_331200_172800 0 7.889286e-07
I5557 n1_m1_331200_177600 0 1.243647e-06
I5558 n1_m1_331200_182400 0 6.149241e-07
I5559 n1_m1_331200_187200 0 3.275824e-07
I5560 n1_m1_331200_192000 0 1.471209e-07
I5561 n1_m1_331200_196800 0 2.700079e-07
I5562 n1_m1_331200_201600 0 3.168238e-07
I5563 n1_m1_331200_206400 0 1.349143e-07
I5564 n1_m1_331200_211200 0 2.244026e-07
I5565 n1_m1_331200_216000 0 4.835265e-07
I5566 n1_m1_331200_220800 0 7.566964e-07
I5567 n1_m1_331200_225600 0 2.039516e-07
I5568 n1_m1_331200_230400 0 2.224165e-07
I5569 n1_m1_331200_235200 0 5.029845e-07
I5570 n1_m1_331200_240000 0 1.352014e-07
I5571 n1_m1_331200_244800 0 6.097955e-07
I5572 n1_m1_331200_249600 0 1.002908e-06
I5573 n1_m1_331200_254400 0 3.963750e-07
I5574 n1_m1_331200_259200 0 3.070197e-07
I5575 n1_m1_331200_264000 0 2.070952e-07
I5576 n1_m1_331200_268800 0 5.329141e-07
I5577 n1_m1_331200_273600 0 4.804377e-07
I5578 n1_m1_331200_278400 0 3.303612e-07
I5579 n1_m1_331200_283200 0 4.265838e-07
I5580 n1_m1_331200_288000 0 3.287665e-07
I5581 n1_m1_331200_292800 0 6.032035e-07
I5582 n1_m1_331200_297600 0 7.226406e-07
I5583 n1_m1_331200_302400 0 7.884166e-06
I5584 n1_m1_331200_307200 0 6.397768e-07
I5585 n1_m1_331200_312000 0 1.215686e-06
I5586 n1_m1_331200_316800 0 7.134031e-07
I5587 n1_m1_331200_321600 0 9.120253e-07
I5588 n1_m1_331200_326400 0 6.465262e-07
I5589 n1_m1_331200_331200 0 2.369420e-07
I5590 n1_m1_331200_336000 0 1.088831e-06
I5591 n1_m1_331200_340800 0 3.269396e-07
I5592 n1_m1_331200_345600 0 2.294162e-07
I5593 n1_m1_331200_350400 0 4.935240e-07
I5594 n1_m1_331200_355200 0 6.980357e-07
I5595 n1_m1_331200_360000 0 7.401607e-07
I5596 n1_m1_331200_364800 0 1.956554e-07
I5597 n1_m1_331200_369600 0 5.185198e-07
I5598 n1_m1_331200_374400 0 5.520893e-07
I5599 n1_m1_331200_379200 0 5.723412e-07
I5600 n1_m1_331200_384000 0 6.952809e-07
I5601 n1_m1_331200_388800 0 2.995308e-07
I5602 n1_m1_331200_393600 0 9.698541e-07
I5603 n1_m1_331200_398400 0 2.227347e-07
I5604 n1_m1_336000_4800 0 1.883077e-07
I5605 n1_m1_336000_9600 0 6.835897e-08
I5606 n1_m1_336000_14400 0 4.973506e-07
I5607 n1_m1_336000_19200 0 3.135000e-07
I5608 n1_m1_336000_24000 0 1.414723e-06
I5609 n1_m1_336000_28800 0 3.188539e-07
I5610 n1_m1_336000_33600 0 1.224971e-06
I5611 n1_m1_336000_38400 0 5.028594e-07
I5612 n1_m1_336000_43200 0 5.458710e-07
I5613 n1_m1_336000_48000 0 1.202590e-06
I5614 n1_m1_336000_52800 0 8.886192e-07
I5615 n1_m1_336000_57600 0 9.951514e-07
I5616 n1_m1_336000_62400 0 7.936664e-07
I5617 n1_m1_336000_67200 0 1.085393e-06
I5618 n1_m1_336000_72000 0 5.691779e-07
I5619 n1_m1_336000_76800 0 8.540605e-07
I5620 n1_m1_336000_81600 0 1.911585e-06
I5621 n1_m1_336000_86400 0 1.159829e-06
I5622 n1_m1_336000_91200 0 8.786709e-07
I5623 n1_m1_336000_96000 0 5.572516e-07
I5624 n1_m1_336000_100800 0 6.700792e-07
I5625 n1_m1_336000_105600 0 1.024307e-06
I5626 n1_m1_336000_110400 0 1.280871e-05
I5627 n1_m1_336000_115200 0 5.472179e-06
I5628 n1_m1_336000_120000 0 6.607679e-07
I5629 n1_m1_336000_124800 0 5.020130e-07
I5630 n1_m1_336000_129600 0 1.047700e-06
I5631 n1_m1_336000_134400 0 8.061559e-07
I5632 n1_m1_336000_139200 0 5.521501e-07
I5633 n1_m1_336000_144000 0 9.377536e-07
I5634 n1_m1_336000_148800 0 8.205199e-07
I5635 n1_m1_336000_153600 0 8.177039e-07
I5636 n1_m1_336000_158400 0 1.815680e-07
I5637 n1_m1_336000_163200 0 6.567530e-07
I5638 n1_m1_336000_168000 0 6.818867e-07
I5639 n1_m1_336000_172800 0 5.621250e-07
I5640 n1_m1_336000_177600 0 6.728707e-07
I5641 n1_m1_336000_182400 0 7.863616e-07
I5642 n1_m1_336000_187200 0 3.735033e-07
I5643 n1_m1_336000_192000 0 1.127728e-06
I5644 n1_m1_336000_196800 0 2.024214e-07
I5645 n1_m1_336000_201600 0 1.236340e-06
I5646 n1_m1_336000_206400 0 1.015564e-06
I5647 n1_m1_336000_211200 0 3.137370e-07
I5648 n1_m1_336000_216000 0 1.325198e-06
I5649 n1_m1_336000_220800 0 7.862532e-07
I5650 n1_m1_336000_225600 0 4.337150e-07
I5651 n1_m1_336000_230400 0 9.334805e-07
I5652 n1_m1_336000_235200 0 6.310671e-07
I5653 n1_m1_336000_240000 0 4.354370e-07
I5654 n1_m1_336000_244800 0 5.442007e-07
I5655 n1_m1_336000_249600 0 1.550678e-06
I5656 n1_m1_336000_254400 0 9.373597e-07
I5657 n1_m1_336000_259200 0 6.833417e-07
I5658 n1_m1_336000_264000 0 7.986460e-07
I5659 n1_m1_336000_268800 0 1.069196e-06
I5660 n1_m1_336000_273600 0 3.518131e-06
I5661 n1_m1_336000_278400 0 7.218344e-06
I5662 n1_m1_336000_283200 0 9.141030e-07
I5663 n1_m1_336000_288000 0 4.933418e-07
I5664 n1_m1_336000_292800 0 8.505628e-07
I5665 n1_m1_336000_297600 0 1.066713e-06
I5666 n1_m1_336000_302400 0 4.507912e-07
I5667 n1_m1_336000_307200 0 7.200584e-07
I5668 n1_m1_336000_312000 0 2.064048e-06
I5669 n1_m1_336000_316800 0 7.715666e-07
I5670 n1_m1_336000_321600 0 9.401738e-07
I5671 n1_m1_336000_326400 0 7.698386e-07
I5672 n1_m1_336000_331200 0 3.221569e-07
I5673 n1_m1_336000_336000 0 1.222187e-06
I5674 n1_m1_336000_340800 0 5.741071e-07
I5675 n1_m1_336000_345600 0 1.035196e-06
I5676 n1_m1_336000_350400 0 2.909540e-07
I5677 n1_m1_336000_355200 0 7.250622e-07
I5678 n1_m1_336000_360000 0 1.598315e-06
I5679 n1_m1_336000_364800 0 1.587666e-07
I5680 n1_m1_336000_369600 0 7.754425e-07
I5681 n1_m1_336000_374400 0 6.872277e-07
I5682 n1_m1_336000_379200 0 4.870479e-07
I5683 n1_m1_336000_384000 0 3.164502e-07
I5684 n1_m1_336000_388800 0 7.283977e-07
I5685 n1_m1_336000_393600 0 8.804046e-07
I5686 n1_m1_336000_398400 0 3.452653e-07
I5687 n1_m1_340800_4800 0 4.452071e-08
I5688 n1_m1_340800_9600 0 2.968289e-07
I5689 n1_m1_340800_14400 0 3.568047e-07
I5690 n1_m1_340800_19200 0 2.049286e-07
I5691 n1_m1_340800_24000 0 5.102857e-07
I5692 n1_m1_340800_28800 0 2.634662e-07
I5693 n1_m1_340800_33600 0 1.949408e-07
I5694 n1_m1_340800_38400 0 2.839167e-07
I5695 n1_m1_340800_43200 0 2.488515e-07
I5696 n1_m1_340800_48000 0 1.764497e-08
I5697 n1_m1_340800_57600 0 1.194118e-07
I5698 n1_m1_340800_62400 0 1.001629e-07
I5699 n1_m1_340800_67200 0 9.012923e-08
I5700 n1_m1_340800_72000 0 2.667002e-07
I5701 n1_m1_340800_76800 0 1.335608e-07
I5702 n1_m1_340800_81600 0 8.121321e-07
I5703 n1_m1_340800_86400 0 1.775532e-07
I5704 n1_m1_340800_91200 0 2.559709e-07
I5705 n1_m1_340800_96000 0 6.822857e-08
I5706 n1_m1_340800_100800 0 3.242632e-07
I5707 n1_m1_340800_105600 0 3.461071e-07
I5708 n1_m1_340800_110400 0 1.452041e-07
I5709 n1_m1_340800_115200 0 1.946537e-07
I5710 n1_m1_340800_120000 0 1.693699e-07
I5711 n1_m1_340800_124800 0 7.142857e-08
I5712 n1_m1_340800_129600 0 1.224286e-07
I5713 n1_m1_340800_134400 0 2.290179e-08
I5714 n1_m1_340800_139200 0 9.947669e-08
I5715 n1_m1_340800_144000 0 2.467103e-07
I5716 n1_m1_340800_148800 0 2.116277e-07
I5717 n1_m1_340800_153600 0 1.705649e-07
I5718 n1_m1_340800_158400 0 2.672440e-07
I5719 n1_m1_340800_163200 0 1.973171e-07
I5720 n1_m1_340800_168000 0 3.840536e-07
I5721 n1_m1_340800_172800 0 3.830357e-07
I5722 n1_m1_340800_177600 0 3.813994e-07
I5723 n1_m1_340800_182400 0 2.819554e-07
I5724 n1_m1_340800_187200 0 1.885714e-08
I5725 n1_m1_340800_192000 0 3.533750e-07
I5726 n1_m1_340800_196800 0 1.131854e-07
I5727 n1_m1_340800_201600 0 3.229888e-07
I5728 n1_m1_340800_206400 0 2.152857e-07
I5729 n1_m1_340800_211200 0 2.135679e-07
I5730 n1_m1_340800_216000 0 9.037500e-08
I5731 n1_m1_340800_220800 0 3.297407e-07
I5732 n1_m1_340800_225600 0 2.787879e-08
I5733 n1_m1_340800_230400 0 2.310090e-07
I5734 n1_m1_340800_235200 0 1.096022e-07
I5735 n1_m1_340800_240000 0 2.894643e-07
I5736 n1_m1_340800_244800 0 2.475000e-07
I5737 n1_m1_340800_249600 0 4.567141e-07
I5738 n1_m1_340800_254400 0 4.116854e-07
I5739 n1_m1_340800_259200 0 3.643948e-07
I5740 n1_m1_340800_264000 0 5.205905e-07
I5741 n1_m1_340800_268800 0 3.823482e-07
I5742 n1_m1_340800_273600 0 3.773357e-07
I5743 n1_m1_340800_278400 0 6.235476e-07
I5744 n1_m1_340800_283200 0 5.158739e-07
I5745 n1_m1_340800_288000 0 4.803292e-07
I5746 n1_m1_340800_292800 0 5.569913e-07
I5747 n1_m1_340800_297600 0 4.053506e-07
I5748 n1_m1_340800_302400 0 1.035000e-07
I5749 n1_m1_340800_307200 0 3.803571e-07
I5750 n1_m1_340800_312000 0 1.911750e-07
I5751 n1_m1_340800_316800 0 1.824572e-07
I5752 n1_m1_340800_321600 0 3.072857e-07
I5753 n1_m1_340800_326400 0 7.821429e-08
I5754 n1_m1_340800_331200 0 2.692727e-07
I5755 n1_m1_340800_336000 0 1.250000e-07
I5756 n1_m1_340800_340800 0 2.142857e-07
I5757 n1_m1_340800_345600 0 3.491161e-07
I5758 n1_m1_340800_350400 0 1.714623e-07
I5759 n1_m1_340800_355200 0 3.710823e-07
I5760 n1_m1_340800_360000 0 1.778605e-07
I5761 n1_m1_340800_364800 0 1.235706e-07
I5762 n1_m1_340800_369600 0 5.157508e-07
I5763 n1_m1_340800_374400 0 3.553571e-07
I5764 n1_m1_340800_379200 0 3.663880e-07
I5765 n1_m1_340800_384000 0 2.323455e-07
I5766 n1_m1_340800_388800 0 3.090000e-08
I5767 n1_m1_340800_393600 0 1.073143e-07
I5768 n1_m1_340800_398400 0 5.245714e-08
I5769 n1_m1_345600_4800 0 2.102485e-07
I5770 n1_m1_345600_9600 0 8.052480e-07
I5771 n1_m1_345600_14400 0 5.595703e-07
I5772 n1_m1_345600_19200 0 6.671429e-07
I5773 n1_m1_345600_24000 0 8.170130e-07
I5774 n1_m1_345600_28800 0 1.374788e-06
I5775 n1_m1_345600_33600 0 6.418077e-07
I5776 n1_m1_345600_38400 0 7.418325e-07
I5777 n1_m1_345600_43200 0 8.265854e-07
I5778 n1_m1_345600_48000 0 7.447731e-07
I5779 n1_m1_345600_52800 0 1.068594e-06
I5780 n1_m1_345600_57600 0 6.192026e-07
I5781 n1_m1_345600_62400 0 1.108750e-06
I5782 n1_m1_345600_67200 0 5.673987e-07
I5783 n1_m1_345600_72000 0 1.738550e-06
I5784 n1_m1_345600_76800 0 1.104954e-06
I5785 n1_m1_345600_81600 0 7.315216e-07
I5786 n1_m1_345600_86400 0 1.039135e-06
I5787 n1_m1_345600_91200 0 6.545440e-07
I5788 n1_m1_345600_96000 0 7.465714e-07
I5789 n1_m1_345600_100800 0 4.429071e-07
I5790 n1_m1_345600_105600 0 7.314250e-07
I5791 n1_m1_345600_110400 0 6.566357e-07
I5792 n1_m1_345600_115200 0 9.882251e-07
I5793 n1_m1_345600_120000 0 4.992251e-07
I5794 n1_m1_345600_124800 0 9.479018e-07
I5795 n1_m1_345600_129600 0 4.570975e-07
I5796 n1_m1_345600_134400 0 7.041312e-07
I5797 n1_m1_345600_139200 0 5.730804e-07
I5798 n1_m1_345600_144000 0 3.882321e-07
I5799 n1_m1_345600_148800 0 6.613420e-07
I5800 n1_m1_345600_153600 0 7.553802e-07
I5801 n1_m1_345600_158400 0 1.157670e-06
I5802 n1_m1_345600_163200 0 8.875177e-07
I5803 n1_m1_345600_168000 0 5.842205e-07
I5804 n1_m1_345600_172800 0 7.454643e-07
I5805 n1_m1_345600_177600 0 9.609792e-07
I5806 n1_m1_345600_182400 0 8.151831e-07
I5807 n1_m1_345600_187200 0 2.859143e-07
I5808 n1_m1_345600_192000 0 1.356830e-06
I5809 n1_m1_345600_196800 0 4.035714e-07
I5810 n1_m1_345600_201600 0 1.407908e-06
I5811 n1_m1_345600_206400 0 1.336971e-06
I5812 n1_m1_345600_211200 0 4.158157e-07
I5813 n1_m1_345600_216000 0 9.703584e-07
I5814 n1_m1_345600_220800 0 4.147608e-07
I5815 n1_m1_345600_225600 0 7.224108e-07
I5816 n1_m1_345600_230400 0 9.213175e-07
I5817 n1_m1_345600_235200 0 8.534210e-07
I5818 n1_m1_345600_240000 0 2.747232e-07
I5819 n1_m1_345600_244800 0 5.897679e-07
I5820 n1_m1_345600_249600 0 7.148384e-07
I5821 n1_m1_345600_254400 0 9.827204e-07
I5822 n1_m1_345600_259200 0 7.692695e-07
I5823 n1_m1_345600_264000 0 1.093167e-06
I5824 n1_m1_345600_268800 0 7.138946e-07
I5825 n1_m1_345600_273600 0 1.022170e-06
I5826 n1_m1_345600_278400 0 1.150690e-06
I5827 n1_m1_345600_283200 0 8.308259e-07
I5828 n1_m1_345600_288000 0 1.070792e-06
I5829 n1_m1_345600_292800 0 8.186364e-07
I5830 n1_m1_345600_297600 0 1.028307e-06
I5831 n1_m1_345600_302400 0 3.128214e-07
I5832 n1_m1_345600_307200 0 8.856696e-07
I5833 n1_m1_345600_312000 0 6.655257e-07
I5834 n1_m1_345600_316800 0 1.231999e-06
I5835 n1_m1_345600_321600 0 1.086866e-06
I5836 n1_m1_345600_326400 0 5.813939e-07
I5837 n1_m1_345600_331200 0 8.485727e-07
I5838 n1_m1_345600_336000 0 7.435165e-07
I5839 n1_m1_345600_340800 0 5.472727e-07
I5840 n1_m1_345600_345600 0 1.009017e-06
I5841 n1_m1_345600_350400 0 3.798821e-07
I5842 n1_m1_345600_355200 0 5.877519e-07
I5843 n1_m1_345600_360000 0 6.570637e-07
I5844 n1_m1_345600_364800 0 9.331018e-07
I5845 n1_m1_345600_369600 0 5.637229e-07
I5846 n1_m1_345600_374400 0 4.936357e-07
I5847 n1_m1_345600_379200 0 1.123622e-06
I5848 n1_m1_345600_384000 0 1.345153e-06
I5849 n1_m1_345600_388800 0 5.191368e-07
I5850 n1_m1_345600_393600 0 4.621292e-07
I5851 n1_m1_345600_398400 0 9.428571e-08
I5852 n1_m1_350400_4800 0 9.323077e-08
I5853 n1_m1_350400_9600 0 7.769231e-09
I5854 n1_m1_350400_14400 0 3.701126e-07
I5855 n1_m1_350400_19200 0 3.956571e-07
I5856 n1_m1_350400_24000 0 6.769298e-07
I5857 n1_m1_350400_28800 0 6.466830e-07
I5858 n1_m1_350400_33600 0 6.917266e-06
I5859 n1_m1_350400_38400 0 5.649889e-07
I5860 n1_m1_350400_43200 0 5.541520e-07
I5861 n1_m1_350400_48000 0 3.114647e-07
I5862 n1_m1_350400_52800 0 2.877491e-07
I5863 n1_m1_350400_57600 0 5.941069e-07
I5864 n1_m1_350400_62400 0 3.225464e-07
I5865 n1_m1_350400_67200 0 4.186308e-07
I5866 n1_m1_350400_72000 0 1.649737e-06
I5867 n1_m1_350400_76800 0 5.589018e-07
I5868 n1_m1_350400_81600 0 2.502181e-06
I5869 n1_m1_350400_86400 0 5.809037e-07
I5870 n1_m1_350400_91200 0 6.832157e-07
I5871 n1_m1_350400_96000 0 4.917143e-07
I5872 n1_m1_350400_100800 0 6.005179e-07
I5873 n1_m1_350400_105600 0 1.094654e-06
I5874 n1_m1_350400_110400 0 6.588137e-07
I5875 n1_m1_350400_115200 0 4.828757e-07
I5876 n1_m1_350400_120000 0 3.829425e-07
I5877 n1_m1_350400_124800 0 9.118461e-07
I5878 n1_m1_350400_129600 0 5.287159e-07
I5879 n1_m1_350400_134400 0 5.710688e-07
I5880 n1_m1_350400_139200 0 5.234407e-07
I5881 n1_m1_350400_144000 0 6.588941e-07
I5882 n1_m1_350400_148800 0 5.268812e-07
I5883 n1_m1_350400_153600 0 5.615216e-07
I5884 n1_m1_350400_158400 0 3.334911e-07
I5885 n1_m1_350400_163200 0 8.413170e-07
I5886 n1_m1_350400_168000 0 8.233387e-07
I5887 n1_m1_350400_172800 0 3.849121e-07
I5888 n1_m1_350400_177600 0 3.113848e-07
I5889 n1_m1_350400_182400 0 2.907767e-07
I5890 n1_m1_350400_187200 0 6.148964e-07
I5891 n1_m1_350400_192000 0 8.912703e-07
I5892 n1_m1_350400_196800 0 3.869945e-07
I5893 n1_m1_350400_201600 0 5.141893e-07
I5894 n1_m1_350400_206400 0 2.072205e-07
I5895 n1_m1_350400_211200 0 7.742321e-07
I5896 n1_m1_350400_216000 0 9.195987e-07
I5897 n1_m1_350400_220800 0 1.808029e-07
I5898 n1_m1_350400_225600 0 9.177551e-07
I5899 n1_m1_350400_230400 0 3.623592e-07
I5900 n1_m1_350400_235200 0 5.009339e-07
I5901 n1_m1_350400_240000 0 2.733393e-07
I5902 n1_m1_350400_244800 0 7.562500e-07
I5903 n1_m1_350400_249600 0 8.130967e-07
I5904 n1_m1_350400_254400 0 7.084482e-07
I5905 n1_m1_350400_259200 0 5.610893e-07
I5906 n1_m1_350400_264000 0 4.884286e-07
I5907 n1_m1_350400_268800 0 6.140018e-07
I5908 n1_m1_350400_273600 0 6.493305e-07
I5909 n1_m1_350400_278400 0 7.558571e-07
I5910 n1_m1_350400_283200 0 6.515204e-07
I5911 n1_m1_350400_288000 0 2.908212e-07
I5912 n1_m1_350400_292800 0 5.721861e-07
I5913 n1_m1_350400_297600 0 5.702399e-07
I5914 n1_m1_350400_302400 0 4.230879e-08
I5915 n1_m1_350400_307200 0 4.438255e-07
I5916 n1_m1_350400_312000 0 5.117282e-07
I5917 n1_m1_350400_316800 0 4.762440e-07
I5918 n1_m1_350400_321600 0 2.987809e-07
I5919 n1_m1_350400_326400 0 1.317918e-07
I5920 n1_m1_350400_331200 0 5.759296e-07
I5921 n1_m1_350400_336000 0 4.407692e-07
I5922 n1_m1_350400_340800 0 8.521390e-07
I5923 n1_m1_350400_345600 0 6.754649e-07
I5924 n1_m1_350400_350400 0 3.641545e-07
I5925 n1_m1_350400_355200 0 4.800959e-07
I5926 n1_m1_350400_360000 0 6.272786e-07
I5927 n1_m1_350400_364800 0 4.312027e-07
I5928 n1_m1_350400_369600 0 1.208313e-06
I5929 n1_m1_350400_374400 0 4.338571e-07
I5930 n1_m1_350400_379200 0 9.915541e-07
I5931 n1_m1_350400_384000 0 9.486360e-07
I5932 n1_m1_350400_388800 0 4.202632e-07
I5933 n1_m1_350400_393600 0 5.225851e-07
I5934 n1_m1_355200_4800 0 4.475524e-07
I5935 n1_m1_355200_9600 0 6.111608e-07
I5936 n1_m1_355200_14400 0 2.575195e-07
I5937 n1_m1_355200_19200 0 1.488868e-07
I5938 n1_m1_355200_24000 0 5.912129e-07
I5939 n1_m1_355200_28800 0 5.275821e-07
I5940 n1_m1_355200_33600 0 1.335640e-06
I5941 n1_m1_355200_38400 0 3.881615e-07
I5942 n1_m1_355200_43200 0 6.154001e-07
I5943 n1_m1_355200_48000 0 1.115770e-06
I5944 n1_m1_355200_52800 0 6.828312e-07
I5945 n1_m1_355200_57600 0 1.959442e-07
I5946 n1_m1_355200_62400 0 4.028750e-07
I5947 n1_m1_355200_67200 0 4.010536e-07
I5948 n1_m1_355200_72000 0 5.507382e-07
I5949 n1_m1_355200_76800 0 5.182850e-07
I5950 n1_m1_355200_81600 0 1.517720e-06
I5951 n1_m1_355200_86400 0 2.836841e-07
I5952 n1_m1_355200_91200 0 3.232740e-06
I5953 n1_m1_355200_96000 0 2.503673e-06
I5954 n1_m1_355200_100800 0 3.887442e-07
I5955 n1_m1_355200_105600 0 1.021154e-06
I5956 n1_m1_355200_110400 0 9.373252e-07
I5957 n1_m1_355200_115200 0 5.918036e-07
I5958 n1_m1_355200_120000 0 6.409821e-07
I5959 n1_m1_355200_124800 0 4.500467e-07
I5960 n1_m1_355200_129600 0 6.589255e-07
I5961 n1_m1_355200_134400 0 5.749307e-07
I5962 n1_m1_355200_139200 0 6.794433e-07
I5963 n1_m1_355200_144000 0 1.219328e-06
I5964 n1_m1_355200_148800 0 3.374159e-07
I5965 n1_m1_355200_153600 0 7.313577e-07
I5966 n1_m1_355200_158400 0 7.871429e-07
I5967 n1_m1_355200_163200 0 2.835750e-07
I5968 n1_m1_355200_168000 0 6.095568e-07
I5969 n1_m1_355200_172800 0 2.919212e-07
I5970 n1_m1_355200_177600 0 1.069163e-06
I5971 n1_m1_355200_182400 0 4.048393e-07
I5972 n1_m1_355200_187200 0 4.774143e-07
I5973 n1_m1_355200_192000 0 8.914917e-07
I5974 n1_m1_355200_196800 0 5.636422e-07
I5975 n1_m1_355200_201600 0 6.876667e-07
I5976 n1_m1_355200_206400 0 6.255179e-07
I5977 n1_m1_355200_211200 0 3.492841e-07
I5978 n1_m1_355200_216000 0 4.879991e-07
I5979 n1_m1_355200_220800 0 4.597922e-07
I5980 n1_m1_355200_225600 0 9.666435e-07
I5981 n1_m1_355200_230400 0 4.462665e-07
I5982 n1_m1_355200_235200 0 5.224791e-07
I5983 n1_m1_355200_240000 0 8.452268e-07
I5984 n1_m1_355200_244800 0 4.256964e-07
I5985 n1_m1_355200_249600 0 1.237519e-06
I5986 n1_m1_355200_254400 0 3.406990e-07
I5987 n1_m1_355200_259200 0 7.200714e-07
I5988 n1_m1_355200_264000 0 6.852048e-07
I5989 n1_m1_355200_268800 0 3.531107e-07
I5990 n1_m1_355200_273600 0 5.240268e-07
I5991 n1_m1_355200_278400 0 3.620342e-06
I5992 n1_m1_355200_283200 0 1.657894e-06
I5993 n1_m1_355200_288000 0 6.770048e-07
I5994 n1_m1_355200_292800 0 1.681071e-07
I5995 n1_m1_355200_297600 0 6.077071e-07
I5996 n1_m1_355200_302400 0 3.545741e-07
I5997 n1_m1_355200_307200 0 6.922905e-07
I5998 n1_m1_355200_312000 0 7.526327e-07
I5999 n1_m1_355200_316800 0 2.921943e-07
I6000 n1_m1_355200_321600 0 4.397650e-07
I6001 n1_m1_355200_326400 0 9.363265e-08
I6002 n1_m1_355200_331200 0 4.088782e-07
I6003 n1_m1_355200_336000 0 4.892787e-07
I6004 n1_m1_355200_340800 0 4.708739e-07
I6005 n1_m1_355200_345600 0 6.764790e-07
I6006 n1_m1_355200_350400 0 6.195879e-08
I6007 n1_m1_355200_355200 0 4.591951e-07
I6008 n1_m1_355200_360000 0 3.119742e-07
I6009 n1_m1_355200_364800 0 7.121429e-07
I6010 n1_m1_355200_369600 0 5.438571e-07
I6011 n1_m1_355200_374400 0 9.600000e-08
I6012 n1_m1_355200_379200 0 1.042857e-06
I6013 n1_m1_355200_384000 0 1.324202e-06
I6014 n1_m1_355200_388800 0 1.700571e-07
I6015 n1_m1_355200_393600 0 1.100000e-07
I6016 n1_m1_360000_4800 0 2.909091e-07
I6017 n1_m1_360000_9600 0 6.543776e-07
I6018 n1_m1_360000_14400 0 9.600747e-07
I6019 n1_m1_360000_19200 0 6.696089e-07
I6020 n1_m1_360000_24000 0 7.967017e-07
I6021 n1_m1_360000_28800 0 5.270537e-07
I6022 n1_m1_360000_33600 0 3.170132e-07
I6023 n1_m1_360000_38400 0 9.021329e-07
I6024 n1_m1_360000_43200 0 8.427177e-07
I6025 n1_m1_360000_48000 0 5.903376e-07
I6026 n1_m1_360000_52800 0 7.525205e-07
I6027 n1_m1_360000_57600 0 5.040034e-07
I6028 n1_m1_360000_62400 0 7.290286e-07
I6029 n1_m1_360000_67200 0 7.428312e-07
I6030 n1_m1_360000_72000 0 8.451060e-07
I6031 n1_m1_360000_76800 0 9.398462e-07
I6032 n1_m1_360000_81600 0 2.538569e-06
I6033 n1_m1_360000_86400 0 3.652596e-07
I6034 n1_m1_360000_91200 0 2.489443e-06
I6035 n1_m1_360000_96000 0 2.458390e-06
I6036 n1_m1_360000_100800 0 7.897936e-07
I6037 n1_m1_360000_105600 0 8.162455e-07
I6038 n1_m1_360000_110400 0 1.427088e-06
I6039 n1_m1_360000_115200 0 5.462449e-07
I6040 n1_m1_360000_120000 0 1.231020e-06
I6041 n1_m1_360000_124800 0 1.090491e-06
I6042 n1_m1_360000_129600 0 1.324455e-06
I6043 n1_m1_360000_134400 0 9.175706e-07
I6044 n1_m1_360000_139200 0 4.551071e-07
I6045 n1_m1_360000_144000 0 6.787418e-07
I6046 n1_m1_360000_148800 0 1.044325e-06
I6047 n1_m1_360000_153600 0 1.107302e-06
I6048 n1_m1_360000_158400 0 6.458429e-07
I6049 n1_m1_360000_163200 0 6.351788e-07
I6050 n1_m1_360000_168000 0 9.274626e-07
I6051 n1_m1_360000_172800 0 1.077722e-06
I6052 n1_m1_360000_177600 0 9.820666e-07
I6053 n1_m1_360000_182400 0 5.855759e-07
I6054 n1_m1_360000_187200 0 1.025996e-06
I6055 n1_m1_360000_192000 0 1.504446e-06
I6056 n1_m1_360000_196800 0 7.613065e-07
I6057 n1_m1_360000_201600 0 8.230599e-07
I6058 n1_m1_360000_206400 0 6.751111e-07
I6059 n1_m1_360000_211200 0 5.058841e-07
I6060 n1_m1_360000_216000 0 7.261723e-07
I6061 n1_m1_360000_220800 0 6.181364e-07
I6062 n1_m1_360000_225600 0 8.816423e-06
I6063 n1_m1_360000_230400 0 8.723728e-07
I6064 n1_m1_360000_235200 0 5.361432e-07
I6065 n1_m1_360000_240000 0 1.196978e-06
I6066 n1_m1_360000_244800 0 1.112223e-06
I6067 n1_m1_360000_249600 0 8.491113e-07
I6068 n1_m1_360000_254400 0 7.113482e-07
I6069 n1_m1_360000_259200 0 8.978214e-07
I6070 n1_m1_360000_264000 0 1.120775e-06
I6071 n1_m1_360000_268800 0 1.003232e-06
I6072 n1_m1_360000_273600 0 9.390018e-07
I6073 n1_m1_360000_278400 0 2.681123e-06
I6074 n1_m1_360000_283200 0 1.699840e-06
I6075 n1_m1_360000_288000 0 1.076835e-06
I6076 n1_m1_360000_292800 0 5.504708e-07
I6077 n1_m1_360000_297600 0 7.391372e-07
I6078 n1_m1_360000_302400 0 5.856654e-07
I6079 n1_m1_360000_307200 0 1.109353e-06
I6080 n1_m1_360000_312000 0 5.912412e-07
I6081 n1_m1_360000_316800 0 7.856786e-07
I6082 n1_m1_360000_321600 0 1.117270e-06
I6083 n1_m1_360000_326400 0 2.218912e-07
I6084 n1_m1_360000_331200 0 9.028128e-07
I6085 n1_m1_360000_336000 0 4.098729e-07
I6086 n1_m1_360000_340800 0 6.574076e-07
I6087 n1_m1_360000_345600 0 1.455576e-06
I6088 n1_m1_360000_350400 0 6.046920e-07
I6089 n1_m1_360000_355200 0 9.490446e-07
I6090 n1_m1_360000_360000 0 4.523374e-07
I6091 n1_m1_360000_364800 0 6.322420e-07
I6092 n1_m1_360000_369600 0 6.028214e-07
I6093 n1_m1_360000_374400 0 3.908895e-07
I6094 n1_m1_360000_379200 0 1.426922e-06
I6095 n1_m1_360000_384000 0 1.536384e-06
I6096 n1_m1_360000_388800 0 8.075491e-07
I6097 n1_m1_360000_393600 0 1.224884e-06
I6098 n1_m1_360000_398400 0 1.054286e-07
I6099 n1_m1_364800_14400 0 3.717344e-07
I6100 n1_m1_364800_19200 0 1.977579e-07
I6101 n1_m1_364800_24000 0 5.909470e-07
I6102 n1_m1_364800_28800 0 4.991301e-07
I6103 n1_m1_364800_33600 0 2.013505e-07
I6104 n1_m1_364800_38400 0 1.587239e-07
I6105 n1_m1_364800_43200 0 3.492045e-07
I6106 n1_m1_364800_48000 0 4.399141e-07
I6107 n1_m1_364800_52800 0 4.868042e-07
I6108 n1_m1_364800_57600 0 1.673750e-07
I6109 n1_m1_364800_62400 0 5.960357e-07
I6110 n1_m1_364800_67200 0 3.802679e-07
I6111 n1_m1_364800_72000 0 1.016923e-07
I6112 n1_m1_364800_76800 0 3.379341e-07
I6113 n1_m1_364800_81600 0 1.807963e-06
I6114 n1_m1_364800_86400 0 6.969203e-07
I6115 n1_m1_364800_91200 0 2.609274e-07
I6116 n1_m1_364800_96000 0 9.024595e-07
I6117 n1_m1_364800_100800 0 6.163357e-07
I6118 n1_m1_364800_105600 0 7.221473e-07
I6119 n1_m1_364800_110400 0 5.565657e-07
I6120 n1_m1_364800_115200 0 4.811501e-07
I6121 n1_m1_364800_120000 0 9.990236e-07
I6122 n1_m1_364800_124800 0 3.431868e-07
I6123 n1_m1_364800_129600 0 8.506364e-07
I6124 n1_m1_364800_134400 0 5.772364e-07
I6125 n1_m1_364800_139200 0 4.220879e-07
I6126 n1_m1_364800_144000 0 9.281593e-07
I6127 n1_m1_364800_148800 0 2.560066e-07
I6128 n1_m1_364800_153600 0 8.623380e-07
I6129 n1_m1_364800_158400 0 4.519286e-07
I6130 n1_m1_364800_163200 0 6.509221e-07
I6131 n1_m1_364800_168000 0 8.689068e-07
I6132 n1_m1_364800_172800 0 4.433042e-07
I6133 n1_m1_364800_177600 0 8.619684e-07
I6134 n1_m1_364800_182400 0 6.344137e-07
I6135 n1_m1_364800_187200 0 3.702321e-07
I6136 n1_m1_364800_192000 0 8.179360e-07
I6137 n1_m1_364800_196800 0 2.325952e-07
I6138 n1_m1_364800_201600 0 5.818544e-07
I6139 n1_m1_364800_206400 0 3.954425e-07
I6140 n1_m1_364800_211200 0 5.903157e-07
I6141 n1_m1_364800_216000 0 5.615786e-07
I6142 n1_m1_364800_220800 0 5.248500e-07
I6143 n1_m1_364800_225600 0 6.629821e-07
I6144 n1_m1_364800_230400 0 5.191893e-07
I6145 n1_m1_364800_235200 0 1.866480e-07
I6146 n1_m1_364800_240000 0 8.234957e-07
I6147 n1_m1_364800_244800 0 4.450950e-07
I6148 n1_m1_364800_249600 0 9.085446e-07
I6149 n1_m1_364800_254400 0 3.087607e-07
I6150 n1_m1_364800_259200 0 4.448474e-07
I6151 n1_m1_364800_264000 0 5.519173e-07
I6152 n1_m1_364800_268800 0 3.949132e-07
I6153 n1_m1_364800_273600 0 1.144720e-06
I6154 n1_m1_364800_278400 0 2.616871e-06
I6155 n1_m1_364800_283200 0 4.050224e-07
I6156 n1_m1_364800_288000 0 7.373057e-07
I6157 n1_m1_364800_292800 0 6.998918e-07
I6158 n1_m1_364800_297600 0 4.463523e-07
I6159 n1_m1_364800_302400 0 1.224152e-07
I6160 n1_m1_364800_307200 0 3.788807e-07
I6161 n1_m1_364800_312000 0 1.992798e-07
I6162 n1_m1_364800_316800 0 3.240464e-07
I6163 n1_m1_364800_321600 0 6.355699e-06
I6164 n1_m1_364800_326400 0 7.036850e-07
I6165 n1_m1_364800_331200 0 3.119792e-07
I6166 n1_m1_364800_336000 0 2.586051e-07
I6167 n1_m1_364800_340800 0 2.268700e-07
I6168 n1_m1_364800_345600 0 1.032368e-06
I6169 n1_m1_364800_350400 0 1.775696e-07
I6170 n1_m1_364800_355200 0 2.798214e-07
I6171 n1_m1_364800_360000 0 3.183071e-07
I6172 n1_m1_364800_364800 0 6.459777e-07
I6173 n1_m1_364800_369600 0 6.847747e-07
I6174 n1_m1_364800_374400 0 4.849534e-07
I6175 n1_m1_364800_379200 0 6.938095e-07
I6176 n1_m1_364800_384000 0 2.858874e-07
I6177 n1_m1_364800_388800 0 2.222937e-07
I6178 n1_m1_364800_393600 0 5.938304e-07
I6179 n1_m1_364800_398400 0 2.322857e-07
I6180 n1_m1_369600_4800 0 4.294038e-07
I6181 n1_m1_369600_9600 0 6.766170e-07
I6182 n1_m1_369600_14400 0 6.750893e-07
I6183 n1_m1_369600_19200 0 4.124515e-07
I6184 n1_m1_369600_24000 0 5.246735e-07
I6185 n1_m1_369600_28800 0 5.235368e-07
I6186 n1_m1_369600_33600 0 4.399661e-07
I6187 n1_m1_369600_38400 0 6.521202e-07
I6188 n1_m1_369600_43200 0 1.745495e-07
I6189 n1_m1_369600_48000 0 6.056033e-07
I6190 n1_m1_369600_52800 0 4.875545e-07
I6191 n1_m1_369600_57600 0 5.237254e-07
I6192 n1_m1_369600_62400 0 1.968250e-07
I6193 n1_m1_369600_67200 0 1.474000e-07
I6194 n1_m1_369600_72000 0 1.062628e-06
I6195 n1_m1_369600_76800 0 5.052170e-07
I6196 n1_m1_369600_81600 0 6.552589e-07
I6197 n1_m1_369600_86400 0 2.379673e-07
I6198 n1_m1_369600_91200 0 2.402791e-07
I6199 n1_m1_369600_96000 0 8.291857e-07
I6200 n1_m1_369600_100800 0 4.772799e-07
I6201 n1_m1_369600_105600 0 8.699196e-07
I6202 n1_m1_369600_110400 0 2.751667e-07
I6203 n1_m1_369600_115200 0 4.395472e-07
I6204 n1_m1_369600_120000 0 6.546801e-07
I6205 n1_m1_369600_124800 0 5.631321e-06
I6206 n1_m1_369600_129600 0 2.756300e-06
I6207 n1_m1_369600_134400 0 4.354646e-07
I6208 n1_m1_369600_139200 0 2.106429e-07
I6209 n1_m1_369600_144000 0 7.023904e-07
I6210 n1_m1_369600_148800 0 3.979307e-07
I6211 n1_m1_369600_153600 0 3.796780e-07
I6212 n1_m1_369600_158400 0 3.080500e-07
I6213 n1_m1_369600_163200 0 4.415381e-07
I6214 n1_m1_369600_168000 0 5.083143e-07
I6215 n1_m1_369600_172800 0 3.145013e-07
I6216 n1_m1_369600_177600 0 4.120154e-07
I6217 n1_m1_369600_182400 0 3.583536e-07
I6218 n1_m1_369600_187200 0 6.865714e-07
I6219 n1_m1_369600_192000 0 9.234519e-07
I6220 n1_m1_369600_196800 0 5.221107e-07
I6221 n1_m1_369600_201600 0 8.521238e-07
I6222 n1_m1_369600_206400 0 6.329821e-07
I6223 n1_m1_369600_211200 0 3.350393e-07
I6224 n1_m1_369600_216000 0 1.123567e-06
I6225 n1_m1_369600_220800 0 4.525322e-07
I6226 n1_m1_369600_225600 0 6.115323e-07
I6227 n1_m1_369600_230400 0 7.724786e-07
I6228 n1_m1_369600_235200 0 3.585286e-07
I6229 n1_m1_369600_240000 0 6.337360e-07
I6230 n1_m1_369600_244800 0 3.530545e-07
I6231 n1_m1_369600_249600 0 5.267590e-07
I6232 n1_m1_369600_254400 0 3.100079e-07
I6233 n1_m1_369600_259200 0 2.884929e-07
I6234 n1_m1_369600_264000 0 5.791940e-07
I6235 n1_m1_369600_268800 0 2.334739e-07
I6236 n1_m1_369600_273600 0 1.093527e-06
I6237 n1_m1_369600_278400 0 4.360491e-07
I6238 n1_m1_369600_283200 0 5.928139e-07
I6239 n1_m1_369600_288000 0 6.370112e-07
I6240 n1_m1_369600_292800 0 4.607423e-07
I6241 n1_m1_369600_297600 0 7.331994e-07
I6242 n1_m1_369600_302400 0 2.351598e-07
I6243 n1_m1_369600_307200 0 6.117817e-07
I6244 n1_m1_369600_312000 0 6.114805e-07
I6245 n1_m1_369600_316800 0 5.520849e-07
I6246 n1_m1_369600_321600 0 9.427685e-07
I6247 n1_m1_369600_326400 0 2.820577e-07
I6248 n1_m1_369600_331200 0 3.810427e-07
I6249 n1_m1_369600_336000 0 7.242607e-07
I6250 n1_m1_369600_340800 0 3.911044e-07
I6251 n1_m1_369600_345600 0 2.018030e-07
I6252 n1_m1_369600_350400 0 2.772366e-07
I6253 n1_m1_369600_355200 0 6.686964e-07
I6254 n1_m1_369600_360000 0 7.096082e-07
I6255 n1_m1_369600_364800 0 1.212088e-07
I6256 n1_m1_369600_369600 0 5.397878e-07
I6257 n1_m1_369600_374400 0 3.761368e-07
I6258 n1_m1_369600_379200 0 4.167471e-07
I6259 n1_m1_369600_384000 0 5.529913e-07
I6260 n1_m1_369600_388800 0 5.537582e-07
I6261 n1_m1_369600_393600 0 6.901375e-07
I6262 n1_m1_369600_398400 0 9.600000e-08
I6263 n1_m1_374400_4800 0 3.339808e-07
I6264 n1_m1_374400_9600 0 5.055984e-07
I6265 n1_m1_374400_14400 0 3.462946e-07
I6266 n1_m1_374400_19200 0 2.998214e-07
I6267 n1_m1_374400_24000 0 6.837143e-07
I6268 n1_m1_374400_28800 0 4.136845e-07
I6269 n1_m1_374400_33600 0 3.984262e-07
I6270 n1_m1_374400_38400 0 3.597991e-07
I6271 n1_m1_374400_43200 0 2.185154e-07
I6272 n1_m1_374400_48000 0 4.727229e-07
I6273 n1_m1_374400_52800 0 7.116928e-07
I6274 n1_m1_374400_57600 0 3.356345e-07
I6275 n1_m1_374400_62400 0 4.848411e-07
I6276 n1_m1_374400_67200 0 3.935973e-07
I6277 n1_m1_374400_72000 0 5.028360e-07
I6278 n1_m1_374400_76800 0 8.351930e-07
I6279 n1_m1_374400_81600 0 1.149777e-06
I6280 n1_m1_374400_86400 0 4.974433e-07
I6281 n1_m1_374400_91200 0 3.329451e-07
I6282 n1_m1_374400_96000 0 8.467143e-07
I6283 n1_m1_374400_100800 0 2.583703e-07
I6284 n1_m1_374400_105600 0 5.765361e-07
I6285 n1_m1_374400_110400 0 4.864017e-07
I6286 n1_m1_374400_115200 0 8.208527e-07
I6287 n1_m1_374400_120000 0 9.519742e-07
I6288 n1_m1_374400_124800 0 2.218929e-07
I6289 n1_m1_374400_129600 0 9.464396e-07
I6290 n1_m1_374400_134400 0 1.198176e-06
I6291 n1_m1_374400_139200 0 4.025714e-07
I6292 n1_m1_374400_144000 0 8.218953e-07
I6293 n1_m1_374400_148800 0 1.327089e-06
I6294 n1_m1_374400_153600 0 3.000673e-06
I6295 n1_m1_374400_158400 0 4.617527e-07
I6296 n1_m1_374400_163200 0 1.140352e-06
I6297 n1_m1_374400_168000 0 5.005667e-07
I6298 n1_m1_374400_172800 0 4.972468e-07
I6299 n1_m1_374400_177600 0 6.667100e-07
I6300 n1_m1_374400_182400 0 2.110061e-06
I6301 n1_m1_374400_187200 0 2.655921e-06
I6302 n1_m1_374400_192000 0 6.405213e-07
I6303 n1_m1_374400_196800 0 2.195586e-07
I6304 n1_m1_374400_201600 0 6.060815e-07
I6305 n1_m1_374400_206400 0 9.144777e-07
I6306 n1_m1_374400_211200 0 3.929304e-07
I6307 n1_m1_374400_216000 0 7.125007e-07
I6308 n1_m1_374400_220800 0 3.867202e-07
I6309 n1_m1_374400_225600 0 4.991725e-07
I6310 n1_m1_374400_230400 0 6.706071e-07
I6311 n1_m1_374400_235200 0 4.909643e-07
I6312 n1_m1_374400_240000 0 1.036247e-06
I6313 n1_m1_374400_244800 0 3.524364e-07
I6314 n1_m1_374400_249600 0 9.457528e-07
I6315 n1_m1_374400_254400 0 3.460547e-07
I6316 n1_m1_374400_259200 0 5.603757e-07
I6317 n1_m1_374400_264000 0 9.208622e-07
I6318 n1_m1_374400_268800 0 3.990121e-07
I6319 n1_m1_374400_273600 0 4.729586e-07
I6320 n1_m1_374400_278400 0 2.165974e-07
I6321 n1_m1_374400_283200 0 3.478197e-07
I6322 n1_m1_374400_288000 0 4.711453e-07
I6323 n1_m1_374400_292800 0 4.639541e-07
I6324 n1_m1_374400_297600 0 1.204070e-06
I6325 n1_m1_374400_302400 0 5.235952e-07
I6326 n1_m1_374400_307200 0 3.389286e-07
I6327 n1_m1_374400_312000 0 4.018400e-07
I6328 n1_m1_374400_316800 0 2.027915e-07
I6329 n1_m1_374400_321600 0 6.963185e-07
I6330 n1_m1_374400_326400 0 3.917885e-07
I6331 n1_m1_374400_331200 0 9.276593e-08
I6332 n1_m1_374400_336000 0 7.199227e-07
I6333 n1_m1_374400_340800 0 6.497706e-07
I6334 n1_m1_374400_345600 0 1.402542e-06
I6335 n1_m1_374400_350400 0 3.966165e-07
I6336 n1_m1_374400_355200 0 5.612679e-07
I6337 n1_m1_374400_360000 0 4.954029e-07
I6338 n1_m1_374400_364800 0 3.973882e-07
I6339 n1_m1_374400_369600 0 7.804230e-07
I6340 n1_m1_374400_374400 0 5.633128e-07
I6341 n1_m1_374400_379200 0 8.097209e-06
I6342 n1_m1_374400_384000 0 8.256755e-07
I6343 n1_m1_374400_388800 0 2.177143e-07
I6344 n1_m1_374400_393600 0 8.663125e-07
I6345 n1_m1_379200_9600 0 2.345000e-08
I6346 n1_m1_379200_14400 0 2.776786e-07
I6347 n1_m1_379200_19200 0 3.755714e-07
I6348 n1_m1_379200_24000 0 1.632857e-06
I6349 n1_m1_379200_28800 0 5.666607e-07
I6350 n1_m1_379200_33600 0 5.604035e-07
I6351 n1_m1_379200_38400 0 6.924665e-07
I6352 n1_m1_379200_43200 0 2.394244e-07
I6353 n1_m1_379200_48000 0 6.180316e-07
I6354 n1_m1_379200_52800 0 1.068403e-06
I6355 n1_m1_379200_57600 0 6.658713e-07
I6356 n1_m1_379200_62400 0 7.171964e-07
I6357 n1_m1_379200_67200 0 1.110346e-06
I6358 n1_m1_379200_72000 0 4.358387e-07
I6359 n1_m1_379200_76800 0 1.916044e-06
I6360 n1_m1_379200_81600 0 1.744722e-06
I6361 n1_m1_379200_86400 0 6.370858e-07
I6362 n1_m1_379200_91200 0 2.273939e-07
I6363 n1_m1_379200_96000 0 4.368214e-07
I6364 n1_m1_379200_100800 0 8.555989e-07
I6365 n1_m1_379200_105600 0 8.045309e-07
I6366 n1_m1_379200_110400 0 4.708602e-07
I6367 n1_m1_379200_115200 0 8.977313e-07
I6368 n1_m1_379200_120000 0 6.616616e-07
I6369 n1_m1_379200_124800 0 3.270268e-07
I6370 n1_m1_379200_129600 0 6.505526e-07
I6371 n1_m1_379200_134400 0 8.775195e-07
I6372 n1_m1_379200_139200 0 6.388571e-07
I6373 n1_m1_379200_144000 0 8.939286e-07
I6374 n1_m1_379200_148800 0 1.975965e-06
I6375 n1_m1_379200_153600 0 4.408324e-06
I6376 n1_m1_379200_158400 0 4.464890e-07
I6377 n1_m1_379200_163200 0 2.745577e-07
I6378 n1_m1_379200_168000 0 6.072789e-07
I6379 n1_m1_379200_172800 0 3.683091e-07
I6380 n1_m1_379200_177600 0 4.800770e-07
I6381 n1_m1_379200_182400 0 1.769082e-06
I6382 n1_m1_379200_187200 0 2.135347e-06
I6383 n1_m1_379200_192000 0 8.655536e-07
I6384 n1_m1_379200_196800 0 3.384103e-07
I6385 n1_m1_379200_201600 0 9.398225e-07
I6386 n1_m1_379200_206400 0 5.096071e-07
I6387 n1_m1_379200_211200 0 4.233482e-07
I6388 n1_m1_379200_216000 0 8.128916e-07
I6389 n1_m1_379200_220800 0 1.806330e-07
I6390 n1_m1_379200_225600 0 9.339524e-07
I6391 n1_m1_379200_230400 0 2.067143e-07
I6392 n1_m1_379200_235200 0 5.175000e-07
I6393 n1_m1_379200_240000 0 8.898658e-07
I6394 n1_m1_379200_244800 0 2.185714e-07
I6395 n1_m1_379200_249600 0 6.043939e-07
I6396 n1_m1_379200_254400 0 4.056791e-07
I6397 n1_m1_379200_259200 0 5.588279e-07
I6398 n1_m1_379200_264000 0 5.438781e-07
I6399 n1_m1_379200_268800 0 3.867524e-07
I6400 n1_m1_379200_273600 0 8.458539e-07
I6401 n1_m1_379200_278400 0 5.251059e-07
I6402 n1_m1_379200_283200 0 8.315471e-07
I6403 n1_m1_379200_288000 0 8.110948e-07
I6404 n1_m1_379200_292800 0 4.117634e-07
I6405 n1_m1_379200_297600 0 1.330402e-06
I6406 n1_m1_379200_302400 0 5.608476e-07
I6407 n1_m1_379200_307200 0 5.631250e-07
I6408 n1_m1_379200_312000 0 1.080400e-06
I6409 n1_m1_379200_316800 0 5.178464e-07
I6410 n1_m1_379200_321600 0 7.962381e-07
I6411 n1_m1_379200_326400 0 1.015393e-06
I6412 n1_m1_379200_331200 0 1.983750e-07
I6413 n1_m1_379200_336000 0 4.448859e-07
I6414 n1_m1_379200_340800 0 4.131250e-07
I6415 n1_m1_379200_345600 0 6.722822e-06
I6416 n1_m1_379200_350400 0 6.799463e-07
I6417 n1_m1_379200_355200 0 1.470589e-06
I6418 n1_m1_379200_360000 0 5.603304e-07
I6419 n1_m1_379200_364800 0 6.519052e-07
I6420 n1_m1_379200_369600 0 4.172321e-07
I6421 n1_m1_379200_374400 0 5.006250e-08
I6422 n1_m1_379200_379200 0 3.030536e-07
I6423 n1_m1_379200_384000 0 6.102000e-07
I6424 n1_m1_379200_388800 0 4.180714e-07
I6425 n1_m1_379200_393600 0 5.706046e-07
I6426 n1_m1_379200_398400 0 2.143922e-07
I6427 n1_m1_384000_14400 0 8.502009e-07
I6428 n1_m1_384000_19200 0 4.561786e-07
I6429 n1_m1_384000_24000 0 5.233080e-07
I6430 n1_m1_384000_28800 0 7.030913e-07
I6431 n1_m1_384000_33600 0 8.103421e-06
I6432 n1_m1_384000_38400 0 6.714940e-07
I6433 n1_m1_384000_43200 0 2.071141e-07
I6434 n1_m1_384000_48000 0 4.825536e-07
I6435 n1_m1_384000_52800 0 8.951964e-07
I6436 n1_m1_384000_57600 0 3.213869e-07
I6437 n1_m1_384000_62400 0 8.545714e-07
I6438 n1_m1_384000_67200 0 6.835875e-07
I6439 n1_m1_384000_72000 0 8.560361e-07
I6440 n1_m1_384000_76800 0 3.982204e-06
I6441 n1_m1_384000_81600 0 3.727242e-06
I6442 n1_m1_384000_86400 0 7.628737e-07
I6443 n1_m1_384000_91200 0 3.020711e-07
I6444 n1_m1_384000_96000 0 8.301188e-07
I6445 n1_m1_384000_100800 0 8.465526e-07
I6446 n1_m1_384000_105600 0 9.645728e-07
I6447 n1_m1_384000_110400 0 8.151583e-07
I6448 n1_m1_384000_115200 0 3.821520e-07
I6449 n1_m1_384000_120000 0 1.085243e-06
I6450 n1_m1_384000_124800 0 6.220268e-07
I6451 n1_m1_384000_129600 0 8.378982e-07
I6452 n1_m1_384000_134400 0 7.540709e-07
I6453 n1_m1_384000_139200 0 3.883469e-07
I6454 n1_m1_384000_144000 0 1.218640e-06
I6455 n1_m1_384000_148800 0 2.957073e-07
I6456 n1_m1_384000_153600 0 8.487987e-07
I6457 n1_m1_384000_158400 0 4.192874e-07
I6458 n1_m1_384000_163200 0 3.373324e-07
I6459 n1_m1_384000_168000 0 1.120709e-06
I6460 n1_m1_384000_172800 0 4.035029e-07
I6461 n1_m1_384000_177600 0 1.309741e-06
I6462 n1_m1_384000_182400 0 5.717319e-07
I6463 n1_m1_384000_187200 0 9.110589e-07
I6464 n1_m1_384000_192000 0 9.656055e-07
I6465 n1_m1_384000_196800 0 5.451739e-07
I6466 n1_m1_384000_201600 0 1.098437e-06
I6467 n1_m1_384000_206400 0 3.947929e-07
I6468 n1_m1_384000_211200 0 3.934672e-07
I6469 n1_m1_384000_216000 0 9.790601e-07
I6470 n1_m1_384000_220800 0 2.825161e-07
I6471 n1_m1_384000_225600 0 1.091955e-06
I6472 n1_m1_384000_230400 0 5.346714e-06
I6473 n1_m1_384000_235200 0 4.048205e-06
I6474 n1_m1_384000_240000 0 1.391013e-06
I6475 n1_m1_384000_244800 0 3.915878e-07
I6476 n1_m1_384000_249600 0 3.568223e-06
I6477 n1_m1_384000_254400 0 1.886475e-06
I6478 n1_m1_384000_259200 0 8.109937e-07
I6479 n1_m1_384000_264000 0 7.125500e-07
I6480 n1_m1_384000_268800 0 8.465281e-07
I6481 n1_m1_384000_273600 0 1.052903e-06
I6482 n1_m1_384000_278400 0 6.943709e-07
I6483 n1_m1_384000_283200 0 1.538265e-06
I6484 n1_m1_384000_288000 0 9.635880e-07
I6485 n1_m1_384000_292800 0 9.891946e-07
I6486 n1_m1_384000_297600 0 1.851846e-06
I6487 n1_m1_384000_302400 0 3.988643e-07
I6488 n1_m1_384000_307200 0 8.780995e-07
I6489 n1_m1_384000_312000 0 5.665084e-07
I6490 n1_m1_384000_316800 0 9.133599e-07
I6491 n1_m1_384000_321600 0 9.041399e-07
I6492 n1_m1_384000_326400 0 6.308929e-07
I6493 n1_m1_384000_331200 0 7.600938e-07
I6494 n1_m1_384000_336000 0 6.343104e-07
I6495 n1_m1_384000_340800 0 4.922411e-07
I6496 n1_m1_384000_345600 0 8.693594e-07
I6497 n1_m1_384000_350400 0 6.352554e-07
I6498 n1_m1_384000_355200 0 1.199891e-06
I6499 n1_m1_384000_360000 0 5.578861e-07
I6500 n1_m1_384000_364800 0 7.166206e-07
I6501 n1_m1_384000_369600 0 3.589352e-07
I6502 n1_m1_384000_374400 0 7.460277e-07
I6503 n1_m1_384000_379200 0 3.778041e-07
I6504 n1_m1_384000_384000 0 9.381420e-07
I6505 n1_m1_384000_388800 0 2.234429e-07
I6506 n1_m1_384000_393600 0 1.221660e-06
I6507 n1_m1_384000_398400 0 5.584935e-07
I6508 n1_m1_388800_9600 0 9.500000e-08
I6509 n1_m1_388800_14400 0 3.313094e-07
I6510 n1_m1_388800_19200 0 3.295903e-07
I6511 n1_m1_388800_24000 0 4.707940e-07
I6512 n1_m1_388800_28800 0 4.113033e-07
I6513 n1_m1_388800_33600 0 3.229674e-07
I6514 n1_m1_388800_38400 0 6.532933e-07
I6515 n1_m1_388800_43200 0 9.498462e-08
I6516 n1_m1_388800_48000 0 4.823203e-07
I6517 n1_m1_388800_52800 0 3.945508e-07
I6518 n1_m1_388800_57600 0 2.950479e-07
I6519 n1_m1_388800_62400 0 4.270087e-07
I6520 n1_m1_388800_67200 0 4.115471e-07
I6521 n1_m1_388800_72000 0 4.229294e-07
I6522 n1_m1_388800_76800 0 2.989390e-07
I6523 n1_m1_388800_81600 0 6.374303e-07
I6524 n1_m1_388800_86400 0 5.286615e-07
I6525 n1_m1_388800_91200 0 1.438299e-07
I6526 n1_m1_388800_96000 0 6.177543e-07
I6527 n1_m1_388800_100800 0 5.579740e-07
I6528 n1_m1_388800_105600 0 3.734340e-07
I6529 n1_m1_388800_110400 0 3.948179e-07
I6530 n1_m1_388800_115200 0 2.691271e-07
I6531 n1_m1_388800_120000 0 6.420675e-07
I6532 n1_m1_388800_124800 0 1.916332e-07
I6533 n1_m1_388800_129600 0 3.772908e-07
I6534 n1_m1_388800_134400 0 3.623402e-07
I6535 n1_m1_388800_139200 0 2.170102e-07
I6536 n1_m1_388800_144000 0 6.806967e-07
I6537 n1_m1_388800_148800 0 2.631368e-07
I6538 n1_m1_388800_153600 0 6.158709e-07
I6539 n1_m1_388800_158400 0 3.112709e-07
I6540 n1_m1_388800_163200 0 2.754881e-07
I6541 n1_m1_388800_168000 0 4.712358e-07
I6542 n1_m1_388800_172800 0 2.452608e-07
I6543 n1_m1_388800_177600 0 4.580859e-07
I6544 n1_m1_388800_182400 0 2.526044e-07
I6545 n1_m1_388800_187200 0 4.740839e-07
I6546 n1_m1_388800_192000 0 3.756936e-07
I6547 n1_m1_388800_196800 0 3.410751e-07
I6548 n1_m1_388800_201600 0 6.387576e-07
I6549 n1_m1_388800_206400 0 2.131143e-07
I6550 n1_m1_388800_211200 0 2.054802e-07
I6551 n1_m1_388800_216000 0 6.091949e-07
I6552 n1_m1_388800_220800 0 1.834795e-07
I6553 n1_m1_388800_225600 0 1.101997e-06
I6554 n1_m1_388800_230400 0 8.912757e-07
I6555 n1_m1_388800_235200 0 2.867317e-07
I6556 n1_m1_388800_240000 0 3.879231e-07
I6557 n1_m1_388800_244800 0 3.724694e-07
I6558 n1_m1_388800_249600 0 2.331131e-06
I6559 n1_m1_388800_254400 0 1.010971e-06
I6560 n1_m1_388800_259200 0 2.427906e-07
I6561 n1_m1_388800_264000 0 4.514657e-07
I6562 n1_m1_388800_268800 0 3.510104e-07
I6563 n1_m1_388800_273600 0 1.270583e-06
I6564 n1_m1_388800_278400 0 2.519328e-06
I6565 n1_m1_388800_283200 0 7.305146e-07
I6566 n1_m1_388800_288000 0 9.802964e-07
I6567 n1_m1_388800_292800 0 6.610062e-07
I6568 n1_m1_388800_297600 0 1.202634e-06
I6569 n1_m1_388800_302400 0 4.182143e-07
I6570 n1_m1_388800_307200 0 3.573469e-07
I6571 n1_m1_388800_312000 0 3.557773e-07
I6572 n1_m1_388800_316800 0 5.838017e-07
I6573 n1_m1_388800_321600 0 3.052059e-07
I6574 n1_m1_388800_326400 0 6.205714e-08
I6575 n1_m1_388800_331200 0 4.274233e-07
I6576 n1_m1_388800_336000 0 3.640420e-07
I6577 n1_m1_388800_340800 0 3.173018e-07
I6578 n1_m1_388800_345600 0 5.347073e-07
I6579 n1_m1_388800_350400 0 3.040604e-07
I6580 n1_m1_388800_355200 0 6.455662e-07
I6581 n1_m1_388800_360000 0 3.176758e-07
I6582 n1_m1_388800_364800 0 6.071201e-07
I6583 n1_m1_388800_369600 0 3.996557e-07
I6584 n1_m1_388800_374400 0 7.284375e-08
I6585 n1_m1_388800_379200 0 3.627173e-07
I6586 n1_m1_388800_384000 0 5.875438e-07
I6587 n1_m1_388800_393600 0 2.080000e-08
I6588 n1_m1_393600_9600 0 2.920000e-07
I6589 n1_m1_393600_14400 0 6.097835e-07
I6590 n1_m1_393600_19200 0 2.785004e-07
I6591 n1_m1_393600_24000 0 4.382952e-07
I6592 n1_m1_393600_28800 0 4.236823e-07
I6593 n1_m1_393600_33600 0 3.279038e-07
I6594 n1_m1_393600_38400 0 3.863990e-07
I6595 n1_m1_393600_43200 0 3.094385e-07
I6596 n1_m1_393600_48000 0 4.315866e-07
I6597 n1_m1_393600_52800 0 4.825420e-07
I6598 n1_m1_393600_57600 0 4.671429e-07
I6599 n1_m1_393600_62400 0 5.647253e-07
I6600 n1_m1_393600_67200 0 6.628463e-07
I6601 n1_m1_393600_72000 0 6.637682e-07
I6602 n1_m1_393600_76800 0 4.144258e-07
I6603 n1_m1_393600_81600 0 4.124890e-07
I6604 n1_m1_393600_86400 0 3.966642e-07
I6605 n1_m1_393600_91200 0 3.655490e-07
I6606 n1_m1_393600_96000 0 4.212857e-07
I6607 n1_m1_393600_100800 0 2.841449e-07
I6608 n1_m1_393600_105600 0 4.910580e-07
I6609 n1_m1_393600_110400 0 3.838535e-07
I6610 n1_m1_393600_115200 0 4.370460e-07
I6611 n1_m1_393600_120000 0 9.860777e-07
I6612 n1_m1_393600_124800 0 5.906200e-07
I6613 n1_m1_393600_129600 0 6.636896e-07
I6614 n1_m1_393600_134400 0 4.793768e-07
I6615 n1_m1_393600_139200 0 1.851484e-07
I6616 n1_m1_393600_144000 0 6.686131e-07
I6617 n1_m1_393600_148800 0 3.107629e-07
I6618 n1_m1_393600_153600 0 5.726370e-07
I6619 n1_m1_393600_158400 0 2.596225e-07
I6620 n1_m1_393600_163200 0 3.771394e-07
I6621 n1_m1_393600_168000 0 6.239865e-07
I6622 n1_m1_393600_172800 0 2.272741e-07
I6623 n1_m1_393600_177600 0 7.910613e-07
I6624 n1_m1_393600_182400 0 2.301295e-07
I6625 n1_m1_393600_187200 0 3.809286e-07
I6626 n1_m1_393600_192000 0 5.425833e-07
I6627 n1_m1_393600_196800 0 2.505077e-07
I6628 n1_m1_393600_201600 0 7.565060e-07
I6629 n1_m1_393600_206400 0 2.472019e-07
I6630 n1_m1_393600_211200 0 4.188294e-07
I6631 n1_m1_393600_216000 0 8.110479e-07
I6632 n1_m1_393600_220800 0 2.325714e-07
I6633 n1_m1_393600_225600 0 6.376374e-07
I6634 n1_m1_393600_230400 0 2.697243e-07
I6635 n1_m1_393600_235200 0 5.486104e-07
I6636 n1_m1_393600_240000 0 5.023181e-07
I6637 n1_m1_393600_244800 0 4.184747e-07
I6638 n1_m1_393600_249600 0 2.373417e-06
I6639 n1_m1_393600_254400 0 1.181025e-06
I6640 n1_m1_393600_259200 0 4.323658e-07
I6641 n1_m1_393600_264000 0 4.944430e-07
I6642 n1_m1_393600_268800 0 5.443896e-07
I6643 n1_m1_393600_273600 0 1.946742e-06
I6644 n1_m1_393600_278400 0 3.692042e-06
I6645 n1_m1_393600_283200 0 4.667830e-07
I6646 n1_m1_393600_288000 0 6.401026e-07
I6647 n1_m1_393600_292800 0 8.461071e-07
I6648 n1_m1_393600_297600 0 1.465964e-06
I6649 n1_m1_393600_302400 0 3.774815e-07
I6650 n1_m1_393600_307200 0 5.844805e-07
I6651 n1_m1_393600_312000 0 5.633978e-07
I6652 n1_m1_393600_316800 0 3.643026e-07
I6653 n1_m1_393600_321600 0 5.927871e-07
I6654 n1_m1_393600_326400 0 1.751621e-07
I6655 n1_m1_393600_331200 0 4.710615e-07
I6656 n1_m1_393600_336000 0 4.864772e-07
I6657 n1_m1_393600_340800 0 5.304643e-07
I6658 n1_m1_393600_345600 0 6.353506e-07
I6659 n1_m1_393600_350400 0 3.613244e-07
I6660 n1_m1_393600_355200 0 4.031679e-07
I6661 n1_m1_393600_360000 0 3.098290e-07
I6662 n1_m1_393600_364800 0 4.845643e-07
I6663 n1_m1_393600_369600 0 3.710476e-07
I6664 n1_m1_393600_374400 0 6.235714e-09
I6665 n1_m1_393600_379200 0 7.414286e-08
I6666 n1_m1_393600_384000 0 9.885714e-08
I6667 n1_m1_398400_14400 0 2.047646e-07
I6668 n1_m1_398400_19200 0 2.571000e-07
I6669 n1_m1_398400_24000 0 3.541786e-07
I6670 n1_m1_398400_28800 0 2.842679e-07
I6671 n1_m1_398400_33600 0 5.037033e-07
I6672 n1_m1_398400_38400 0 4.054038e-07
I6673 n1_m1_398400_43200 0 1.768308e-07
I6674 n1_m1_398400_48000 0 3.606002e-07
I6675 n1_m1_398400_52800 0 3.645982e-07
I6676 n1_m1_398400_57600 0 4.297949e-07
I6677 n1_m1_398400_62400 0 4.383929e-07
I6678 n1_m1_398400_67200 0 1.628977e-07
I6679 n1_m1_398400_72000 0 5.034038e-07
I6680 n1_m1_398400_76800 0 2.605783e-07
I6681 n1_m1_398400_81600 0 4.070893e-07
I6682 n1_m1_398400_86400 0 3.834478e-07
I6683 n1_m1_398400_91200 0 3.428022e-07
I6684 n1_m1_398400_96000 0 3.830143e-07
I6685 n1_m1_398400_100800 0 2.915000e-07
I6686 n1_m1_398400_105600 0 4.033929e-07
I6687 n1_m1_398400_110400 0 3.294643e-07
I6688 n1_m1_398400_115200 0 3.614107e-07
I6689 n1_m1_398400_120000 0 3.339623e-07
I6690 n1_m1_398400_124800 0 3.567005e-07
I6691 n1_m1_398400_129600 0 3.621071e-07
I6692 n1_m1_398400_134400 0 2.740268e-07
I6693 n1_m1_398400_139200 0 3.755357e-07
I6694 n1_m1_398400_144000 0 5.183036e-07
I6695 n1_m1_398400_148800 0 1.649918e-07
I6696 n1_m1_398400_153600 0 5.459107e-07
I6697 n1_m1_398400_158400 0 2.556429e-07
I6698 n1_m1_398400_163200 0 3.107143e-07
I6699 n1_m1_398400_168000 0 4.285041e-07
I6700 n1_m1_398400_172800 0 2.223388e-07
I6701 n1_m1_398400_177600 0 4.891868e-07
I6702 n1_m1_398400_182400 0 3.202343e-07
I6703 n1_m1_398400_187200 0 2.517738e-07
I6704 n1_m1_398400_192000 0 4.541369e-07
I6705 n1_m1_398400_196800 0 1.946245e-07
I6706 n1_m1_398400_201600 0 4.670112e-07
I6707 n1_m1_398400_206400 0 1.734560e-07
I6708 n1_m1_398400_211200 0 4.268214e-07
I6709 n1_m1_398400_216000 0 5.762082e-07
I6710 n1_m1_398400_220800 0 2.827286e-07
I6711 n1_m1_398400_225600 0 3.982587e-07
I6712 n1_m1_398400_230400 0 2.161020e-07
I6713 n1_m1_398400_235200 0 3.373652e-07
I6714 n1_m1_398400_240000 0 3.658054e-07
I6715 n1_m1_398400_244800 0 1.792964e-07
I6716 n1_m1_398400_249600 0 1.727359e-06
I6717 n1_m1_398400_254400 0 7.642991e-07
I6718 n1_m1_398400_259200 0 1.614464e-07
I6719 n1_m1_398400_264000 0 5.024563e-07
I6720 n1_m1_398400_268800 0 3.577704e-07
I6721 n1_m1_398400_273600 0 4.108130e-07
I6722 n1_m1_398400_278400 0 4.032143e-07
I6723 n1_m1_398400_283200 0 3.914107e-07
I6724 n1_m1_398400_288000 0 2.862429e-07
I6725 n1_m1_398400_292800 0 2.699107e-07
I6726 n1_m1_398400_297600 0 1.011853e-06
I6727 n1_m1_398400_302400 0 1.101226e-06
I6728 n1_m1_398400_307200 0 3.067267e-07
I6729 n1_m1_398400_312000 0 3.942857e-07
I6730 n1_m1_398400_316800 0 1.773607e-07
I6731 n1_m1_398400_321600 0 4.362054e-07
I6732 n1_m1_398400_326400 0 6.428571e-08
I6733 n1_m1_398400_331200 0 3.403214e-07
I6734 n1_m1_398400_336000 0 4.321250e-07
I6735 n1_m1_398400_340800 0 3.315000e-07
I6736 n1_m1_398400_345600 0 2.510755e-07
I6737 n1_m1_398400_350400 0 3.947321e-07
I6738 n1_m1_398400_355200 0 4.361786e-07
I6739 n1_m1_398400_360000 0 1.810893e-07
I6740 n1_m1_398400_364800 0 3.580179e-07
I6741 n1_m1_398400_369600 0 1.633571e-07
I6742 n1_m1_398400_379200 0 2.710000e-07
I6743 n1_m1_32000_9600 0 6.160000e-08
I6744 n1_m1_32000_14400 0 2.715969e-07
I6745 n1_m1_32000_19200 0 2.451352e-07
I6746 n1_m1_32000_24000 0 3.632143e-07
I6747 n1_m1_32000_28800 0 2.898622e-07
I6748 n1_m1_32000_33600 0 2.103377e-07
I6749 n1_m1_32000_38400 0 1.847009e-07
I6750 n1_m1_32000_43200 0 2.545512e-07
I6751 n1_m1_32000_48000 0 1.634144e-07
I6752 n1_m1_32000_52800 0 1.103339e-07
I6753 n1_m1_32000_57600 0 3.791385e-06
I6754 n1_m1_32000_62400 0 1.426786e-08
I6755 n1_m1_32000_67200 0 1.052009e-07
I6756 n1_m1_32000_72000 0 4.746859e-07
I6757 n1_m1_32000_76800 0 2.431058e-07
I6758 n1_m1_32000_81600 0 1.405067e-07
I6759 n1_m1_32000_86400 0 1.171202e-07
I6760 n1_m1_32000_91200 0 2.064495e-07
I6761 n1_m1_32000_96000 0 2.097107e-07
I6762 n1_m1_32000_100800 0 1.691857e-07
I6763 n1_m1_32000_105600 0 2.395065e-07
I6764 n1_m1_32000_110400 0 5.800000e-08
I6765 n1_m1_32000_115200 0 3.408174e-07
I6766 n1_m1_32000_120000 0 1.833116e-07
I6767 n1_m1_32000_124800 0 2.418554e-07
I6768 n1_m1_32000_129600 0 4.303520e-07
I6769 n1_m1_32000_134400 0 7.920918e-08
I6770 n1_m1_32000_139200 0 3.409497e-07
I6771 n1_m1_32000_144000 0 1.155227e-07
I6772 n1_m1_32000_148800 0 3.106061e-07
I6773 n1_m1_32000_153600 0 2.330237e-07
I6774 n1_m1_32000_158400 0 9.736156e-08
I6775 n1_m1_32000_163200 0 1.258406e-07
I6776 n1_m1_32000_168000 0 8.097308e-07
I6777 n1_m1_32000_172800 0 2.281126e-07
I6778 n1_m1_32000_177600 0 2.071161e-07
I6779 n1_m1_32000_182400 0 1.256758e-07
I6780 n1_m1_32000_187200 0 4.757187e-06
I6781 n1_m1_32000_192000 0 9.640984e-07
I6782 n1_m1_32000_196800 0 1.397916e-07
I6783 n1_m1_32000_201600 0 2.979945e-08
I6784 n1_m1_32000_206400 0 5.203720e-08
I6785 n1_m1_32000_211200 0 1.704063e-07
I6786 n1_m1_32000_216000 0 1.383550e-07
I6787 n1_m1_32000_220800 0 3.512662e-07
I6788 n1_m1_32000_225600 0 2.384607e-07
I6789 n1_m1_32000_230400 0 1.923481e-07
I6790 n1_m1_32000_235200 0 3.423417e-07
I6791 n1_m1_32000_240000 0 2.321680e-07
I6792 n1_m1_32000_244800 0 3.941006e-07
I6793 n1_m1_32000_249600 0 2.480735e-07
I6794 n1_m1_32000_254400 0 2.831339e-07
I6795 n1_m1_32000_259200 0 2.510701e-07
I6796 n1_m1_32000_264000 0 3.885149e-07
I6797 n1_m1_32000_268800 0 2.136082e-07
I6798 n1_m1_32000_273600 0 5.180143e-06
I6799 n1_m1_32000_278400 0 3.066964e-07
I6800 n1_m1_32000_283200 0 3.223544e-07
I6801 n1_m1_32000_288000 0 1.535360e-07
I6802 n1_m1_32000_292800 0 3.495062e-07
I6803 n1_m1_32000_297600 0 1.221250e-07
I6804 n1_m1_32000_302400 0 1.281884e-07
I6805 n1_m1_32000_307200 0 1.335156e-07
I6806 n1_m1_32000_312000 0 2.061853e-07
I6807 n1_m1_32000_316800 0 2.519853e-07
I6808 n1_m1_32000_321600 0 2.571985e-07
I6809 n1_m1_32000_326400 0 2.533929e-07
I6810 n1_m1_32000_331200 0 2.679396e-08
I6811 n1_m1_32000_336000 0 1.216099e-07
I6812 n1_m1_32000_340800 0 7.070612e-08
I6813 n1_m1_32000_345600 0 5.581127e-06
I6814 n1_m1_32000_350400 0 1.369036e-07
I6815 n1_m1_32000_355200 0 5.707143e-07
I6816 n1_m1_32000_360000 0 1.883418e-07
I6817 n1_m1_32000_364800 0 1.263290e-07
I6818 n1_m1_32000_369600 0 1.974264e-07
I6819 n1_m1_32000_374400 0 1.148029e-07
I6820 n1_m1_32000_379200 0 1.491438e-07
I6821 n1_m1_32000_384000 0 3.488892e-07
I6822 n1_m1_32000_388800 0 1.018681e-08
I6823 n1_m1_32000_393600 0 7.518750e-08
I6824 n1_m1_60000_4800 0 9.443787e-08
I6825 n1_m1_60000_9600 0 3.891198e-07
I6826 n1_m1_60000_14400 0 2.298036e-07
I6827 n1_m1_60000_19200 0 3.280102e-07
I6828 n1_m1_60000_24000 0 1.245755e-07
I6829 n1_m1_60000_28800 0 3.010561e-07
I6830 n1_m1_60000_33600 0 6.076331e-06
I6831 n1_m1_60000_38400 0 1.828462e-07
I6832 n1_m1_60000_43200 0 1.321154e-08
I6833 n1_m1_60000_48000 0 2.088464e-07
I6834 n1_m1_60000_52800 0 4.768831e-08
I6835 n1_m1_60000_57600 0 4.604021e-07
I6836 n1_m1_60000_62400 0 3.071916e-07
I6837 n1_m1_60000_67200 0 1.205958e-07
I6838 n1_m1_60000_72000 0 3.935577e-07
I6839 n1_m1_60000_76800 0 2.863015e-07
I6840 n1_m1_60000_81600 0 5.066638e-07
I6841 n1_m1_60000_86400 0 1.837418e-07
I6842 n1_m1_60000_91200 0 1.639286e-07
I6843 n1_m1_60000_96000 0 4.694059e-07
I6844 n1_m1_60000_100800 0 3.503468e-08
I6845 n1_m1_60000_105600 0 1.812302e-07
I6846 n1_m1_60000_110400 0 3.705087e-07
I6847 n1_m1_60000_115200 0 1.777816e-07
I6848 n1_m1_60000_120000 0 3.790020e-07
I6849 n1_m1_60000_124800 0 2.424052e-07
I6850 n1_m1_60000_129600 0 2.882679e-07
I6851 n1_m1_60000_134400 0 3.326518e-07
I6852 n1_m1_60000_139200 0 1.862500e-07
I6853 n1_m1_60000_144000 0 3.197163e-07
I6854 n1_m1_60000_148800 0 3.329156e-07
I6855 n1_m1_60000_153600 0 3.352613e-07
I6856 n1_m1_60000_158400 0 3.375536e-07
I6857 n1_m1_60000_163200 0 3.868601e-07
I6858 n1_m1_60000_168000 0 3.507619e-07
I6859 n1_m1_60000_172800 0 3.159107e-07
I6860 n1_m1_60000_177600 0 4.182933e-07
I6861 n1_m1_60000_182400 0 2.538933e-07
I6862 n1_m1_60000_187200 0 6.421369e-07
I6863 n1_m1_60000_192000 0 4.400794e-07
I6864 n1_m1_60000_196800 0 3.909375e-07
I6865 n1_m1_60000_201600 0 2.563511e-07
I6866 n1_m1_60000_206400 0 2.054429e-07
I6867 n1_m1_60000_211200 0 5.277438e-07
I6868 n1_m1_60000_216000 0 2.318495e-07
I6869 n1_m1_60000_220800 0 3.156920e-07
I6870 n1_m1_60000_225600 0 5.358333e-08
I6871 n1_m1_60000_230400 0 8.272208e-08
I6872 n1_m1_60000_235200 0 1.918900e-07
I6873 n1_m1_60000_240000 0 8.784026e-08
I6874 n1_m1_60000_244800 0 7.431429e-08
I6875 n1_m1_60000_249600 0 1.181633e-07
I6876 n1_m1_60000_254400 0 9.873852e-08
I6877 n1_m1_60000_259200 0 2.525400e-07
I6878 n1_m1_60000_264000 0 1.174508e-07
I6879 n1_m1_60000_268800 0 1.456981e-07
I6880 n1_m1_60000_273600 0 2.415000e-07
I6881 n1_m1_60000_278400 0 3.536016e-06
I6882 n1_m1_60000_283200 0 1.697437e-06
I6883 n1_m1_60000_288000 0 4.257321e-07
I6884 n1_m1_60000_292800 0 3.021978e-08
I6885 n1_m1_60000_297600 0 4.513274e-07
I6886 n1_m1_60000_302400 0 2.265560e-07
I6887 n1_m1_60000_307200 0 8.285374e-08
I6888 n1_m1_60000_312000 0 2.233293e-07
I6889 n1_m1_60000_316800 0 3.340276e-07
I6890 n1_m1_60000_321600 0 2.241010e-07
I6891 n1_m1_60000_326400 0 1.324286e-07
I6892 n1_m1_60000_331200 0 2.924464e-07
I6893 n1_m1_60000_336000 0 2.495900e-07
I6894 n1_m1_60000_340800 0 2.956929e-07
I6895 n1_m1_60000_345600 0 3.863070e-07
I6896 n1_m1_60000_350400 0 1.701176e-07
I6897 n1_m1_60000_355200 0 3.605378e-07
I6898 n1_m1_60000_360000 0 1.937706e-07
I6899 n1_m1_60000_364800 0 3.580804e-07
I6900 n1_m1_60000_369600 0 3.824588e-07
I6901 n1_m1_60000_374400 0 3.467059e-07
I6902 n1_m1_60000_379200 0 7.643984e-08
I6903 n1_m1_60000_384000 0 3.499982e-07
I6904 n1_m1_60000_388800 0 1.604784e-07
I6905 n1_m1_60000_393600 0 1.198485e-07
I6906 n1_m1_88000_4800 0 9.876923e-08
I6907 n1_m1_88000_9600 0 3.177308e-07
I6908 n1_m1_88000_14400 0 1.580000e-07
I6909 n1_m1_88000_19200 0 4.408929e-08
I6910 n1_m1_88000_24000 0 1.100982e-07
I6911 n1_m1_88000_28800 0 1.115625e-07
I6912 n1_m1_88000_33600 0 4.856696e-07
I6913 n1_m1_88000_38400 0 3.261607e-07
I6914 n1_m1_88000_43200 0 2.985865e-07
I6915 n1_m1_88000_48000 0 2.255711e-07
I6916 n1_m1_88000_52800 0 1.109091e-07
I6917 n1_m1_88000_57600 0 3.832547e-07
I6918 n1_m1_88000_62400 0 4.861607e-07
I6919 n1_m1_88000_67200 0 4.457576e-07
I6920 n1_m1_88000_72000 0 9.975470e-08
I6921 n1_m1_88000_76800 0 4.649822e-07
I6922 n1_m1_88000_81600 0 4.507468e-07
I6923 n1_m1_88000_86400 0 3.848970e-07
I6924 n1_m1_88000_91200 0 7.128159e-08
I6925 n1_m1_88000_96000 0 4.072857e-07
I6926 n1_m1_88000_100800 0 4.057778e-07
I6927 n1_m1_88000_105600 0 1.041524e-07
I6928 n1_m1_88000_110400 0 1.073397e-07
I6929 n1_m1_88000_115200 0 1.359835e-07
I6930 n1_m1_88000_120000 0 3.059429e-07
I6931 n1_m1_88000_124800 0 7.257143e-07
I6932 n1_m1_88000_129600 0 3.018182e-07
I6933 n1_m1_88000_134400 0 1.952604e-07
I6934 n1_m1_88000_139200 0 6.875510e-08
I6935 n1_m1_88000_144000 0 2.106143e-07
I6936 n1_m1_88000_148800 0 1.227071e-07
I6937 n1_m1_88000_153600 0 4.062357e-07
I6938 n1_m1_88000_158400 0 3.807619e-08
I6939 n1_m1_88000_163200 0 4.325000e-08
I6940 n1_m1_88000_168000 0 3.771464e-07
I6941 n1_m1_88000_172800 0 1.262000e-07
I6942 n1_m1_88000_177600 0 2.501857e-08
I6943 n1_m1_88000_182400 0 2.360000e-07
I6944 n1_m1_88000_192000 0 4.127500e-07
I6945 n1_m1_88000_196800 0 1.266234e-07
I6946 n1_m1_88000_201600 0 5.221883e-07
I6947 n1_m1_88000_206400 0 1.901429e-07
I6948 n1_m1_88000_211200 0 3.217670e-07
I6949 n1_m1_88000_216000 0 7.628491e-07
I6950 n1_m1_88000_220800 0 2.400446e-07
I6951 n1_m1_88000_225600 0 2.891680e-07
I6952 n1_m1_88000_230400 0 3.899107e-07
I6953 n1_m1_88000_235200 0 3.880804e-07
I6954 n1_m1_88000_240000 0 1.059227e-07
I6955 n1_m1_88000_244800 0 9.498214e-08
I6956 n1_m1_88000_249600 0 1.971024e-07
I6957 n1_m1_88000_254400 0 3.720429e-07
I6958 n1_m1_88000_259200 0 7.158857e-07
I6959 n1_m1_88000_264000 0 2.444000e-07
I6960 n1_m1_88000_268800 0 4.963631e-07
I6961 n1_m1_88000_273600 0 2.225824e-07
I6962 n1_m1_88000_278400 0 7.967033e-08
I6963 n1_m1_88000_283200 0 2.968750e-07
I6964 n1_m1_88000_288000 0 3.476896e-07
I6965 n1_m1_88000_292800 0 3.772321e-07
I6966 n1_m1_88000_297600 0 5.867607e-07
I6967 n1_m1_88000_302400 0 1.920879e-07
I6968 n1_m1_88000_307200 0 1.084524e-07
I6969 n1_m1_88000_312000 0 4.369264e-07
I6970 n1_m1_88000_316800 0 9.496537e-08
I6971 n1_m1_88000_321600 0 2.152304e-07
I6972 n1_m1_88000_326400 0 3.038827e-07
I6973 n1_m1_88000_331200 0 4.592449e-08
I6974 n1_m1_88000_336000 0 4.223912e-07
I6975 n1_m1_88000_340800 0 1.970216e-07
I6976 n1_m1_88000_345600 0 5.579050e-07
I6977 n1_m1_88000_350400 0 2.886940e-07
I6978 n1_m1_88000_355200 0 2.076132e-06
I6979 n1_m1_88000_360000 0 9.069677e-07
I6980 n1_m1_88000_364800 0 1.460000e-07
I6981 n1_m1_88000_369600 0 1.643644e-07
I6982 n1_m1_88000_374400 0 3.362771e-07
I6983 n1_m1_88000_384000 0 3.840314e-07
I6984 n1_m1_88000_388800 0 1.797768e-07
I6985 n1_m1_88000_393600 0 8.120000e-08
I6986 n1_m1_116000_4800 0 1.706769e-07
I6987 n1_m1_116000_9600 0 4.671981e-07
I6988 n1_m1_116000_14400 0 5.566883e-07
I6989 n1_m1_116000_19200 0 4.740844e-07
I6990 n1_m1_116000_24000 0 6.015107e-07
I6991 n1_m1_116000_28800 0 2.343750e-07
I6992 n1_m1_116000_33600 0 6.877411e-07
I6993 n1_m1_116000_38400 0 5.677532e-07
I6994 n1_m1_116000_43200 0 3.634937e-07
I6995 n1_m1_116000_48000 0 6.160362e-07
I6996 n1_m1_116000_52800 0 2.435132e-07
I6997 n1_m1_116000_57600 0 5.388304e-07
I6998 n1_m1_116000_62400 0 1.886286e-07
I6999 n1_m1_116000_67200 0 2.253286e-07
I7000 n1_m1_116000_72000 0 7.550978e-07
I7001 n1_m1_116000_81600 0 4.845060e-07
I7002 n1_m1_116000_86400 0 4.641357e-07
I7003 n1_m1_116000_91200 0 6.612571e-07
I7004 n1_m1_116000_96000 0 7.670571e-07
I7005 n1_m1_116000_100800 0 4.597429e-07
I7006 n1_m1_116000_105600 0 2.992857e-07
I7007 n1_m1_116000_110400 0 1.310000e-07
I7008 n1_m1_116000_115200 0 1.715429e-07
I7009 n1_m1_116000_120000 0 4.216984e-07
I7010 n1_m1_116000_124800 0 7.578175e-07
I7011 n1_m1_116000_129600 0 2.114286e-08
I7012 n1_m1_116000_134400 0 1.737024e-07
I7013 n1_m1_116000_139200 0 5.539177e-07
I7014 n1_m1_116000_144000 0 2.780338e-07
I7015 n1_m1_116000_148800 0 1.845429e-07
I7016 n1_m1_116000_153600 0 7.810602e-07
I7017 n1_m1_116000_158400 0 3.861088e-07
I7018 n1_m1_116000_163200 0 4.934357e-07
I7019 n1_m1_116000_168000 0 3.661429e-07
I7020 n1_m1_116000_172800 0 3.787143e-07
I7021 n1_m1_116000_177600 0 6.523750e-07
I7022 n1_m1_116000_182400 0 2.254330e-07
I7023 n1_m1_116000_187200 0 4.269827e-07
I7024 n1_m1_116000_192000 0 7.713065e-07
I7025 n1_m1_116000_196800 0 4.949121e-07
I7026 n1_m1_116000_201600 0 5.997459e-07
I7027 n1_m1_116000_206400 0 6.633661e-07
I7028 n1_m1_116000_211200 0 3.522500e-07
I7029 n1_m1_116000_216000 0 2.664571e-07
I7030 n1_m1_116000_220800 0 1.270762e-07
I7031 n1_m1_116000_225600 0 7.051286e-07
I7032 n1_m1_116000_230400 0 1.922000e-07
I7033 n1_m1_116000_235200 0 2.368214e-07
I7034 n1_m1_116000_240000 0 1.145786e-06
I7035 n1_m1_116000_244800 0 5.148941e-07
I7036 n1_m1_116000_249600 0 6.110357e-07
I7037 n1_m1_116000_254400 0 3.056810e-07
I7038 n1_m1_116000_259200 0 2.489429e-07
I7039 n1_m1_116000_264000 0 6.088857e-07
I7040 n1_m1_116000_268800 0 4.950143e-07
I7041 n1_m1_116000_273600 0 1.080095e-07
I7042 n1_m1_116000_278400 0 3.553095e-07
I7043 n1_m1_116000_283200 0 1.561524e-07
I7044 n1_m1_116000_288000 0 8.426989e-07
I7045 n1_m1_116000_292800 0 1.328187e-07
I7046 n1_m1_116000_297600 0 6.583359e-07
I7047 n1_m1_116000_302400 0 5.519251e-07
I7048 n1_m1_116000_307200 0 5.006548e-07
I7049 n1_m1_116000_312000 0 9.046474e-07
I7050 n1_m1_116000_316800 0 1.783841e-07
I7051 n1_m1_116000_321600 0 8.678788e-07
I7052 n1_m1_116000_326400 0 3.672105e-07
I7053 n1_m1_116000_331200 0 4.193348e-07
I7054 n1_m1_116000_336000 0 6.667429e-07
I7055 n1_m1_116000_340800 0 1.840762e-07
I7056 n1_m1_116000_345600 0 4.177297e-07
I7057 n1_m1_116000_350400 0 3.645571e-07
I7058 n1_m1_116000_355200 0 9.049929e-07
I7059 n1_m1_116000_360000 0 7.717067e-07
I7060 n1_m1_116000_364800 0 3.070536e-07
I7061 n1_m1_116000_369600 0 8.775606e-07
I7062 n1_m1_116000_374400 0 1.035232e-07
I7063 n1_m1_116000_379200 0 6.511071e-07
I7064 n1_m1_116000_384000 0 4.540714e-07
I7065 n1_m1_116000_388800 0 6.171429e-08
I7066 n1_m1_116000_393600 0 8.686633e-07
I7067 n1_m1_116000_398400 0 1.504176e-07
I7068 n1_m1_172000_4800 0 1.015385e-07
I7069 n1_m1_172000_9600 0 2.518782e-07
I7070 n1_m1_172000_14400 0 8.533333e-08
I7071 n1_m1_172000_19200 0 2.531868e-08
I7072 n1_m1_172000_24000 0 4.335683e-07
I7073 n1_m1_172000_33600 0 4.515625e-07
I7074 n1_m1_172000_38400 0 1.665096e-07
I7075 n1_m1_172000_48000 0 4.332500e-07
I7076 n1_m1_172000_52800 0 1.771000e-07
I7077 n1_m1_172000_57600 0 3.766158e-07
I7078 n1_m1_172000_62400 0 2.556172e-07
I7079 n1_m1_172000_67200 0 5.733736e-07
I7080 n1_m1_172000_72000 0 2.501209e-07
I7081 n1_m1_172000_76800 0 1.918755e-07
I7082 n1_m1_172000_81600 0 2.620286e-07
I7083 n1_m1_172000_86400 0 2.265939e-07
I7084 n1_m1_172000_91200 0 1.108885e-07
I7085 n1_m1_172000_96000 0 1.239893e-07
I7086 n1_m1_172000_100800 0 1.084210e-07
I7087 n1_m1_172000_105600 0 3.679084e-07
I7088 n1_m1_172000_110400 0 4.066369e-07
I7089 n1_m1_172000_115200 0 9.504762e-08
I7090 n1_m1_172000_120000 0 2.276714e-07
I7091 n1_m1_172000_124800 0 2.612857e-07
I7092 n1_m1_172000_129600 0 5.022762e-07
I7093 n1_m1_172000_134400 0 7.561270e-08
I7094 n1_m1_172000_139200 0 4.650000e-08
I7095 n1_m1_172000_144000 0 3.894571e-07
I7096 n1_m1_172000_148800 0 1.150429e-07
I7097 n1_m1_172000_153600 0 2.877551e-09
I7098 n1_m1_172000_158400 0 6.383673e-08
I7099 n1_m1_172000_163200 0 4.800714e-08
I7100 n1_m1_172000_168000 0 2.505071e-07
I7101 n1_m1_172000_172800 0 2.801143e-07
I7102 n1_m1_172000_177600 0 4.628571e-08
I7103 n1_m1_172000_182400 0 3.342857e-08
I7104 n1_m1_172000_187200 0 4.457143e-08
I7105 n1_m1_172000_192000 0 1.120000e-07
I7106 n1_m1_172000_196800 0 3.392000e-07
I7107 n1_m1_172000_201600 0 3.662857e-08
I7108 n1_m1_172000_206400 0 6.157143e-08
I7109 n1_m1_172000_211200 0 1.531857e-07
I7110 n1_m1_172000_216000 0 1.104476e-07
I7111 n1_m1_172000_220800 0 3.027778e-07
I7112 n1_m1_172000_225600 0 1.600000e-07
I7113 n1_m1_172000_230400 0 9.000000e-08
I7114 n1_m1_172000_240000 0 3.663081e-07
I7115 n1_m1_172000_244800 0 3.940233e-07
I7116 n1_m1_172000_249600 0 3.284416e-07
I7117 n1_m1_172000_254400 0 1.635000e-07
I7118 n1_m1_172000_259200 0 4.839048e-07
I7119 n1_m1_172000_264000 0 2.945143e-07
I7120 n1_m1_172000_268800 0 1.892000e-07
I7121 n1_m1_172000_273600 0 4.883270e-07
I7122 n1_m1_172000_278400 0 2.124603e-07
I7123 n1_m1_172000_283200 0 3.734107e-07
I7124 n1_m1_172000_288000 0 9.124821e-07
I7125 n1_m1_172000_292800 0 3.745333e-07
I7126 n1_m1_172000_297600 0 9.772831e-08
I7127 n1_m1_172000_302400 0 7.186147e-08
I7128 n1_m1_172000_307200 0 2.195438e-07
I7129 n1_m1_172000_312000 0 1.595604e-08
I7130 n1_m1_172000_316800 0 1.852500e-07
I7131 n1_m1_172000_321600 0 2.656607e-07
I7132 n1_m1_172000_326400 0 3.276571e-07
I7133 n1_m1_172000_331200 0 3.960143e-07
I7134 n1_m1_172000_336000 0 2.024214e-07
I7135 n1_m1_172000_340800 0 1.040286e-07
I7136 n1_m1_172000_345600 0 9.430200e-07
I7137 n1_m1_172000_350400 0 5.724133e-07
I7138 n1_m1_172000_355200 0 7.670748e-07
I7139 n1_m1_172000_360000 0 4.602679e-07
I7140 n1_m1_172000_364800 0 2.739827e-07
I7141 n1_m1_172000_369600 0 2.648214e-07
I7142 n1_m1_172000_374400 0 3.385089e-07
I7143 n1_m1_172000_379200 0 2.799167e-07
I7144 n1_m1_172000_384000 0 4.610460e-07
I7145 n1_m1_172000_388800 0 1.898095e-07
I7146 n1_m1_172000_393600 0 4.975971e-07
I7147 n1_m1_172000_398400 0 6.791209e-08
I7148 n1_m1_200000_4800 0 2.234965e-07
I7149 n1_m1_200000_9600 0 2.251204e-07
I7150 n1_m1_200000_14400 0 2.250893e-07
I7151 n1_m1_200000_19200 0 3.466071e-07
I7152 n1_m1_200000_24000 0 3.779399e-07
I7153 n1_m1_200000_28800 0 2.666369e-07
I7154 n1_m1_200000_33600 0 4.829320e-07
I7155 n1_m1_200000_38400 0 3.249519e-07
I7156 n1_m1_200000_43200 0 3.011205e-07
I7157 n1_m1_200000_48000 0 8.449381e-08
I7158 n1_m1_200000_52800 0 5.927273e-08
I7159 n1_m1_200000_57600 0 6.877153e-07
I7160 n1_m1_200000_62400 0 3.021193e-08
I7161 n1_m1_200000_67200 0 1.229272e-07
I7162 n1_m1_200000_72000 0 2.891587e-07
I7163 n1_m1_200000_76800 0 1.897030e-07
I7164 n1_m1_200000_81600 0 5.551339e-08
I7165 n1_m1_200000_86400 0 1.874829e-07
I7166 n1_m1_200000_91200 0 2.621078e-07
I7167 n1_m1_200000_96000 0 1.721121e-07
I7168 n1_m1_200000_100800 0 6.469039e-08
I7169 n1_m1_200000_105600 0 2.701558e-07
I7170 n1_m1_200000_110400 0 2.892857e-08
I7171 n1_m1_200000_115200 0 1.296875e-07
I7172 n1_m1_200000_120000 0 4.086857e-07
I7173 n1_m1_200000_124800 0 4.961905e-08
I7174 n1_m1_200000_129600 0 3.634881e-07
I7175 n1_m1_200000_134400 0 2.505603e-07
I7176 n1_m1_200000_139200 0 2.838690e-07
I7177 n1_m1_200000_144000 0 1.650429e-07
I7178 n1_m1_200000_148800 0 2.042976e-07
I7179 n1_m1_200000_153600 0 5.659929e-08
I7180 n1_m1_200000_158400 0 6.382082e-08
I7181 n1_m1_200000_163200 0 2.729966e-08
I7182 n1_m1_200000_168000 0 1.387632e-07
I7183 n1_m1_200000_172800 0 1.352686e-07
I7184 n1_m1_200000_177600 0 4.370238e-08
I7185 n1_m1_200000_182400 0 9.833095e-08
I7186 n1_m1_200000_187200 0 1.343429e-07
I7187 n1_m1_200000_192000 0 1.218393e-07
I7188 n1_m1_200000_196800 0 2.613750e-07
I7189 n1_m1_200000_201600 0 2.002476e-07
I7190 n1_m1_200000_206400 0 6.231071e-08
I7191 n1_m1_200000_211200 0 1.250000e-07
I7192 n1_m1_200000_216000 0 2.747143e-07
I7193 n1_m1_200000_220800 0 1.510357e-07
I7194 n1_m1_200000_225600 0 2.983393e-07
I7195 n1_m1_200000_230400 0 2.200714e-07
I7196 n1_m1_200000_235200 0 2.094143e-07
I7197 n1_m1_200000_240000 0 5.437308e-07
I7198 n1_m1_200000_244800 0 8.477237e-08
I7199 n1_m1_200000_249600 0 3.602948e-07
I7200 n1_m1_200000_254400 0 9.920167e-08
I7201 n1_m1_200000_259200 0 1.737633e-07
I7202 n1_m1_200000_264000 0 4.155500e-07
I7203 n1_m1_200000_268800 0 1.002857e-07
I7204 n1_m1_200000_273600 0 1.087971e-07
I7205 n1_m1_200000_278400 0 2.505635e-07
I7206 n1_m1_200000_283200 0 3.165873e-07
I7207 n1_m1_200000_288000 0 8.709567e-07
I7208 n1_m1_200000_292800 0 1.100000e-07
I7209 n1_m1_200000_297600 0 1.411740e-07
I7210 n1_m1_200000_302400 0 2.331295e-07
I7211 n1_m1_200000_307200 0 1.300000e-07
I7212 n1_m1_200000_312000 0 4.681473e-07
I7213 n1_m1_200000_316800 0 5.443750e-08
I7214 n1_m1_200000_321600 0 1.628571e-07
I7215 n1_m1_200000_326400 0 1.316883e-07
I7216 n1_m1_200000_331200 0 2.083203e-07
I7217 n1_m1_200000_336000 0 2.303992e-07
I7218 n1_m1_200000_340800 0 1.010683e-07
I7219 n1_m1_200000_345600 0 1.101586e-07
I7220 n1_m1_200000_350400 0 3.397857e-07
I7221 n1_m1_200000_355200 0 3.080229e-07
I7222 n1_m1_200000_360000 0 4.650514e-07
I7223 n1_m1_200000_364800 0 1.258047e-07
I7224 n1_m1_200000_369600 0 2.742890e-07
I7225 n1_m1_200000_374400 0 2.967823e-07
I7226 n1_m1_200000_379200 0 1.880286e-07
I7227 n1_m1_200000_384000 0 3.530909e-07
I7228 n1_m1_200000_388800 0 2.790357e-07
I7229 n1_m1_200000_393600 0 3.966315e-07
I7230 n1_m1_200000_398400 0 6.926374e-08
I7231 n1_m1_228000_4800 0 2.079441e-07
I7232 n1_m1_228000_9600 0 3.378287e-07
I7233 n1_m1_228000_14400 0 2.519286e-07
I7234 n1_m1_228000_19200 0 1.675893e-07
I7235 n1_m1_228000_24000 0 1.840696e-07
I7236 n1_m1_228000_28800 0 1.443807e-06
I7237 n1_m1_228000_33600 0 1.878519e-06
I7238 n1_m1_228000_38400 0 3.199399e-07
I7239 n1_m1_228000_43200 0 8.840000e-08
I7240 n1_m1_228000_48000 0 2.006743e-07
I7241 n1_m1_228000_52800 0 2.272500e-07
I7242 n1_m1_228000_57600 0 2.756453e-07
I7243 n1_m1_228000_62400 0 2.220536e-07
I7244 n1_m1_228000_67200 0 5.658333e-08
I7245 n1_m1_228000_72000 0 3.846932e-07
I7246 n1_m1_228000_76800 0 2.233442e-06
I7247 n1_m1_228000_81600 0 1.873482e-06
I7248 n1_m1_228000_86400 0 2.109313e-07
I7249 n1_m1_228000_91200 0 6.914286e-08
I7250 n1_m1_228000_96000 0 2.797199e-07
I7251 n1_m1_228000_100800 0 1.050551e-07
I7252 n1_m1_228000_105600 0 2.316930e-07
I7253 n1_m1_228000_110400 0 2.005824e-07
I7254 n1_m1_228000_115200 0 2.130714e-08
I7255 n1_m1_228000_120000 0 3.061310e-07
I7256 n1_m1_228000_124800 0 4.717857e-07
I7257 n1_m1_228000_129600 0 4.258621e-06
I7258 n1_m1_228000_134400 0 1.132341e-07
I7259 n1_m1_228000_139200 0 3.899408e-07
I7260 n1_m1_228000_144000 0 3.677714e-07
I7261 n1_m1_228000_148800 0 3.261633e-08
I7262 n1_m1_228000_153600 0 4.061980e-07
I7263 n1_m1_228000_158400 0 1.004724e-07
I7264 n1_m1_228000_163200 0 1.153049e-07
I7265 n1_m1_228000_168000 0 1.891943e-07
I7266 n1_m1_228000_172800 0 7.770494e-08
I7267 n1_m1_228000_177600 0 1.232065e-07
I7268 n1_m1_228000_182400 0 3.461543e-07
I7269 n1_m1_228000_187200 0 5.458857e-07
I7270 n1_m1_228000_192000 0 6.249667e-07
I7271 n1_m1_228000_196800 0 1.326264e-07
I7272 n1_m1_228000_201600 0 4.709374e-07
I7273 n1_m1_228000_206400 0 1.963929e-07
I7274 n1_m1_228000_211200 0 2.849299e-07
I7275 n1_m1_228000_216000 0 4.411339e-07
I7276 n1_m1_228000_220800 0 1.929890e-07
I7277 n1_m1_228000_225600 0 2.736800e-07
I7278 n1_m1_228000_230400 0 2.275325e-07
I7279 n1_m1_228000_240000 0 7.919196e-08
I7280 n1_m1_228000_244800 0 2.413393e-07
I7281 n1_m1_228000_249600 0 4.321633e-07
I7282 n1_m1_228000_254400 0 7.323673e-08
I7283 n1_m1_228000_259200 0 1.880286e-07
I7284 n1_m1_228000_264000 0 5.816159e-07
I7285 n1_m1_228000_268800 0 3.455230e-07
I7286 n1_m1_228000_273600 0 5.402762e-07
I7287 n1_m1_228000_278400 0 6.369048e-08
I7288 n1_m1_228000_283200 0 3.251339e-07
I7289 n1_m1_228000_288000 0 3.010536e-07
I7290 n1_m1_228000_292800 0 1.852679e-08
I7291 n1_m1_228000_297600 0 1.469107e-07
I7292 n1_m1_228000_302400 0 3.744821e-07
I7293 n1_m1_228000_307200 0 2.358737e-07
I7294 n1_m1_228000_312000 0 4.001671e-07
I7295 n1_m1_228000_316800 0 3.515128e-07
I7296 n1_m1_228000_321600 0 2.503942e-07
I7297 n1_m1_228000_326400 0 2.346429e-07
I7298 n1_m1_228000_331200 0 3.200816e-07
I7299 n1_m1_228000_336000 0 2.541134e-07
I7300 n1_m1_228000_340800 0 3.098970e-07
I7301 n1_m1_228000_345600 0 4.177576e-07
I7302 n1_m1_228000_350400 0 3.762500e-07
I7303 n1_m1_228000_355200 0 2.505357e-07
I7304 n1_m1_228000_360000 0 5.713393e-07
I7305 n1_m1_228000_364800 0 7.004286e-07
I7306 n1_m1_228000_369600 0 5.432429e-07
I7307 n1_m1_228000_374400 0 9.494675e-08
I7308 n1_m1_228000_379200 0 1.839973e-07
I7309 n1_m1_228000_384000 0 6.449567e-07
I7310 n1_m1_228000_388800 0 3.809091e-07
I7311 n1_m1_228000_393600 0 2.670869e-07
I7312 n1_m1_228000_398400 0 8.245918e-08
I7313 n1_m1_256000_4800 0 1.346154e-07
I7314 n1_m1_256000_9600 0 3.279247e-07
I7315 n1_m1_256000_14400 0 2.784056e-07
I7316 n1_m1_256000_19200 0 1.662730e-07
I7317 n1_m1_256000_24000 0 1.766875e-07
I7318 n1_m1_256000_28800 0 2.604643e-06
I7319 n1_m1_256000_33600 0 3.235165e-06
I7320 n1_m1_256000_38400 0 2.706834e-07
I7321 n1_m1_256000_43200 0 1.182019e-07
I7322 n1_m1_256000_48000 0 3.118169e-07
I7323 n1_m1_256000_52800 0 7.302449e-07
I7324 n1_m1_256000_57600 0 5.156012e-07
I7325 n1_m1_256000_62400 0 1.974026e-07
I7326 n1_m1_256000_67200 0 5.853277e-07
I7327 n1_m1_256000_72000 0 5.561079e-07
I7328 n1_m1_256000_76800 0 1.881960e-07
I7329 n1_m1_256000_81600 0 3.186951e-07
I7330 n1_m1_256000_86400 0 1.295066e-07
I7331 n1_m1_256000_91200 0 2.295592e-07
I7332 n1_m1_256000_96000 0 1.936438e-07
I7333 n1_m1_256000_100800 0 1.880591e-07
I7334 n1_m1_256000_105600 0 1.673393e-07
I7335 n1_m1_256000_110400 0 1.076786e-07
I7336 n1_m1_256000_115200 0 3.885000e-07
I7337 n1_m1_256000_120000 0 8.236883e-07
I7338 n1_m1_256000_124800 0 3.850649e-07
I7339 n1_m1_256000_129600 0 2.573723e-07
I7340 n1_m1_256000_134400 0 3.577143e-08
I7341 n1_m1_256000_139200 0 1.944286e-07
I7342 n1_m1_256000_144000 0 2.962143e-07
I7343 n1_m1_256000_148800 0 2.303571e-08
I7344 n1_m1_256000_153600 0 8.995714e-08
I7345 n1_m1_256000_158400 0 3.114286e-08
I7346 n1_m1_256000_163200 0 1.924286e-07
I7347 n1_m1_256000_168000 0 8.205000e-08
I7348 n1_m1_256000_172800 0 4.257551e-08
I7349 n1_m1_256000_177600 0 3.528340e-07
I7350 n1_m1_256000_182400 0 4.342857e-08
I7351 n1_m1_256000_187200 0 1.753333e-07
I7352 n1_m1_256000_192000 0 4.843048e-07
I7353 n1_m1_256000_196800 0 8.370000e-08
I7354 n1_m1_256000_201600 0 2.643355e-06
I7355 n1_m1_256000_206400 0 2.035279e-06
I7356 n1_m1_256000_211200 0 4.421143e-08
I7357 n1_m1_256000_216000 0 4.720524e-07
I7358 n1_m1_256000_220800 0 2.167857e-07
I7359 n1_m1_256000_225600 0 1.523265e-07
I7360 n1_m1_256000_230400 0 1.911020e-07
I7361 n1_m1_256000_235200 0 4.285714e-08
I7362 n1_m1_256000_240000 0 1.246571e-07
I7363 n1_m1_256000_244800 0 2.294286e-07
I7364 n1_m1_256000_249600 0 3.444286e-07
I7365 n1_m1_256000_254400 0 1.787143e-08
I7366 n1_m1_256000_259200 0 1.897714e-07
I7367 n1_m1_256000_264000 0 1.913135e-07
I7368 n1_m1_256000_268800 0 9.028730e-08
I7369 n1_m1_256000_273600 0 2.327143e-07
I7370 n1_m1_256000_278400 0 1.028571e-07
I7371 n1_m1_256000_283200 0 2.438286e-07
I7372 n1_m1_256000_288000 0 8.974286e-08
I7373 n1_m1_256000_292800 0 8.952802e-07
I7374 n1_m1_256000_297600 0 8.993178e-07
I7375 n1_m1_256000_302400 0 3.512075e-07
I7376 n1_m1_256000_307200 0 2.254876e-07
I7377 n1_m1_256000_312000 0 1.742308e-07
I7378 n1_m1_256000_316800 0 1.129659e-07
I7379 n1_m1_256000_321600 0 2.016964e-07
I7380 n1_m1_256000_326400 0 1.855000e-07
I7381 n1_m1_256000_331200 0 1.265179e-07
I7382 n1_m1_256000_336000 0 6.273818e-07
I7383 n1_m1_256000_340800 0 4.793247e-07
I7384 n1_m1_256000_345600 0 3.220000e-07
I7385 n1_m1_256000_350400 0 1.171875e-07
I7386 n1_m1_256000_355200 0 3.723539e-07
I7387 n1_m1_256000_360000 0 5.748052e-07
I7388 n1_m1_256000_364800 0 1.613736e-07
I7389 n1_m1_256000_369600 0 3.782837e-07
I7390 n1_m1_256000_374400 0 6.096699e-07
I7391 n1_m1_256000_379200 0 1.622827e-06
I7392 n1_m1_256000_384000 0 2.183869e-06
I7393 n1_m1_256000_388800 0 3.035547e-07
I7394 n1_m1_256000_393600 0 1.884286e-07
I7395 n1_m1_256000_398400 0 8.914286e-08
I7396 n1_m1_284000_4800 0 2.566154e-07
I7397 n1_m1_284000_9600 0 9.907909e-07
I7398 n1_m1_284000_14400 0 2.083297e-07
I7399 n1_m1_284000_19200 0 2.324082e-07
I7400 n1_m1_284000_24000 0 4.411371e-07
I7401 n1_m1_284000_28800 0 4.292411e-07
I7402 n1_m1_284000_33600 0 8.799492e-07
I7403 n1_m1_284000_38400 0 1.635577e-06
I7404 n1_m1_284000_43200 0 5.175529e-07
I7405 n1_m1_284000_48000 0 9.401264e-07
I7406 n1_m1_284000_52800 0 1.358063e-07
I7407 n1_m1_284000_57600 0 1.290128e-06
I7408 n1_m1_284000_62400 0 4.119451e-07
I7409 n1_m1_284000_67200 0 6.770714e-07
I7410 n1_m1_284000_72000 0 4.425764e-07
I7411 n1_m1_284000_76800 0 7.000531e-07
I7412 n1_m1_284000_81600 0 7.040571e-07
I7413 n1_m1_284000_86400 0 1.194769e-07
I7414 n1_m1_284000_91200 0 3.933408e-07
I7415 n1_m1_284000_96000 0 5.879957e-07
I7416 n1_m1_284000_100800 0 6.976694e-07
I7417 n1_m1_284000_105600 0 2.392000e-07
I7418 n1_m1_284000_110400 0 3.181786e-07
I7419 n1_m1_284000_115200 0 3.441714e-07
I7420 n1_m1_284000_120000 0 5.381929e-07
I7421 n1_m1_284000_124800 0 2.671429e-07
I7422 n1_m1_284000_129600 0 4.405418e-07
I7423 n1_m1_284000_134400 0 6.272129e-07
I7424 n1_m1_284000_139200 0 1.314286e-07
I7425 n1_m1_284000_144000 0 2.495510e-07
I7426 n1_m1_284000_148800 0 1.953091e-07
I7427 n1_m1_284000_153600 0 4.345500e-07
I7428 n1_m1_284000_158400 0 2.287238e-07
I7429 n1_m1_284000_163200 0 1.808000e-07
I7430 n1_m1_284000_168000 0 5.826774e-07
I7431 n1_m1_284000_172800 0 4.859740e-07
I7432 n1_m1_284000_177600 0 7.440397e-07
I7433 n1_m1_284000_182400 0 8.322338e-07
I7434 n1_m1_284000_187200 0 7.948831e-07
I7435 n1_m1_284000_192000 0 5.990286e-07
I7436 n1_m1_284000_196800 0 1.827333e-07
I7437 n1_m1_284000_201600 0 7.644286e-07
I7438 n1_m1_284000_206400 0 2.165357e-07
I7439 n1_m1_284000_211200 0 2.972326e-07
I7440 n1_m1_284000_216000 0 5.613928e-07
I7441 n1_m1_284000_220800 0 5.563342e-07
I7442 n1_m1_284000_225600 0 1.117416e-06
I7443 n1_m1_284000_230400 0 5.560852e-07
I7444 n1_m1_284000_235200 0 5.505495e-08
I7445 n1_m1_284000_240000 0 2.011948e-07
I7446 n1_m1_284000_244800 0 3.355117e-07
I7447 n1_m1_284000_249600 0 6.895939e-07
I7448 n1_m1_284000_254400 0 1.830680e-07
I7449 n1_m1_284000_259200 0 4.500000e-08
I7450 n1_m1_284000_264000 0 4.134984e-07
I7451 n1_m1_284000_268800 0 1.477460e-07
I7452 n1_m1_284000_273600 0 7.710476e-07
I7453 n1_m1_284000_278400 0 3.892857e-07
I7454 n1_m1_284000_283200 0 3.759143e-07
I7455 n1_m1_284000_288000 0 7.997238e-07
I7456 n1_m1_284000_292800 0 3.595238e-07
I7457 n1_m1_284000_297600 0 6.149387e-07
I7458 n1_m1_284000_302400 0 2.684361e-07
I7459 n1_m1_284000_307200 0 1.683673e-07
I7460 n1_m1_284000_312000 0 1.072515e-06
I7461 n1_m1_284000_316800 0 4.861772e-07
I7462 n1_m1_284000_321600 0 1.266792e-06
I7463 n1_m1_284000_326400 0 5.847198e-07
I7464 n1_m1_284000_331200 0 6.074243e-07
I7465 n1_m1_284000_336000 0 7.267797e-07
I7466 n1_m1_284000_340800 0 3.688746e-07
I7467 n1_m1_284000_345600 0 4.703423e-07
I7468 n1_m1_284000_350400 0 5.762143e-07
I7469 n1_m1_284000_355200 0 2.354571e-07
I7470 n1_m1_284000_360000 0 8.911411e-07
I7471 n1_m1_284000_364800 0 6.600000e-08
I7472 n1_m1_284000_369600 0 5.186957e-07
I7473 n1_m1_284000_374400 0 6.249057e-06
I7474 n1_m1_284000_379200 0 9.728571e-08
I7475 n1_m1_284000_384000 0 8.477857e-07
I7476 n1_m1_284000_388800 0 3.245536e-07
I7477 n1_m1_284000_393600 0 9.197768e-07
I7478 n1_m1_284000_398400 0 1.362857e-07
I7479 n1_m1_340000_4800 0 2.104615e-07
I7480 n1_m1_340000_9600 0 7.569231e-08
I7481 n1_m1_340000_14400 0 3.138404e-07
I7482 n1_m1_340000_19200 0 8.592857e-08
I7483 n1_m1_340000_24000 0 5.000000e-07
I7484 n1_m1_340000_28800 0 2.600706e-07
I7485 n1_m1_340000_33600 0 2.054289e-07
I7486 n1_m1_340000_38400 0 4.289941e-08
I7487 n1_m1_340000_43200 0 2.269626e-07
I7488 n1_m1_340000_48000 0 1.724308e-07
I7489 n1_m1_340000_52800 0 1.037500e-07
I7490 n1_m1_340000_57600 0 3.206112e-07
I7491 n1_m1_340000_62400 0 6.021564e-07
I7492 n1_m1_340000_67200 0 1.787029e-07
I7493 n1_m1_340000_72000 0 1.545442e-07
I7494 n1_m1_340000_76800 0 3.883826e-07
I7495 n1_m1_340000_81600 0 8.736786e-07
I7496 n1_m1_340000_86400 0 1.411418e-07
I7497 n1_m1_340000_91200 0 3.504582e-07
I7498 n1_m1_340000_96000 0 2.804857e-07
I7499 n1_m1_340000_100800 0 3.470118e-07
I7500 n1_m1_340000_105600 0 5.066929e-07
I7501 n1_m1_340000_110400 0 3.662857e-07
I7502 n1_m1_340000_115200 0 2.983929e-07
I7503 n1_m1_340000_120000 0 3.149071e-07
I7504 n1_m1_340000_124800 0 1.603442e-07
I7505 n1_m1_340000_129600 0 4.273766e-07
I7506 n1_m1_340000_134400 0 3.552830e-07
I7507 n1_m1_340000_139200 0 5.286260e-07
I7508 n1_m1_340000_144000 0 4.580325e-07
I7509 n1_m1_340000_148800 0 3.448723e-07
I7510 n1_m1_340000_153600 0 3.218396e-07
I7511 n1_m1_340000_158400 0 3.172789e-07
I7512 n1_m1_340000_163200 0 3.470128e-07
I7513 n1_m1_340000_168000 0 3.730536e-07
I7514 n1_m1_340000_172800 0 2.891786e-07
I7515 n1_m1_340000_177600 0 1.284643e-07
I7516 n1_m1_340000_182400 0 3.006000e-07
I7517 n1_m1_340000_192000 0 4.752045e-07
I7518 n1_m1_340000_196800 0 3.210476e-07
I7519 n1_m1_340000_201600 0 4.075821e-07
I7520 n1_m1_340000_206400 0 2.348650e-07
I7521 n1_m1_340000_211200 0 3.917143e-07
I7522 n1_m1_340000_216000 0 4.688786e-07
I7523 n1_m1_340000_220800 0 3.877719e-07
I7524 n1_m1_340000_225600 0 1.326147e-07
I7525 n1_m1_340000_230400 0 3.165195e-07
I7526 n1_m1_340000_235200 0 2.387519e-07
I7527 n1_m1_340000_240000 0 3.640137e-07
I7528 n1_m1_340000_244800 0 2.045110e-07
I7529 n1_m1_340000_249600 0 4.770776e-07
I7530 n1_m1_340000_254400 0 3.867928e-07
I7531 n1_m1_340000_259200 0 1.532490e-07
I7532 n1_m1_340000_264000 0 5.281524e-07
I7533 n1_m1_340000_268800 0 3.815875e-07
I7534 n1_m1_340000_273600 0 4.144500e-07
I7535 n1_m1_340000_278400 0 4.288333e-07
I7536 n1_m1_340000_283200 0 3.726216e-07
I7537 n1_m1_340000_288000 0 1.889796e-07
I7538 n1_m1_340000_292800 0 1.991342e-07
I7539 n1_m1_340000_297600 0 3.959221e-07
I7540 n1_m1_340000_302400 0 4.067857e-08
I7541 n1_m1_340000_307200 0 1.673077e-07
I7542 n1_m1_340000_312000 0 1.014731e-07
I7543 n1_m1_340000_316800 0 1.490055e-07
I7544 n1_m1_340000_321600 0 2.505357e-07
I7545 n1_m1_340000_326400 0 1.912088e-08
I7546 n1_m1_340000_331200 0 2.507253e-08
I7547 n1_m1_340000_336000 0 2.559286e-07
I7548 n1_m1_340000_340800 0 1.091429e-07
I7549 n1_m1_340000_345600 0 2.543304e-07
I7550 n1_m1_340000_350400 0 2.666623e-07
I7551 n1_m1_340000_355200 0 3.710823e-07
I7552 n1_m1_340000_360000 0 1.459836e-07
I7553 n1_m1_340000_364800 0 1.764476e-07
I7554 n1_m1_340000_369600 0 5.157508e-07
I7555 n1_m1_340000_374400 0 3.553571e-07
I7556 n1_m1_340000_379200 0 3.663880e-07
I7557 n1_m1_340000_384000 0 2.202224e-07
I7558 n1_m1_340000_393600 0 1.007663e-07
I7559 n1_m1_340000_398400 0 6.525714e-08
I7560 n1_m1_368000_4800 0 2.446154e-07
I7561 n1_m1_368000_9600 0 2.701346e-07
I7562 n1_m1_368000_14400 0 3.675893e-07
I7563 n1_m1_368000_19200 0 1.952092e-07
I7564 n1_m1_368000_24000 0 6.612245e-09
I7565 n1_m1_368000_28800 0 5.749041e-08
I7566 n1_m1_368000_33600 0 1.663885e-07
I7567 n1_m1_368000_38400 0 3.432212e-07
I7568 n1_m1_368000_43200 0 8.461623e-08
I7569 n1_m1_368000_48000 0 4.558201e-07
I7570 n1_m1_368000_52800 0 3.564935e-07
I7571 n1_m1_368000_57600 0 1.843239e-07
I7572 n1_m1_368000_62400 0 2.707964e-07
I7573 n1_m1_368000_67200 0 1.470036e-07
I7574 n1_m1_368000_72000 0 4.051827e-07
I7575 n1_m1_368000_76800 0 2.512905e-07
I7576 n1_m1_368000_81600 0 4.375944e-07
I7577 n1_m1_368000_86400 0 3.663253e-07
I7578 n1_m1_368000_91200 0 1.980951e-07
I7579 n1_m1_368000_96000 0 3.541641e-07
I7580 n1_m1_368000_100800 0 2.928899e-07
I7581 n1_m1_368000_105600 0 5.097232e-07
I7582 n1_m1_368000_110400 0 1.597959e-07
I7583 n1_m1_368000_115200 0 1.108794e-07
I7584 n1_m1_368000_120000 0 4.613313e-07
I7585 n1_m1_368000_124800 0 1.035275e-07
I7586 n1_m1_368000_129600 0 3.298208e-07
I7587 n1_m1_368000_134400 0 2.930450e-07
I7588 n1_m1_368000_139200 0 8.219780e-08
I7589 n1_m1_368000_144000 0 4.866442e-07
I7590 n1_m1_368000_148800 0 2.480643e-07
I7591 n1_m1_368000_153600 0 3.990089e-07
I7592 n1_m1_368000_158400 0 2.562500e-07
I7593 n1_m1_368000_163200 0 1.114342e-07
I7594 n1_m1_368000_168000 0 1.801163e-07
I7595 n1_m1_368000_172800 0 2.610122e-07
I7596 n1_m1_368000_177600 0 3.303084e-07
I7597 n1_m1_368000_182400 0 3.753452e-07
I7598 n1_m1_368000_187200 0 3.648214e-07
I7599 n1_m1_368000_192000 0 2.415862e-07
I7600 n1_m1_368000_196800 0 5.601429e-08
I7601 n1_m1_368000_201600 0 3.497929e-07
I7602 n1_m1_368000_206400 0 2.396911e-07
I7603 n1_m1_368000_211200 0 1.460250e-07
I7604 n1_m1_368000_216000 0 3.597063e-07
I7605 n1_m1_368000_220800 0 1.520833e-07
I7606 n1_m1_368000_225600 0 2.755071e-07
I7607 n1_m1_368000_230400 0 1.168857e-07
I7608 n1_m1_368000_235200 0 9.547253e-08
I7609 n1_m1_368000_240000 0 3.509639e-07
I7610 n1_m1_368000_244800 0 2.492623e-07
I7611 n1_m1_368000_249600 0 4.655304e-07
I7612 n1_m1_368000_254400 0 2.842512e-07
I7613 n1_m1_368000_259200 0 2.143233e-07
I7614 n1_m1_368000_264000 0 3.126642e-07
I7615 n1_m1_368000_268800 0 2.854880e-07
I7616 n1_m1_368000_273600 0 5.025089e-07
I7617 n1_m1_368000_278400 0 2.708304e-07
I7618 n1_m1_368000_283200 0 1.846271e-07
I7619 n1_m1_368000_288000 0 1.762764e-07
I7620 n1_m1_368000_292800 0 1.540839e-07
I7621 n1_m1_368000_297600 0 3.317212e-07
I7622 n1_m1_368000_302400 0 1.416054e-07
I7623 n1_m1_368000_307200 0 2.178421e-07
I7624 n1_m1_368000_312000 0 1.666325e-07
I7625 n1_m1_368000_316800 0 3.363129e-07
I7626 n1_m1_368000_321600 0 1.867995e-06
I7627 n1_m1_368000_326400 0 6.971648e-08
I7628 n1_m1_368000_331200 0 1.417746e-07
I7629 n1_m1_368000_336000 0 1.735931e-07
I7630 n1_m1_368000_340800 0 7.897959e-08
I7631 n1_m1_368000_345600 0 3.768674e-07
I7632 n1_m1_368000_350400 0 1.353661e-07
I7633 n1_m1_368000_355200 0 3.555357e-07
I7634 n1_m1_368000_360000 0 1.012251e-07
I7635 n1_m1_368000_364800 0 5.497589e-07
I7636 n1_m1_368000_369600 0 5.273181e-07
I7637 n1_m1_368000_374400 0 9.734505e-08
I7638 n1_m1_368000_379200 0 1.752944e-07
I7639 n1_m1_368000_384000 0 2.476838e-07
I7640 n1_m1_368000_388800 0 2.753846e-07
I7641 n1_m1_368000_393600 0 1.177714e-07
I7642 n1_m1_396000_14400 0 3.526826e-07
I7643 n1_m1_396000_19200 0 2.184093e-07
I7644 n1_m1_396000_24000 0 3.813670e-07
I7645 n1_m1_396000_28800 0 2.626909e-07
I7646 n1_m1_396000_33600 0 3.360014e-07
I7647 n1_m1_396000_38400 0 3.378365e-07
I7648 n1_m1_396000_43200 0 9.513846e-08
I7649 n1_m1_396000_48000 0 3.005055e-07
I7650 n1_m1_396000_52800 0 3.645982e-07
I7651 n1_m1_396000_57600 0 1.248974e-07
I7652 n1_m1_396000_62400 0 3.973214e-07
I7653 n1_m1_396000_67200 0 3.535214e-07
I7654 n1_m1_396000_72000 0 3.722538e-07
I7655 n1_m1_396000_76800 0 2.318310e-07
I7656 n1_m1_396000_81600 0 1.633503e-07
I7657 n1_m1_396000_86400 0 2.994148e-07
I7658 n1_m1_396000_91200 0 2.353462e-07
I7659 n1_m1_396000_96000 0 2.766484e-07
I7660 n1_m1_396000_100800 0 2.293143e-07
I7661 n1_m1_396000_105600 0 3.078709e-07
I7662 n1_m1_396000_110400 0 2.366346e-07
I7663 n1_m1_396000_115200 0 3.261147e-07
I7664 n1_m1_396000_120000 0 2.170210e-07
I7665 n1_m1_396000_124800 0 3.566356e-07
I7666 n1_m1_396000_129600 0 3.926429e-07
I7667 n1_m1_396000_134400 0 3.018567e-07
I7668 n1_m1_396000_139200 0 1.298874e-07
I7669 n1_m1_396000_144000 0 4.988929e-07
I7670 n1_m1_396000_148800 0 1.221469e-07
I7671 n1_m1_396000_153600 0 4.299809e-07
I7672 n1_m1_396000_158400 0 1.839346e-07
I7673 n1_m1_396000_163200 0 1.485308e-07
I7674 n1_m1_396000_168000 0 3.957908e-07
I7675 n1_m1_396000_172800 0 1.472806e-07
I7676 n1_m1_396000_177600 0 4.985314e-07
I7677 n1_m1_396000_182400 0 1.230429e-07
I7678 n1_m1_396000_187200 0 2.610119e-07
I7679 n1_m1_396000_192000 0 4.541369e-07
I7680 n1_m1_396000_196800 0 1.125107e-07
I7681 n1_m1_396000_201600 0 4.598352e-07
I7682 n1_m1_396000_206400 0 1.636277e-07
I7683 n1_m1_396000_211200 0 2.057679e-07
I7684 n1_m1_396000_216000 0 5.427165e-07
I7685 n1_m1_396000_220800 0 1.740714e-07
I7686 n1_m1_396000_225600 0 3.265656e-07
I7687 n1_m1_396000_230400 0 1.153265e-07
I7688 n1_m1_396000_235200 0 2.872803e-07
I7689 n1_m1_396000_240000 0 3.280688e-07
I7690 n1_m1_396000_244800 0 1.049431e-07
I7691 n1_m1_396000_249600 0 1.268511e-06
I7692 n1_m1_396000_254400 0 6.714190e-07
I7693 n1_m1_396000_259200 0 2.352898e-07
I7694 n1_m1_396000_264000 0 3.439319e-07
I7695 n1_m1_396000_268800 0 3.781016e-07
I7696 n1_m1_396000_273600 0 3.436623e-07
I7697 n1_m1_396000_278400 0 1.992695e-07
I7698 n1_m1_396000_283200 0 3.213331e-07
I7699 n1_m1_396000_288000 0 1.642403e-07
I7700 n1_m1_396000_292800 0 1.770536e-07
I7701 n1_m1_396000_297600 0 8.525397e-07
I7702 n1_m1_396000_302400 0 8.270135e-07
I7703 n1_m1_396000_307200 0 3.440070e-07
I7704 n1_m1_396000_312000 0 2.054451e-07
I7705 n1_m1_396000_316800 0 2.096071e-07
I7706 n1_m1_396000_321600 0 4.641284e-07
I7707 n1_m1_396000_326400 0 1.245522e-07
I7708 n1_m1_396000_331200 0 3.302679e-07
I7709 n1_m1_396000_336000 0 2.695549e-07
I7710 n1_m1_396000_340800 0 2.723214e-07
I7711 n1_m1_396000_345600 0 3.446786e-07
I7712 n1_m1_396000_350400 0 1.836935e-07
I7713 n1_m1_396000_355200 0 3.634821e-07
I7714 n1_m1_396000_360000 0 1.396532e-07
I7715 n1_m1_396000_364800 0 3.504464e-07
I7716 n1_m1_396000_369600 0 2.271615e-07
I7717 n1_m1_396000_374400 0 3.117857e-08
.op
.end
